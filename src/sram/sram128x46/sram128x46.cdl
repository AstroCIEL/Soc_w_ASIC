+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_edger dbl dwl vddc_11 vnwc_12 vnwp_1 vpw_12 vssc wl[0] wl[1]
+  sram128x46cchs4wd_edgbl_dummy_ull
.ends sram128x46mem_l_test2row
****
.subckt sram128x46cchs4wd_edgbl_ull dbl dwl vddc vnwc vnwp vpw vssc wl[0]
+  wl[1]
** sram128x46cchs4wd_edgbl_ull: 12 flat devices **
mi0.mxn0 net11 wl[0] i0.ncored vpw nchpg_ullsr W=0.105U L=0.035U NF=1
mi0.mxn1 i0.ncored i0.core vssc vpw nchpd_ullsr W=0.14U L=0.035U NF=1
mi0.mxn2 i0.cored vddc vssc vpw nchpd_ullsr W=0.14U L=0.035U NF=1
mi0.mxn3 dbl dwl i0.cored vpw nchpg_ullsr W=0.105U L=0.035U NF=1
mi0.mxp0 vddc i0.core vddc vnwc pchpu_ullsr W=0.05U L=0.035U NF=1
mi0.mxp1 i0.core vddc vddc vnwc pchpu_ullsr W=0.05U L=0.035U NF=1
mi14.mxn0 net11 wl[1] i14.ncored vpw nchpg_ullsr W=0.105U L=0.035U NF=1
mi14.mxn1 i14.ncored i14.core vssc vpw nchpd_ullsr W=0.14U L=0.035U NF=1
mi14.mxn2 i14.cored vddc vssc vpw nchpd_ullsr W=0.14U L=0.035U NF=1
mi14.mxn3 dbl dwl i14.cored vpw nchpg_ullsr W=0.105U L=0.035U NF=1
mi14.mxp0 vddc i14.core vddc vnwc pchpu_ullsr W=0.05U L=0.035U NF=1
mi14.mxp1 i14.core vddc vddc vnwc pchpu_ullsr W=0.05U L=0.035U NF=1
.ends sram128x46cchs4wd_edgbl_ull
****
.subckt sram128x46mem_l_top_row vddc_11 vpw_12 vnwc_12 dbl dwl vddc_10 vnwc_11
+  bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10 bl[0]_9 nbl[0]_9 bl[1]_9 vddpe_9
+  vddce_9 vnwc_10 nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 nbl[0]_7
+  nbl[1]_7 vddpe_7 vpw_8 vddpe_6 vddce_6 vpw_7 bl[2]_6 nbl[2]_6 bl[0]_5
+  vddce_5 vddc_5 vnwc_6 vpw_6 nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4
+  vddpe_4 vddce_4 vnwc_5 nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe_3 vpw_4 nbl[0]_2
+  nbl[1]_2 vddpe_2 vddce_2 vnwc_3 vssc vpw_3 vddpe_1 vddce_1 vnwc_2 vpw_2
+  bl[2]_1 bl[3]_1 vddce_0 vddc_0 vnwc_1 vsse_0 vpw_1 bl[3]_0 vnwp_0 vnwp_1
+  bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vsse_1 vpw_11
+  nbl[1]_9 vddc_9 vpw_10 bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddce_8 vddc_8
+  vnwc_9 vpw_9 bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddce_7
+  vddc_7 vnwc_8 bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6
+  bl[1]_6 vddc_6 vnwc_7 nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe_5
+  bl[2]_5 bl[3]_5 nbl[1]_4 vddc_4 vpw_5 bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3
+  bl[1]_3 vddce_3 vddc_3 vnwc_4 bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2
+  bl[1]_2 vddc_2 bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1
+  bl[1]_1 vddc_1 nbl[2]_1 nbl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe_0
+  bl[2]_0 nbl[2]_0 nbl[3]_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_l_top_row: 540 flat devices **
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_3 nbl[1]_3 nbl[2]_3 nbl[3]_3 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_3
+  vddce_3 vddpe_3 vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_320 ncored01_322 ncored10_324
+  ncored11_326 ncored20_328 ncored21_330 ncored30_332 ncored31_334 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_edger dbl dwl vddc_11 vnwc_12 vnwp_1 vpw_12 vssc wl[0] wl[1]
+  sram128x46cchs4wd_edgbl_ull
xmem_l_col_top_l bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10
+  cored11 cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vsse_0 wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_l_col_top_r bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_16 cored01_18
+  cored10_20 cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_10
+  nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_32 ncored01_34 ncored10_36
+  ncored11_38 ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_10
+  vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vsse_1 wl[0] wl[1]
+  sram128x46cchs4_ull
.ends sram128x46mem_l_top_row
****
.subckt sram128x46mem_l_test3row vddc_11 vpw_12 vnwc_12 vddc_10 vnwc_11
+  bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10 bl[0]_9 nbl[0]_9 bl[1]_9 vddpe_9
+  vddce_9 vnwc_10 nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 nbl[0]_7
+  nbl[1]_7 vddpe_7 vpw_8 vddpe_6 vddce_6 vpw_7 bl[2]_6 nbl[2]_6 bl[0]_5
+  vddce_5 vddc_5 vnwc_6 vpw_6 nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4
+  vddpe_4 vddce_4 vnwc_5 nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe_3 vpw_4 nbl[0]_2
+  nbl[1]_2 vddpe_2 vddce_2 vnwc_3 vssc vpw_3 vddpe_1 vddce_1 vnwc_2 vpw_2
+  bl[2]_1 bl[3]_1 vddce_0 vddc_0 vnwc_1 vpw_1 bl[3]_0 vnwp_0 vnwp_1 dbl dwl
+  bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vpw_11 nbl[1]_9
+  vddc_9 vpw_10 bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddce_8 vddc_8 vnwc_9 vpw_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddce_7 vddc_7 vnwc_8
+  bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc_6
+  vnwc_7 nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe_5 bl[2]_5 bl[3]_5
+  nbl[1]_4 vddc_4 vpw_5 bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddce_3
+  vddc_3 vnwc_4 bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc_2
+  bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc_1
+  nbl[2]_1 nbl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe_0 bl[2]_0
+  nbl[2]_0 nbl[3]_0 vnwc_0 vpw_0 wl[0] wl[1]
** sram128x46mem_l_test3row: 540 flat devices **
xmem_l_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[1] wl[0]
+  sram128x46cchs4_ull
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[1] wl[0]
+  sram128x46cchs4_ull
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_edger dbl dwl vddc_11 vnwc_12 vnwp_1 vpw_12 vssc wl[0] wl[1]
+  sram128x46cchs4wd_edgbl_dummy_ull
.ends sram128x46mem_l_test3row
****
.subckt sram128x46mem_l_test4row vddc_11 vnwc_12 dbl dwl vddc_10 vnwc_11
+  bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10 bl[0]_9 nbl[0]_9 bl[1]_9 vddpe_9
+  vddce_9 vnwc_10 nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 nbl[0]_7
+  nbl[1]_7 vddpe_7 vpw_8 vddpe_6 vddce_6 vpw_7 bl[2]_6 nbl[2]_6 bl[0]_5
+  vddce_5 vddc_5 vnwc_6 vpw_6 nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4
+  vddpe_4 vddce_4 vnwc_5 nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe_3 vpw_4 nbl[0]_2
+  nbl[1]_2 vddpe_2 vddce_2 vnwc_3 vssc vpw_3 vddpe_1 vddce_1 vnwc_2 vpw_2
+  bl[2]_1 bl[3]_1 vddce_0 vddc_0 vnwc_1 vpw_1 bl[3]_0 vnwp_0 vpw_12 vnwp_1
+  bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vpw_11 nbl[1]_9
+  vddc_9 vpw_10 bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddce_8 vddc_8 vnwc_9 vpw_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddce_7 vddc_7 vnwc_8
+  bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc_6
+  vnwc_7 nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe_5 bl[2]_5 bl[3]_5
+  nbl[1]_4 vddc_4 vpw_5 bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddce_3
+  vddc_3 vnwc_4 bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc_2
+  bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc_1
+  nbl[2]_1 nbl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe_0 bl[2]_0
+  nbl[2]_0 nbl[3]_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_l_test4row: 540 flat devices **
xmem_l_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_edger dbl dwl vddc_11 vnwc_12 vnwp_1 vpw_12 vssc wl[0] wl[1]
+  sram128x46cchs4wd_edgbl_dummy_ull
.ends sram128x46mem_l_test4row
****
.subckt sram128x46mem_l_test5row vddc_11 vpw_12 vnwc_12 vddc_10 vnwc_11
+  bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10 bl[0]_9 nbl[0]_9 bl[1]_9 vddpe_9
+  vddce_9 vnwc_10 nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 nbl[0]_7
+  nbl[1]_7 vddpe_7 vpw_8 vddpe_6 vddce_6 vpw_7 bl[2]_6 nbl[2]_6 bl[0]_5
+  vddce_5 vddc_5 vnwc_6 vpw_6 nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4
+  vddpe_4 vddce_4 vnwc_5 nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe_3 vpw_4 nbl[0]_2
+  nbl[1]_2 vddpe_2 vddce_2 vnwc_3 vssc vpw_3 vddpe_1 vddce_1 vnwc_2 vpw_2
+  bl[2]_1 bl[3]_1 vddce_0 vddc_0 vnwc_1 vpw_1 bl[3]_0 vnwp_0 vnwp_1 dbl dwl
+  bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vpw_11 nbl[1]_9
+  vddc_9 vpw_10 bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddce_8 vddc_8 vnwc_9 vpw_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddce_7 vddc_7 vnwc_8
+  bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc_6
+  vnwc_7 nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe_5 bl[2]_5 bl[3]_5
+  nbl[1]_4 vddc_4 vpw_5 bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddce_3
+  vddc_3 vnwc_4 bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc_2
+  bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc_1
+  nbl[2]_1 nbl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe_0 bl[2]_0
+  nbl[2]_0 nbl[3]_0 vnwc_0 vpw_0 wl[0] wl[1]
** sram128x46mem_l_test5row: 540 flat devices **
xmem_l_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[1] wl[0]
+  sram128x46cchs4_ull
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[1] wl[0]
+  sram128x46cchs4_ull
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_edger dbl dwl vddc_11 vnwc_12 vnwp_1 vpw_12 vssc wl[0] wl[1]
+  sram128x46cchs4wd_edgbl_dummy_ull
.ends sram128x46mem_l_test5row
****
.subckt sram128x46mem_l_test6row vddc_11 vnwc_12 dbl dwl vddc_10 vnwc_11
+  bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10 bl[0]_9 nbl[0]_9 bl[1]_9 vddpe_9
+  vddce_9 vnwc_10 nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 nbl[0]_7
+  nbl[1]_7 vddpe_7 vpw_8 vddpe_6 vddce_6 vpw_7 bl[2]_6 nbl[2]_6 bl[0]_5
+  vddce_5 vddc_5 vnwc_6 vpw_6 nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4
+  vddpe_4 vddce_4 vnwc_5 nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe_3 vpw_4 nbl[0]_2
+  nbl[1]_2 vddpe_2 vddce_2 vnwc_3 vssc vpw_3 vddpe_1 vddce_1 vnwc_2 vpw_2
+  bl[2]_1 bl[3]_1 vddce_0 vddc_0 vnwc_1 vpw_1 bl[3]_0 vnwp_0 vpw_12 vnwp_1
+  bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vpw_11 nbl[1]_9
+  vddc_9 vpw_10 bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddce_8 vddc_8 vnwc_9 vpw_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddce_7 vddc_7 vnwc_8
+  bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc_6
+  vnwc_7 nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe_5 bl[2]_5 bl[3]_5
+  nbl[1]_4 vddc_4 vpw_5 bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddce_3
+  vddc_3 vnwc_4 bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc_2
+  bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc_1
+  nbl[2]_1 nbl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe_0 bl[2]_0
+  nbl[2]_0 nbl[3]_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_l_test6row: 540 flat devices **
xmem_l_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_edger dbl dwl vddc_11 vnwc_12 vnwp_1 vpw_12 vssc wl[0] wl[1]
+  sram128x46cchs4wd_edgbl_dummy_ull
.ends sram128x46mem_l_test6row
****
.subckt sram128x46mem_l_test7row vddc_11 vpw_12 vnwc_12 vddc_10 vnwc_11
+  bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10 bl[0]_9 nbl[0]_9 bl[1]_9 vddpe_9
+  vddce_9 vnwc_10 nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 nbl[0]_7
+  nbl[1]_7 vddpe_7 vpw_8 vddpe_6 vddce_6 vpw_7 bl[2]_6 nbl[2]_6 bl[0]_5
+  vddce_5 vddc_5 vnwc_6 vpw_6 nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4
+  vddpe_4 vddce_4 vnwc_5 nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe_3 vpw_4 nbl[0]_2
+  nbl[1]_2 vddpe_2 vddce_2 vnwc_3 vssc vpw_3 vddpe_1 vddce_1 vnwc_2 vpw_2
+  bl[2]_1 bl[3]_1 vddce_0 vddc_0 vnwc_1 vpw_1 bl[3]_0 vnwp_0 vnwp_1 dbl dwl
+  bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vpw_11 nbl[1]_9
+  vddc_9 vpw_10 bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddce_8 vddc_8 vnwc_9 vpw_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddce_7 vddc_7 vnwc_8
+  bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc_6
+  vnwc_7 nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe_5 bl[2]_5 bl[3]_5
+  nbl[1]_4 vddc_4 vpw_5 bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddce_3
+  vddc_3 vnwc_4 bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc_2
+  bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc_1
+  nbl[2]_1 nbl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe_0 bl[2]_0
+  nbl[2]_0 nbl[3]_0 vnwc_0 vpw_0 wl[0] wl[1]
** sram128x46mem_l_test7row: 540 flat devices **
xmem_l_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[1] wl[0]
+  sram128x46cchs4_ull
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[1] wl[0]
+  sram128x46cchs4_ull
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_edger dbl dwl vddc_11 vnwc_12 vnwp_1 vpw_12 vssc wl[0] wl[1]
+  sram128x46cchs4wd_edgbl_dummy_ull
.ends sram128x46mem_l_test7row
****
.subckt sram128x46mem_l_test8row vddc_11 vnwc_12 dbl dwl vddc_10 vnwc_11
+  bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10 bl[0]_9 nbl[0]_9 bl[1]_9 vddpe_9
+  vddce_9 vnwc_10 nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 nbl[0]_7
+  nbl[1]_7 vddpe_7 vpw_8 vddpe_6 vddce_6 vpw_7 bl[2]_6 nbl[2]_6 bl[0]_5
+  vddce_5 vddc_5 vnwc_6 vpw_6 nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4
+  vddpe_4 vddce_4 vnwc_5 nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe_3 vpw_4 nbl[0]_2
+  nbl[1]_2 vddpe_2 vddce_2 vnwc_3 vssc vpw_3 vddpe_1 vddce_1 vnwc_2 vpw_2
+  bl[2]_1 bl[3]_1 vddce_0 vddc_0 vnwc_1 vpw_1 bl[3]_0 vnwp_0 vpw_12 vnwp_1
+  bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vpw_11 nbl[1]_9
+  vddc_9 vpw_10 bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddce_8 vddc_8 vnwc_9 vpw_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddce_7 vddc_7 vnwc_8
+  bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc_6
+  vnwc_7 nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe_5 bl[2]_5 bl[3]_5
+  nbl[1]_4 vddc_4 vpw_5 bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddce_3
+  vddc_3 vnwc_4 bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc_2
+  bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc_1
+  nbl[2]_1 nbl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe_0 bl[2]_0
+  nbl[2]_0 nbl[3]_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_l_test8row: 540 flat devices **
xmem_l_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_edger dbl dwl vddc_11 vnwc_12 vnwp_1 vpw_12 vssc wl[0] wl[1]
+  sram128x46cchs4wd_edgbl_dummy_ull
.ends sram128x46mem_l_test8row
****
.subckt sram128x46mem_l_test9row vddc_11 vpw_12 vnwc_12 vddc_10 vnwc_11
+  bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10 bl[0]_9 nbl[0]_9 bl[1]_9 vddpe_9
+  vddce_9 vnwc_10 nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 nbl[0]_7
+  nbl[1]_7 vddpe_7 vpw_8 vddpe_6 vddce_6 vpw_7 bl[2]_6 nbl[2]_6 bl[0]_5
+  vddce_5 vddc_5 vnwc_6 vpw_6 nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4
+  vddpe_4 vddce_4 vnwc_5 nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe_3 vpw_4 nbl[0]_2
+  nbl[1]_2 vddpe_2 vddce_2 vnwc_3 vssc vpw_3 vddpe_1 vddce_1 vnwc_2 vpw_2
+  bl[2]_1 bl[3]_1 vddce_0 vddc_0 vnwc_1 vpw_1 bl[3]_0 vnwp_0 vnwp_1 dbl dwl
+  bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vpw_11 nbl[1]_9
+  vddc_9 vpw_10 bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddce_8 vddc_8 vnwc_9 vpw_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddce_7 vddc_7 vnwc_8
+  bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc_6
+  vnwc_7 nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe_5 bl[2]_5 bl[3]_5
+  nbl[1]_4 vddc_4 vpw_5 bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddce_3
+  vddc_3 vnwc_4 bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc_2
+  bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc_1
+  nbl[2]_1 nbl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe_0 bl[2]_0
+  nbl[2]_0 nbl[3]_0 vnwc_0 vpw_0 wl[0] wl[1]
** sram128x46mem_l_test9row: 540 flat devices **
xmem_l_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[1] wl[0]
+  sram128x46cchs4_ull
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[1] wl[0]
+  sram128x46cchs4_ull
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_edger dbl dwl vddc_11 vnwc_12 vnwp_1 vpw_12 vssc wl[0] wl[1]
+  sram128x46cchs4wd_edgbl_dummy_ull
.ends sram128x46mem_l_test9row
****
.subckt sram128x46mem_l_midb_row vddc_11 vnwc_12 dbl dwl vddc_10 vnwc_11
+  bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10 bl[0]_9 nbl[0]_9 bl[1]_9 vddpe_9
+  vddce_9 vnwc_10 nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 nbl[0]_7
+  nbl[1]_7 vddpe_7 vpw_8 vddpe_6 vddce_6 vpw_7 bl[2]_6 nbl[2]_6 bl[0]_5
+  vddce_5 vddc_5 vnwc_6 vpw_6 nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4
+  vddpe_4 vddce_4 vnwc_5 nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe_3 vpw_4 nbl[0]_2
+  nbl[1]_2 vddpe_2 vddce_2 vnwc_3 vssc vpw_3 vddpe_1 vddce_1 vnwc_2 vpw_2
+  bl[2]_1 bl[3]_1 vddce_0 vddc_0 vnwc_1 vpw_1 bl[3]_0 vnwp_0 vpw_12 vnwp_1
+  bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vpw_11 nbl[1]_9
+  vddc_9 vpw_10 bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddce_8 vddc_8 vnwc_9 vpw_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddce_7 vddc_7 vnwc_8
+  bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc_6
+  vnwc_7 nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe_5 bl[2]_5 bl[3]_5
+  nbl[1]_4 vddc_4 vpw_5 bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddce_3
+  vddc_3 vnwc_4 bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc_2
+  bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc_1
+  nbl[2]_1 nbl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe_0 bl[2]_0
+  nbl[2]_0 nbl[3]_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_l_midb_row: 540 flat devices **
xmem_l_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_edger dbl dwl vddc_11 vnwc_12 vnwp_1 vpw_12 vssc wl[0] wl[1]
+  sram128x46cchs4wd_edgbl_dummy_ull
.ends sram128x46mem_l_midb_row
****
.subckt sram128x46memcore_l vnwp_1 bl[1]_10 nbl[2]_10 bl[3]_10 bl[1]_9
+  nbl[3]_9 bl[0]_8 bl[2]_8 nbl[2]_8 bl[0]_7 bl[1]_7 bl[2]_7 nbl[2]_7 nbl[3]_7
+  bl[3]_7 bl[0]_6 nbl[1]_6 bl[1]_6 nbl[2]_6 nbl[3]_6 bl[3]_6 bl[0]_5 bl[1]_5
+  vnwc nbl[2]_5 nbl[3]_5 nbl[1]_4 bl[1]_4 bl[2]_4 nbl[3]_4 nbl[0]_3 nbl[1]_3
+  bl[2]_3 bl[3]_3 bl[2]_2 nbl[2]_2 bl[3]_2 bl[0]_1 bl[1]_1 nbl[2]_1 nbl[3]_1
+  bl[0]_0 nbl[0]_0 bl[1]_0 nbl[2]_0 nbl[3]_0 dbl dwl bl[0]_10 nbl[0]_10
+  nbl[1]_10 vpw bl[2]_10 nbl[3]_10 bl[0]_9 nbl[0]_9 nbl[1]_9 vssc bl[2]_9
+  nbl[2]_9 bl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8 nbl[3]_8 bl[3]_8 nbl[0]_7
+  nbl[1]_7 nbl[0]_6 vddc bl[2]_6 nbl[0]_5 nbl[1]_5 bl[2]_5 bl[3]_5 bl[0]_4
+  nbl[0]_4 vddpe nbl[2]_4 bl[3]_4 bl[0]_3 bl[1]_3 nbl[2]_3 nbl[3]_3 bl[0]_2
+  nbl[0]_2 nbl[1]_2 bl[1]_2 nbl[3]_2 nbl[0]_1 nbl[1]_1 bl[2]_1 bl[3]_1
+  nbl[1]_0 bl[2]_0 bl[3]_0 vnwp_0 wl[1]_31 wl[0]_31 wl[0]_30 wl[1]_30
+  wl[0]_29 wl[1]_29 wl[1]_28 wl[0]_28 wl[0]_27 wl[1]_27 wl[1]_26 wl[0]_26
+  wl[0]_25 wl[1]_25 wl[1]_24 wl[0]_24 wl[0]_23 wl[1]_23 wl[1]_22 wl[0]_22
+  wl[0]_21 wl[1]_21 wl[1]_20 wl[0]_20 wl[0]_19 wl[1]_19 wl[1]_18 wl[0]_18
+  wl[0]_17 wl[1]_17 wl[1]_16 wl[0]_16 wl[0]_15 wl[1]_15 wl[1]_14 wl[0]_14
+  wl[0]_13 wl[1]_13 wl[1]_12 wl[0]_12 wl[0]_11 wl[1]_11 wl[1]_10 wl[0]_10
+  wl[0]_9 wl[1]_9 wl[1]_8 wl[0]_8 wl[0]_7 wl[1]_7 wl[1]_6 wl[0]_6 wl[0]_5
+  wl[1]_5 wl[1]_4 wl[0]_4 wl[0]_3 wl[1]_3 wl[1]_2 wl[0]_2 wl[0]_1 wl[1]_1
+  wl[1]_0 wl[0]_0 actp vss
** sram128x46memcore_l: 17280 flat devices **
xmem_l_row_1 vddc vpw vnwc vddc vnwc bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10
+  bl[0]_9 nbl[0]_9 bl[1]_9 vddpe vddc vnwc nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8
+  vddpe nbl[0]_7 nbl[1]_7 vddpe vpw vddpe vddc vpw bl[2]_6 nbl[2]_6 bl[0]_5
+  vddc vddc vnwc vpw nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4 vddpe vddc
+  vnwc nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe vpw nbl[0]_2 nbl[1]_2 vddpe vddc vnwc
+  vssc vpw vddpe vddc vnwc vpw bl[2]_1 bl[3]_1 vddc vddc vnwc vpw bl[3]_0
+  vnwp_0 vnwp_1 dbl dwl bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe vddc vpw
+  nbl[1]_9 vddc vpw bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddc vddc vnwc vpw
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddc vddc vnwc bl[2]_7
+  nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc vnwc
+  nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe bl[2]_5 bl[3]_5 nbl[1]_4
+  vddc vpw bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddc vddc vnwc bl[2]_3
+  nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc bl[2]_2 nbl[2]_2 nbl[3]_2
+  bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc nbl[2]_1 nbl[3]_1 bl[0]_0
+  nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe bl[2]_0 nbl[2]_0 nbl[3]_0 vnwc vpw wl[0]_1
+  wl[1]_1 sram128x46mem_l_test1row
xmem_l_row_10 vddc vnwc dbl dwl vddc vnwc bl[2]_10 nbl[2]_10 nbl[3]_10
+  bl[3]_10 bl[0]_9 nbl[0]_9 bl[1]_9 vddpe vddc vnwc nbl[3]_9 nbl[0]_8
+  nbl[1]_8 bl[1]_8 vddpe nbl[0]_7 nbl[1]_7 vddpe vpw vddpe vddc vpw bl[2]_6
+  nbl[2]_6 bl[0]_5 vddc vddc vnwc vpw nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4
+  bl[1]_4 vddpe vddc vnwc nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe vpw nbl[0]_2
+  nbl[1]_2 vddpe vddc vnwc vssc vpw vddpe vddc vnwc vpw bl[2]_1 bl[3]_1 vddc
+  vddc vnwc vpw bl[3]_0 vnwp_0 vpw vnwp_1 bl[0]_10 nbl[0]_10 nbl[1]_10
+  bl[1]_10 vddpe vddc vpw nbl[1]_9 vddc vpw bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8
+  vddc vddc vnwc vpw bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddc
+  vddc vnwc bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6
+  bl[1]_6 vddc vnwc nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe bl[2]_5
+  bl[3]_5 nbl[1]_4 vddc vpw bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddc
+  vddc vnwc bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc bl[2]_2
+  nbl[2]_2 nbl[3]_2 bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc nbl[2]_1
+  nbl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe bl[2]_0 nbl[2]_0 nbl[3]_0
+  vnwc vpw wl[1]_10 wl[0]_10 sram128x46mem_l_test10row
xmem_l_row_11 vddc vpw vnwc vddc vnwc bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10
+  bl[0]_9 nbl[0]_9 bl[1]_9 vddpe vddc vnwc nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8
+  vddpe nbl[0]_7 nbl[1]_7 vddpe vpw vddpe vddc vpw bl[2]_6 nbl[2]_6 bl[0]_5
+  vddc vddc vnwc vpw nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4 vddpe vddc
+  vnwc nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe vpw nbl[0]_2 nbl[1]_2 vddpe vddc vnwc
+  vssc vpw vddpe vddc vnwc vpw bl[2]_1 bl[3]_1 vddc vddc vnwc vpw bl[3]_0
+  vnwp_0 vnwp_1 dbl dwl bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe vddc vpw
+  nbl[1]_9 vddc vpw bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddc vddc vnwc vpw
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddc vddc vnwc bl[2]_7
+  nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc vnwc
+  nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe bl[2]_5 bl[3]_5 nbl[1]_4
+  vddc vpw bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddc vddc vnwc bl[2]_3
+  nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc bl[2]_2 nbl[2]_2 nbl[3]_2
+  bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc nbl[2]_1 nbl[3]_1 bl[0]_0
+  nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe bl[2]_0 nbl[2]_0 nbl[3]_0 vnwc vpw wl[0]_11
+  wl[1]_11 sram128x46mem_l_test11row
xmem_l_row_12 vddc vnwc dbl dwl vddc vnwc bl[2]_10 nbl[2]_10 nbl[3]_10
+  bl[3]_10 bl[0]_9 nbl[0]_9 bl[1]_9 vddpe vddc vnwc nbl[3]_9 nbl[0]_8
+  nbl[1]_8 bl[1]_8 vddpe nbl[0]_7 nbl[1]_7 vddpe vpw vddpe vddc vpw bl[2]_6
+  nbl[2]_6 bl[0]_5 vddc vddc vnwc vpw nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4
+  bl[1]_4 vddpe vddc vnwc nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe vpw nbl[0]_2
+  nbl[1]_2 vddpe vddc vnwc vssc vpw vddpe vddc vnwc vpw bl[2]_1 bl[3]_1 vddc
+  vddc vnwc vpw bl[3]_0 vnwp_0 vpw vnwp_1 bl[0]_10 nbl[0]_10 nbl[1]_10
+  bl[1]_10 vddpe vddc vpw nbl[1]_9 vddc vpw bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8
+  vddc vddc vnwc vpw bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddc
+  vddc vnwc bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6
+  bl[1]_6 vddc vnwc nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe bl[2]_5
+  bl[3]_5 nbl[1]_4 vddc vpw bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddc
+  vddc vnwc bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc bl[2]_2
+  nbl[2]_2 nbl[3]_2 bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc nbl[2]_1
+  nbl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe bl[2]_0 nbl[2]_0 nbl[3]_0
+  vnwc vpw wl[1]_12 wl[0]_12 sram128x46mem_l_test12row
xmem_l_row_13 vddc vpw vnwc vddc vnwc bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10
+  bl[0]_9 nbl[0]_9 bl[1]_9 vddpe vddc vnwc nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8
+  vddpe nbl[0]_7 nbl[1]_7 vddpe vpw vddpe vddc vpw bl[2]_6 nbl[2]_6 bl[0]_5
+  vddc vddc vnwc vpw nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4 vddpe vddc
+  vnwc nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe vpw nbl[0]_2 nbl[1]_2 vddpe vddc vnwc
+  vssc vpw vddpe vddc vnwc vpw bl[2]_1 bl[3]_1 vddc vddc vnwc vpw bl[3]_0
+  vnwp_0 vnwp_1 dbl dwl bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe vddc vpw
+  nbl[1]_9 vddc vpw bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddc vddc vnwc vpw
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddc vddc vnwc bl[2]_7
+  nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc vnwc
+  nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe bl[2]_5 bl[3]_5 nbl[1]_4
+  vddc vpw bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddc vddc vnwc bl[2]_3
+  nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc bl[2]_2 nbl[2]_2 nbl[3]_2
+  bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc nbl[2]_1 nbl[3]_1 bl[0]_0
+  nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe bl[2]_0 nbl[2]_0 nbl[3]_0 vnwc vpw wl[0]_13
+  wl[1]_13 sram128x46mem_l_test13row
xmem_l_row_17 vddc vpw vnwc vddc vnwc bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10
+  bl[0]_9 nbl[0]_9 bl[1]_9 vddpe vddc vnwc nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8
+  vddpe nbl[0]_7 nbl[1]_7 vddpe vpw vddpe vddc vpw bl[2]_6 nbl[2]_6 bl[0]_5
+  vddc vddc vnwc vpw nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4 vddpe vddc
+  vnwc nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe vpw nbl[0]_2 nbl[1]_2 vddpe vddc vnwc
+  vssc vpw vddpe vddc vnwc vpw bl[2]_1 bl[3]_1 vddc vddc vnwc vpw bl[3]_0
+  vnwp_0 vnwp_1 dbl dwl bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe vddc vpw
+  nbl[1]_9 vddc vpw bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddc vddc vnwc vpw
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddc vddc vnwc bl[2]_7
+  nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc vnwc
+  nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe bl[2]_5 bl[3]_5 nbl[1]_4
+  vddc vpw bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddc vddc vnwc bl[2]_3
+  nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc bl[2]_2 nbl[2]_2 nbl[3]_2
+  bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc nbl[2]_1 nbl[3]_1 bl[0]_0
+  nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe bl[2]_0 nbl[2]_0 nbl[3]_0 vnwc vpw wl[0]_17
+  wl[1]_17 sram128x46mem_l_test17row
xmem_l_row_18 vddc vnwc dbl dwl vddc vnwc bl[2]_10 nbl[2]_10 nbl[3]_10
+  bl[3]_10 bl[0]_9 nbl[0]_9 bl[1]_9 vddpe vddc vnwc nbl[3]_9 nbl[0]_8
+  nbl[1]_8 bl[1]_8 vddpe nbl[0]_7 nbl[1]_7 vddpe vpw vddpe vddc vpw bl[2]_6
+  nbl[2]_6 bl[0]_5 vddc vddc vnwc vpw nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4
+  bl[1]_4 vddpe vddc vnwc nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe vpw nbl[0]_2
+  nbl[1]_2 vddpe vddc vnwc vssc vpw vddpe vddc vnwc vpw bl[2]_1 bl[3]_1 vddc
+  vddc vnwc vpw bl[3]_0 vnwp_0 vpw vnwp_1 bl[0]_10 nbl[0]_10 nbl[1]_10
+  bl[1]_10 vddpe vddc vpw nbl[1]_9 vddc vpw bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8
+  vddc vddc vnwc vpw bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddc
+  vddc vnwc bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6
+  bl[1]_6 vddc vnwc nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe bl[2]_5
+  bl[3]_5 nbl[1]_4 vddc vpw bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddc
+  vddc vnwc bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc bl[2]_2
+  nbl[2]_2 nbl[3]_2 bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc nbl[2]_1
+  nbl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe bl[2]_0 nbl[2]_0 nbl[3]_0
+  vnwc vpw wl[1]_18 wl[0]_18 sram128x46mem_l_test18row
xmem_l_row_19 vddc vpw vnwc vddc vnwc bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10
+  bl[0]_9 nbl[0]_9 bl[1]_9 vddpe vddc vnwc nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8
+  vddpe nbl[0]_7 nbl[1]_7 vddpe vpw vddpe vddc vpw bl[2]_6 nbl[2]_6 bl[0]_5
+  vddc vddc vnwc vpw nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4 vddpe vddc
+  vnwc nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe vpw nbl[0]_2 nbl[1]_2 vddpe vddc vnwc
+  vssc vpw vddpe vddc vnwc vpw bl[2]_1 bl[3]_1 vddc vddc vnwc vpw bl[3]_0
+  vnwp_0 vnwp_1 dbl dwl bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe vddc vpw
+  nbl[1]_9 vddc vpw bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddc vddc vnwc vpw
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddc vddc vnwc bl[2]_7
+  nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc vnwc
+  nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe bl[2]_5 bl[3]_5 nbl[1]_4
+  vddc vpw bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddc vddc vnwc bl[2]_3
+  nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc bl[2]_2 nbl[2]_2 nbl[3]_2
+  bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc nbl[2]_1 nbl[3]_1 bl[0]_0
+  nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe bl[2]_0 nbl[2]_0 nbl[3]_0 vnwc vpw wl[0]_19
+  wl[1]_19 sram128x46mem_l_test19row
xmem_l_row_2 vddc vnwc dbl dwl vddc vnwc bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10
+  bl[0]_9 nbl[0]_9 bl[1]_9 vddpe vddc vnwc nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8
+  vddpe nbl[0]_7 nbl[1]_7 vddpe vpw vddpe vddc vpw bl[2]_6 nbl[2]_6 bl[0]_5
+  vddc vddc vnwc vpw nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4 vddpe vddc
+  vnwc nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe vpw nbl[0]_2 nbl[1]_2 vddpe vddc vnwc
+  vssc vpw vddpe vddc vnwc vpw bl[2]_1 bl[3]_1 vddc vddc vnwc vpw bl[3]_0
+  vnwp_0 vpw vnwp_1 bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe vddc vpw
+  nbl[1]_9 vddc vpw bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddc vddc vnwc vpw
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddc vddc vnwc bl[2]_7
+  nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc vnwc
+  nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe bl[2]_5 bl[3]_5 nbl[1]_4
+  vddc vpw bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddc vddc vnwc bl[2]_3
+  nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc bl[2]_2 nbl[2]_2 nbl[3]_2
+  bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc nbl[2]_1 nbl[3]_1 bl[0]_0
+  nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe bl[2]_0 nbl[2]_0 nbl[3]_0 vnwc vpw wl[1]_2
+  wl[0]_2 sram128x46mem_l_test2row
xmem_l_row_20 vddc vnwc dbl dwl vddc vnwc bl[2]_10 nbl[2]_10 nbl[3]_10
+  bl[3]_10 bl[0]_9 nbl[0]_9 bl[1]_9 vddpe vddc vnwc nbl[3]_9 nbl[0]_8
+  nbl[1]_8 bl[1]_8 vddpe nbl[0]_7 nbl[1]_7 vddpe vpw vddpe vddc vpw bl[2]_6
+  nbl[2]_6 bl[0]_5 vddc vddc vnwc vpw nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4
+  bl[1]_4 vddpe vddc vnwc nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe vpw nbl[0]_2
+  nbl[1]_2 vddpe vddc vnwc vssc vpw vddpe vddc vnwc vpw bl[2]_1 bl[3]_1 vddc
+  vddc vnwc vpw bl[3]_0 vnwp_0 vpw vnwp_1 bl[0]_10 nbl[0]_10 nbl[1]_10
+  bl[1]_10 vddpe vddc vpw nbl[1]_9 vddc vpw bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8
+  vddc vddc vnwc vpw bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddc
+  vddc vnwc bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6
+  bl[1]_6 vddc vnwc nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe bl[2]_5
+  bl[3]_5 nbl[1]_4 vddc vpw bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddc
+  vddc vnwc bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc bl[2]_2
+  nbl[2]_2 nbl[3]_2 bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc nbl[2]_1
+  nbl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe bl[2]_0 nbl[2]_0 nbl[3]_0
+  vnwc vpw wl[1]_20 wl[0]_20 sram128x46mem_l_test20row
xmem_l_row_21 vddc vpw vnwc vddc vnwc bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10
+  bl[0]_9 nbl[0]_9 bl[1]_9 vddpe vddc vnwc nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8
+  vddpe nbl[0]_7 nbl[1]_7 vddpe vpw vddpe vddc vpw bl[2]_6 nbl[2]_6 bl[0]_5
+  vddc vddc vnwc vpw nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4 vddpe vddc
+  vnwc nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe vpw nbl[0]_2 nbl[1]_2 vddpe vddc vnwc
+  vssc vpw vddpe vddc vnwc vpw bl[2]_1 bl[3]_1 vddc vddc vnwc vpw bl[3]_0
+  vnwp_0 vnwp_1 dbl dwl bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe vddc vpw
+  nbl[1]_9 vddc vpw bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddc vddc vnwc vpw
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddc vddc vnwc bl[2]_7
+  nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc vnwc
+  nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe bl[2]_5 bl[3]_5 nbl[1]_4
+  vddc vpw bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddc vddc vnwc bl[2]_3
+  nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc bl[2]_2 nbl[2]_2 nbl[3]_2
+  bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc nbl[2]_1 nbl[3]_1 bl[0]_0
+  nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe bl[2]_0 nbl[2]_0 nbl[3]_0 vnwc vpw wl[0]_21
+  wl[1]_21 sram128x46mem_l_test21row
xmem_l_row_22 vddc vnwc dbl dwl vddc vnwc bl[2]_10 nbl[2]_10 nbl[3]_10
+  bl[3]_10 bl[0]_9 nbl[0]_9 bl[1]_9 vddpe vddc vnwc nbl[3]_9 nbl[0]_8
+  nbl[1]_8 bl[1]_8 vddpe nbl[0]_7 nbl[1]_7 vddpe vpw vddpe vddc vpw bl[2]_6
+  nbl[2]_6 bl[0]_5 vddc vddc vnwc vpw nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4
+  bl[1]_4 vddpe vddc vnwc nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe vpw nbl[0]_2
+  nbl[1]_2 vddpe vddc vnwc vssc vpw vddpe vddc vnwc vpw bl[2]_1 bl[3]_1 vddc
+  vddc vnwc vpw bl[3]_0 vnwp_0 vpw vnwp_1 bl[0]_10 nbl[0]_10 nbl[1]_10
+  bl[1]_10 vddpe vddc vpw nbl[1]_9 vddc vpw bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8
+  vddc vddc vnwc vpw bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddc
+  vddc vnwc bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6
+  bl[1]_6 vddc vnwc nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe bl[2]_5
+  bl[3]_5 nbl[1]_4 vddc vpw bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddc
+  vddc vnwc bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc bl[2]_2
+  nbl[2]_2 nbl[3]_2 bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc nbl[2]_1
+  nbl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe bl[2]_0 nbl[2]_0 nbl[3]_0
+  vnwc vpw wl[1]_22 wl[0]_22 sram128x46mem_l_test22row
xmem_l_row_23 vddc vpw vnwc vddc vnwc bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10
+  bl[0]_9 nbl[0]_9 bl[1]_9 vddpe vddc vnwc nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8
+  vddpe nbl[0]_7 nbl[1]_7 vddpe vpw vddpe vddc vpw bl[2]_6 nbl[2]_6 bl[0]_5
+  vddc vddc vnwc vpw nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4 vddpe vddc
+  vnwc nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe vpw nbl[0]_2 nbl[1]_2 vddpe vddc vnwc
+  vssc vpw vddpe vddc vnwc vpw bl[2]_1 bl[3]_1 vddc vddc vnwc vpw bl[3]_0
+  vnwp_0 vnwp_1 dbl dwl bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe vddc vpw
+  nbl[1]_9 vddc vpw bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddc vddc vnwc vpw
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddc vddc vnwc bl[2]_7
+  nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc vnwc
+  nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe bl[2]_5 bl[3]_5 nbl[1]_4
+  vddc vpw bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddc vddc vnwc bl[2]_3
+  nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc bl[2]_2 nbl[2]_2 nbl[3]_2
+  bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc nbl[2]_1 nbl[3]_1 bl[0]_0
+  nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe bl[2]_0 nbl[2]_0 nbl[3]_0 vnwc vpw wl[0]_23
+  wl[1]_23 sram128x46mem_l_test23row
xmem_l_row_24 vddc vnwc dbl dwl vddc vnwc bl[2]_10 nbl[2]_10 nbl[3]_10
+  bl[3]_10 bl[0]_9 nbl[0]_9 bl[1]_9 vddpe vddc vnwc nbl[3]_9 nbl[0]_8
+  nbl[1]_8 bl[1]_8 vddpe nbl[0]_7 nbl[1]_7 vddpe vpw vddpe vddc vpw bl[2]_6
+  nbl[2]_6 bl[0]_5 vddc vddc vnwc vpw nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4
+  bl[1]_4 vddpe vddc vnwc nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe vpw nbl[0]_2
+  nbl[1]_2 vddpe vddc vnwc vssc vpw vddpe vddc vnwc vpw bl[2]_1 bl[3]_1 vddc
+  vddc vnwc vpw bl[3]_0 vnwp_0 vpw vnwp_1 bl[0]_10 nbl[0]_10 nbl[1]_10
+  bl[1]_10 vddpe vddc vpw nbl[1]_9 vddc vpw bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8
+  vddc vddc vnwc vpw bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddc
+  vddc vnwc bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6
+  bl[1]_6 vddc vnwc nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe bl[2]_5
+  bl[3]_5 nbl[1]_4 vddc vpw bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddc
+  vddc vnwc bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc bl[2]_2
+  nbl[2]_2 nbl[3]_2 bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc nbl[2]_1
+  nbl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe bl[2]_0 nbl[2]_0 nbl[3]_0
+  vnwc vpw wl[1]_24 wl[0]_24 sram128x46mem_l_test24row
xmem_l_row_25 vddc vpw vnwc vddc vnwc bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10
+  bl[0]_9 nbl[0]_9 bl[1]_9 vddpe vddc vnwc nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8
+  vddpe nbl[0]_7 nbl[1]_7 vddpe vpw vddpe vddc vpw bl[2]_6 nbl[2]_6 bl[0]_5
+  vddc vddc vnwc vpw nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4 vddpe vddc
+  vnwc nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe vpw nbl[0]_2 nbl[1]_2 vddpe vddc vnwc
+  vssc vpw vddpe vddc vnwc vpw bl[2]_1 bl[3]_1 vddc vddc vnwc vpw bl[3]_0
+  vnwp_0 vnwp_1 dbl dwl bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe vddc vpw
+  nbl[1]_9 vddc vpw bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddc vddc vnwc vpw
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddc vddc vnwc bl[2]_7
+  nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc vnwc
+  nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe bl[2]_5 bl[3]_5 nbl[1]_4
+  vddc vpw bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddc vddc vnwc bl[2]_3
+  nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc bl[2]_2 nbl[2]_2 nbl[3]_2
+  bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc nbl[2]_1 nbl[3]_1 bl[0]_0
+  nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe bl[2]_0 nbl[2]_0 nbl[3]_0 vnwc vpw wl[0]_25
+  wl[1]_25 sram128x46mem_l_test25row
xmem_l_row_26 vddc vnwc dbl dwl vddc vnwc bl[2]_10 nbl[2]_10 nbl[3]_10
+  bl[3]_10 bl[0]_9 nbl[0]_9 bl[1]_9 vddpe vddc vnwc nbl[3]_9 nbl[0]_8
+  nbl[1]_8 bl[1]_8 vddpe nbl[0]_7 nbl[1]_7 vddpe vpw vddpe vddc vpw bl[2]_6
+  nbl[2]_6 bl[0]_5 vddc vddc vnwc vpw nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4
+  bl[1]_4 vddpe vddc vnwc nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe vpw nbl[0]_2
+  nbl[1]_2 vddpe vddc vnwc vssc vpw vddpe vddc vnwc vpw bl[2]_1 bl[3]_1 vddc
+  vddc vnwc vpw bl[3]_0 vnwp_0 vpw vnwp_1 bl[0]_10 nbl[0]_10 nbl[1]_10
+  bl[1]_10 vddpe vddc vpw nbl[1]_9 vddc vpw bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8
+  vddc vddc vnwc vpw bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddc
+  vddc vnwc bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6
+  bl[1]_6 vddc vnwc nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe bl[2]_5
+  bl[3]_5 nbl[1]_4 vddc vpw bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddc
+  vddc vnwc bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc bl[2]_2
+  nbl[2]_2 nbl[3]_2 bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc nbl[2]_1
+  nbl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe bl[2]_0 nbl[2]_0 nbl[3]_0
+  vnwc vpw wl[1]_26 wl[0]_26 sram128x46mem_l_test26row
xmem_l_row_27 vddc vpw vnwc vddc vnwc bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10
+  bl[0]_9 nbl[0]_9 bl[1]_9 vddpe vddc vnwc nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8
+  vddpe nbl[0]_7 nbl[1]_7 vddpe vpw vddpe vddc vpw bl[2]_6 nbl[2]_6 bl[0]_5
+  vddc vddc vnwc vpw nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4 vddpe vddc
+  vnwc nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe vpw nbl[0]_2 nbl[1]_2 vddpe vddc vnwc
+  vssc vpw vddpe vddc vnwc vpw bl[2]_1 bl[3]_1 vddc vddc vnwc vpw bl[3]_0
+  vnwp_0 vnwp_1 dbl dwl bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe vddc vpw
+  nbl[1]_9 vddc vpw bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddc vddc vnwc vpw
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddc vddc vnwc bl[2]_7
+  nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc vnwc
+  nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe bl[2]_5 bl[3]_5 nbl[1]_4
+  vddc vpw bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddc vddc vnwc bl[2]_3
+  nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc bl[2]_2 nbl[2]_2 nbl[3]_2
+  bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc nbl[2]_1 nbl[3]_1 bl[0]_0
+  nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe bl[2]_0 nbl[2]_0 nbl[3]_0 vnwc vpw wl[0]_27
+  wl[1]_27 sram128x46mem_l_test27row
xmem_l_row_28 vddc vnwc dbl dwl vddc vnwc bl[2]_10 nbl[2]_10 nbl[3]_10
+  bl[3]_10 bl[0]_9 nbl[0]_9 bl[1]_9 vddpe vddc vnwc nbl[3]_9 nbl[0]_8
+  nbl[1]_8 bl[1]_8 vddpe nbl[0]_7 nbl[1]_7 vddpe vpw vddpe vddc vpw bl[2]_6
+  nbl[2]_6 bl[0]_5 vddc vddc vnwc vpw nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4
+  bl[1]_4 vddpe vddc vnwc nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe vpw nbl[0]_2
+  nbl[1]_2 vddpe vddc vnwc vssc vpw vddpe vddc vnwc vpw bl[2]_1 bl[3]_1 vddc
+  vddc vnwc vpw bl[3]_0 vnwp_0 vpw vnwp_1 bl[0]_10 nbl[0]_10 nbl[1]_10
+  bl[1]_10 vddpe vddc vpw nbl[1]_9 vddc vpw bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8
+  vddc vddc vnwc vpw bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddc
+  vddc vnwc bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6
+  bl[1]_6 vddc vnwc nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe bl[2]_5
+  bl[3]_5 nbl[1]_4 vddc vpw bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddc
+  vddc vnwc bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc bl[2]_2
+  nbl[2]_2 nbl[3]_2 bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc nbl[2]_1
+  nbl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe bl[2]_0 nbl[2]_0 nbl[3]_0
+  vnwc vpw wl[1]_28 wl[0]_28 sram128x46mem_l_test28row
xmem_l_row_29 vddc vpw vnwc vddc vnwc bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10
+  bl[0]_9 nbl[0]_9 bl[1]_9 vddpe vddc vnwc nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8
+  vddpe nbl[0]_7 nbl[1]_7 vddpe vpw vddpe vddc vpw bl[2]_6 nbl[2]_6 bl[0]_5
+  vddc vddc vnwc vpw nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4 vddpe vddc
+  vnwc nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe vpw nbl[0]_2 nbl[1]_2 vddpe vddc vnwc
+  vssc vpw vddpe vddc vnwc vpw bl[2]_1 bl[3]_1 vddc vddc vnwc vpw bl[3]_0
+  vnwp_0 vnwp_1 dbl dwl bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe vddc vpw
+  nbl[1]_9 vddc vpw bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddc vddc vnwc vpw
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddc vddc vnwc bl[2]_7
+  nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc vnwc
+  nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe bl[2]_5 bl[3]_5 nbl[1]_4
+  vddc vpw bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddc vddc vnwc bl[2]_3
+  nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc bl[2]_2 nbl[2]_2 nbl[3]_2
+  bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc nbl[2]_1 nbl[3]_1 bl[0]_0
+  nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe bl[2]_0 nbl[2]_0 nbl[3]_0 vnwc vpw wl[0]_29
+  wl[1]_29 sram128x46mem_l_test29row
xmem_l_row_3 vddc vpw vnwc vddc vnwc bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10
+  bl[0]_9 nbl[0]_9 bl[1]_9 vddpe vddc vnwc nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8
+  vddpe nbl[0]_7 nbl[1]_7 vddpe vpw vddpe vddc vpw bl[2]_6 nbl[2]_6 bl[0]_5
+  vddc vddc vnwc vpw nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4 vddpe vddc
+  vnwc nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe vpw nbl[0]_2 nbl[1]_2 vddpe vddc vnwc
+  vssc vpw vddpe vddc vnwc vpw bl[2]_1 bl[3]_1 vddc vddc vnwc vpw bl[3]_0
+  vnwp_0 vnwp_1 dbl dwl bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe vddc vpw
+  nbl[1]_9 vddc vpw bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddc vddc vnwc vpw
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddc vddc vnwc bl[2]_7
+  nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc vnwc
+  nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe bl[2]_5 bl[3]_5 nbl[1]_4
+  vddc vpw bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddc vddc vnwc bl[2]_3
+  nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc bl[2]_2 nbl[2]_2 nbl[3]_2
+  bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc nbl[2]_1 nbl[3]_1 bl[0]_0
+  nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe bl[2]_0 nbl[2]_0 nbl[3]_0 vnwc vpw wl[0]_3
+  wl[1]_3 sram128x46mem_l_test3row
xmem_l_row_30 vddc vnwc vddc vnwc bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10
+  bl[0]_9 nbl[0]_9 bl[1]_9 vddpe vddc vnwc nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8
+  vddpe nbl[0]_7 nbl[1]_7 vddpe vpw vddpe vddc vpw bl[2]_6 nbl[2]_6 bl[0]_5
+  vddc vddc vnwc vpw nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4 vddpe vddc
+  vnwc nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe vpw nbl[0]_2 nbl[1]_2 vddpe vddc vnwc
+  vssc vpw vddpe vddc vnwc vpw bl[2]_1 bl[3]_1 vddc vddc vnwc vpw bl[3]_0
+  vnwp_0 vpw vnwp_1 dbl dwl bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe vddc
+  vpw nbl[1]_9 vddc vpw bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddc vddc vnwc vpw
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddc vddc vnwc bl[2]_7
+  nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc vnwc
+  nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe bl[2]_5 bl[3]_5 nbl[1]_4
+  vddc vpw bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddc vddc vnwc bl[2]_3
+  nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc bl[2]_2 nbl[2]_2 nbl[3]_2
+  bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc nbl[2]_1 nbl[3]_1 bl[0]_0
+  nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe bl[2]_0 nbl[2]_0 nbl[3]_0 vnwc vpw wl[0]_30
+  wl[1]_30 sram128x46mem_l_test30row
xmem_l_row_4 vddc vnwc dbl dwl vddc vnwc bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10
+  bl[0]_9 nbl[0]_9 bl[1]_9 vddpe vddc vnwc nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8
+  vddpe nbl[0]_7 nbl[1]_7 vddpe vpw vddpe vddc vpw bl[2]_6 nbl[2]_6 bl[0]_5
+  vddc vddc vnwc vpw nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4 vddpe vddc
+  vnwc nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe vpw nbl[0]_2 nbl[1]_2 vddpe vddc vnwc
+  vssc vpw vddpe vddc vnwc vpw bl[2]_1 bl[3]_1 vddc vddc vnwc vpw bl[3]_0
+  vnwp_0 vpw vnwp_1 bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe vddc vpw
+  nbl[1]_9 vddc vpw bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddc vddc vnwc vpw
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddc vddc vnwc bl[2]_7
+  nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc vnwc
+  nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe bl[2]_5 bl[3]_5 nbl[1]_4
+  vddc vpw bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddc vddc vnwc bl[2]_3
+  nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc bl[2]_2 nbl[2]_2 nbl[3]_2
+  bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc nbl[2]_1 nbl[3]_1 bl[0]_0
+  nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe bl[2]_0 nbl[2]_0 nbl[3]_0 vnwc vpw wl[1]_4
+  wl[0]_4 sram128x46mem_l_test4row
xmem_l_row_5 vddc vpw vnwc vddc vnwc bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10
+  bl[0]_9 nbl[0]_9 bl[1]_9 vddpe vddc vnwc nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8
+  vddpe nbl[0]_7 nbl[1]_7 vddpe vpw vddpe vddc vpw bl[2]_6 nbl[2]_6 bl[0]_5
+  vddc vddc vnwc vpw nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4 vddpe vddc
+  vnwc nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe vpw nbl[0]_2 nbl[1]_2 vddpe vddc vnwc
+  vssc vpw vddpe vddc vnwc vpw bl[2]_1 bl[3]_1 vddc vddc vnwc vpw bl[3]_0
+  vnwp_0 vnwp_1 dbl dwl bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe vddc vpw
+  nbl[1]_9 vddc vpw bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddc vddc vnwc vpw
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddc vddc vnwc bl[2]_7
+  nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc vnwc
+  nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe bl[2]_5 bl[3]_5 nbl[1]_4
+  vddc vpw bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddc vddc vnwc bl[2]_3
+  nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc bl[2]_2 nbl[2]_2 nbl[3]_2
+  bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc nbl[2]_1 nbl[3]_1 bl[0]_0
+  nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe bl[2]_0 nbl[2]_0 nbl[3]_0 vnwc vpw wl[0]_5
+  wl[1]_5 sram128x46mem_l_test5row
xmem_l_row_6 vddc vnwc dbl dwl vddc vnwc bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10
+  bl[0]_9 nbl[0]_9 bl[1]_9 vddpe vddc vnwc nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8
+  vddpe nbl[0]_7 nbl[1]_7 vddpe vpw vddpe vddc vpw bl[2]_6 nbl[2]_6 bl[0]_5
+  vddc vddc vnwc vpw nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4 vddpe vddc
+  vnwc nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe vpw nbl[0]_2 nbl[1]_2 vddpe vddc vnwc
+  vssc vpw vddpe vddc vnwc vpw bl[2]_1 bl[3]_1 vddc vddc vnwc vpw bl[3]_0
+  vnwp_0 vpw vnwp_1 bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe vddc vpw
+  nbl[1]_9 vddc vpw bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddc vddc vnwc vpw
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddc vddc vnwc bl[2]_7
+  nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc vnwc
+  nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe bl[2]_5 bl[3]_5 nbl[1]_4
+  vddc vpw bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddc vddc vnwc bl[2]_3
+  nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc bl[2]_2 nbl[2]_2 nbl[3]_2
+  bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc nbl[2]_1 nbl[3]_1 bl[0]_0
+  nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe bl[2]_0 nbl[2]_0 nbl[3]_0 vnwc vpw wl[1]_6
+  wl[0]_6 sram128x46mem_l_test6row
xmem_l_row_7 vddc vpw vnwc vddc vnwc bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10
+  bl[0]_9 nbl[0]_9 bl[1]_9 vddpe vddc vnwc nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8
+  vddpe nbl[0]_7 nbl[1]_7 vddpe vpw vddpe vddc vpw bl[2]_6 nbl[2]_6 bl[0]_5
+  vddc vddc vnwc vpw nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4 vddpe vddc
+  vnwc nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe vpw nbl[0]_2 nbl[1]_2 vddpe vddc vnwc
+  vssc vpw vddpe vddc vnwc vpw bl[2]_1 bl[3]_1 vddc vddc vnwc vpw bl[3]_0
+  vnwp_0 vnwp_1 dbl dwl bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe vddc vpw
+  nbl[1]_9 vddc vpw bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddc vddc vnwc vpw
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddc vddc vnwc bl[2]_7
+  nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc vnwc
+  nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe bl[2]_5 bl[3]_5 nbl[1]_4
+  vddc vpw bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddc vddc vnwc bl[2]_3
+  nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc bl[2]_2 nbl[2]_2 nbl[3]_2
+  bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc nbl[2]_1 nbl[3]_1 bl[0]_0
+  nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe bl[2]_0 nbl[2]_0 nbl[3]_0 vnwc vpw wl[0]_7
+  wl[1]_7 sram128x46mem_l_test7row
xmem_l_row_8 vddc vnwc dbl dwl vddc vnwc bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10
+  bl[0]_9 nbl[0]_9 bl[1]_9 vddpe vddc vnwc nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8
+  vddpe nbl[0]_7 nbl[1]_7 vddpe vpw vddpe vddc vpw bl[2]_6 nbl[2]_6 bl[0]_5
+  vddc vddc vnwc vpw nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4 vddpe vddc
+  vnwc nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe vpw nbl[0]_2 nbl[1]_2 vddpe vddc vnwc
+  vssc vpw vddpe vddc vnwc vpw bl[2]_1 bl[3]_1 vddc vddc vnwc vpw bl[3]_0
+  vnwp_0 vpw vnwp_1 bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe vddc vpw
+  nbl[1]_9 vddc vpw bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddc vddc vnwc vpw
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddc vddc vnwc bl[2]_7
+  nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc vnwc
+  nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe bl[2]_5 bl[3]_5 nbl[1]_4
+  vddc vpw bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddc vddc vnwc bl[2]_3
+  nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc bl[2]_2 nbl[2]_2 nbl[3]_2
+  bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc nbl[2]_1 nbl[3]_1 bl[0]_0
+  nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe bl[2]_0 nbl[2]_0 nbl[3]_0 vnwc vpw wl[1]_8
+  wl[0]_8 sram128x46mem_l_test8row
xmem_l_row_9 vddc vpw vnwc vddc vnwc bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10
+  bl[0]_9 nbl[0]_9 bl[1]_9 vddpe vddc vnwc nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8
+  vddpe nbl[0]_7 nbl[1]_7 vddpe vpw vddpe vddc vpw bl[2]_6 nbl[2]_6 bl[0]_5
+  vddc vddc vnwc vpw nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4 vddpe vddc
+  vnwc nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe vpw nbl[0]_2 nbl[1]_2 vddpe vddc vnwc
+  vssc vpw vddpe vddc vnwc vpw bl[2]_1 bl[3]_1 vddc vddc vnwc vpw bl[3]_0
+  vnwp_0 vnwp_1 dbl dwl bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe vddc vpw
+  nbl[1]_9 vddc vpw bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddc vddc vnwc vpw
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddc vddc vnwc bl[2]_7
+  nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc vnwc
+  nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe bl[2]_5 bl[3]_5 nbl[1]_4
+  vddc vpw bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddc vddc vnwc bl[2]_3
+  nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc bl[2]_2 nbl[2]_2 nbl[3]_2
+  bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc nbl[2]_1 nbl[3]_1 bl[0]_0
+  nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe bl[2]_0 nbl[2]_0 nbl[3]_0 vnwc vpw wl[0]_9
+  wl[1]_9 sram128x46mem_l_test9row
xmem_l_row_bot vddc vnwc dbl dwl vddc vnwc bl[2]_10 nbl[2]_10 nbl[3]_10
+  bl[3]_10 bl[0]_9 nbl[0]_9 bl[1]_9 vddpe vddc vnwc nbl[3]_9 nbl[0]_8
+  nbl[1]_8 bl[1]_8 vddpe nbl[0]_7 nbl[1]_7 vddpe vpw vddpe vddc vpw bl[2]_6
+  nbl[2]_6 bl[0]_5 vddc vddc vnwc vpw nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4
+  bl[1]_4 vddpe vddc vnwc nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe vpw nbl[0]_2
+  nbl[1]_2 vddpe vddc vnwc vssc vpw vddpe vddc vnwc vpw bl[2]_1 bl[3]_1 vddc
+  vddc vnwc vssc vpw bl[3]_0 vnwp_0 vpw vnwp_1 bl[0]_10 nbl[0]_10 nbl[1]_10
+  bl[1]_10 vddpe vddc vssc vpw nbl[1]_9 vddc vpw bl[2]_9 nbl[2]_9 bl[3]_9
+  bl[0]_8 vddc vddc vnwc vpw bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7
+  bl[1]_7 vddc vddc vnwc bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6
+  nbl[1]_6 bl[1]_6 vddc vnwc nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe
+  bl[2]_5 bl[3]_5 nbl[1]_4 vddc vpw bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3
+  vddc vddc vnwc bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc
+  bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc
+  nbl[2]_1 nbl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe bl[2]_0 nbl[2]_0
+  nbl[3]_0 vnwc vpw wl[1]_0 wl[0]_0 sram128x46mem_l_bot_row
xmem_l_row_mid vddc vpw vnwc vddc vnwc bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10
+  bl[0]_9 nbl[0]_9 bl[1]_9 vddpe vddc vnwc nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8
+  vddpe nbl[0]_7 nbl[1]_7 vddpe vpw vddpe vddc vpw bl[2]_6 nbl[2]_6 bl[0]_5
+  vddc vddc vnwc vpw nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4 vddpe vddc
+  vnwc nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe vpw nbl[0]_2 nbl[1]_2 vddpe vddc vnwc
+  vssc vpw vddpe vddc vnwc vpw bl[2]_1 bl[3]_1 vddc vddc vnwc vpw bl[3]_0
+  vnwp_0 vnwp_1 dbl dwl bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe vddc vpw
+  nbl[1]_9 vddc vpw bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddc vddc vnwc vpw
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddc vddc vnwc bl[2]_7
+  nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc vnwc
+  nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe bl[2]_5 bl[3]_5 nbl[1]_4
+  vddc vpw bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddc vddc vnwc bl[2]_3
+  nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc bl[2]_2 nbl[2]_2 nbl[3]_2
+  bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc nbl[2]_1 nbl[3]_1 bl[0]_0
+  nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe bl[2]_0 nbl[2]_0 nbl[3]_0 vnwc vpw wl[0]_15
+  wl[1]_15 sram128x46mem_l_mid_row
xmem_l_row_midb vddc vnwc dbl dwl vddc vnwc bl[2]_10 nbl[2]_10 nbl[3]_10
+  bl[3]_10 bl[0]_9 nbl[0]_9 bl[1]_9 vddpe vddc vnwc nbl[3]_9 nbl[0]_8
+  nbl[1]_8 bl[1]_8 vddpe nbl[0]_7 nbl[1]_7 vddpe vpw vddpe vddc vpw bl[2]_6
+  nbl[2]_6 bl[0]_5 vddc vddc vnwc vpw nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4
+  bl[1]_4 vddpe vddc vnwc nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe vpw nbl[0]_2
+  nbl[1]_2 vddpe vddc vnwc vssc vpw vddpe vddc vnwc vpw bl[2]_1 bl[3]_1 vddc
+  vddc vnwc vpw bl[3]_0 vnwp_0 vpw vnwp_1 bl[0]_10 nbl[0]_10 nbl[1]_10
+  bl[1]_10 vddpe vddc vpw nbl[1]_9 vddc vpw bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8
+  vddc vddc vnwc vpw bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddc
+  vddc vnwc bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6
+  bl[1]_6 vddc vnwc nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe bl[2]_5
+  bl[3]_5 nbl[1]_4 vddc vpw bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddc
+  vddc vnwc bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc bl[2]_2
+  nbl[2]_2 nbl[3]_2 bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc nbl[2]_1
+  nbl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe bl[2]_0 nbl[2]_0 nbl[3]_0
+  vnwc vpw wl[1]_14 wl[0]_14 sram128x46mem_l_midb_row
xmem_l_row_midt vddc vnwc dbl dwl vddc vnwc bl[2]_10 nbl[2]_10 nbl[3]_10
+  bl[3]_10 bl[0]_9 nbl[0]_9 bl[1]_9 vddpe vddc vnwc nbl[3]_9 nbl[0]_8
+  nbl[1]_8 bl[1]_8 vddpe nbl[0]_7 nbl[1]_7 vddpe vpw vddpe vddc vpw bl[2]_6
+  nbl[2]_6 bl[0]_5 vddc vddc vnwc vpw nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4
+  bl[1]_4 vddpe vddc vnwc nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe vpw nbl[0]_2
+  nbl[1]_2 vddpe vddc vnwc vssc vpw vddpe vddc vnwc vpw bl[2]_1 bl[3]_1 vddc
+  vddc vnwc vpw bl[3]_0 vnwp_0 vpw vnwp_1 bl[0]_10 nbl[0]_10 nbl[1]_10
+  bl[1]_10 vddpe vddc vpw nbl[1]_9 vddc vpw bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8
+  vddc vddc vnwc vpw bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddc
+  vddc vnwc bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6
+  bl[1]_6 vddc vnwc nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe bl[2]_5
+  bl[3]_5 nbl[1]_4 vddc vpw bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddc
+  vddc vnwc bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc bl[2]_2
+  nbl[2]_2 nbl[3]_2 bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc nbl[2]_1
+  nbl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe bl[2]_0 nbl[2]_0 nbl[3]_0
+  vnwc vpw wl[1]_16 wl[0]_16 sram128x46mem_l_midt_row
xmem_l_row_top vddc vpw vnwc dbl dwl vddc vnwc bl[2]_10 nbl[2]_10 nbl[3]_10
+  bl[3]_10 bl[0]_9 nbl[0]_9 bl[1]_9 vddpe vddc vnwc nbl[3]_9 nbl[0]_8
+  nbl[1]_8 bl[1]_8 vddpe nbl[0]_7 nbl[1]_7 vddpe vpw vddpe vddc vpw bl[2]_6
+  nbl[2]_6 bl[0]_5 vddc vddc vnwc vpw nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4
+  bl[1]_4 vddpe vddc vnwc nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe vpw nbl[0]_2
+  nbl[1]_2 vddpe vddc vnwc vssc vpw vddpe vddc vnwc vpw bl[2]_1 bl[3]_1 vddc
+  vddc vnwc vssc vpw bl[3]_0 vnwp_0 vnwp_1 bl[0]_10 nbl[0]_10 nbl[1]_10
+  bl[1]_10 vddpe vddc vssc vpw nbl[1]_9 vddc vpw bl[2]_9 nbl[2]_9 bl[3]_9
+  bl[0]_8 vddc vddc vnwc vpw bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7
+  bl[1]_7 vddc vddc vnwc bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6
+  nbl[1]_6 bl[1]_6 vddc vnwc nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe
+  bl[2]_5 bl[3]_5 nbl[1]_4 vddc vpw bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3
+  vddc vddc vnwc bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc
+  bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc
+  nbl[2]_1 nbl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe bl[2]_0 nbl[2]_0
+  nbl[3]_0 vnwc vpw wl[1]_31 wl[0]_31 sram128x46mem_l_top_row
.ends sram128x46memcore_l
****
.subckt sram128x46mem_r_midb_row vpw_13 vnwc_13 bl[3]_11 nbl[3]_11 nbl[2]_11
+  bl[2]_11 vnwc_12 vddc_11 bl[3]_10 nbl[3]_10 nbl[2]_10 vddc_10 vddpe_10
+  nbl[1]_10 nbl[0]_10 bl[3]_9 vddc_9 vddpe_9 nbl[1]_9 bl[3]_8 vpw_9 vssc
+  vddc_8 vddpe_8 bl[3]_7 vpw_8 vddc_7 vddce_7 bl[3]_6 nbl[2]_6 vnwc_7 vddce_6
+  nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc_6 vddpe_5 nbl[3]_4 vpw_5 vddpe_4
+  nbl[1]_4 vpw_4 vnwc_4 vddce_3 vddpe_3 vpw_3 vnwc_3 vddce_2 bl[3]_1 vpw_2
+  vnwc_2 vddce_1 bl[0]_1 nbl[2]_0 vnwc_1 vddce_0 vddpe_0 bl[1]_0 vnwp_1
+  vpw_12 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10
+  vpw_11 vnwc_11 vddce_10 bl[1]_10 bl[0]_10 nbl[3]_9 nbl[2]_9 bl[2]_9 vpw_10
+  vnwc_10 vddce_9 bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8 nbl[2]_8 bl[2]_8 vnwc_9
+  vddce_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7 nbl[2]_7 bl[2]_7 vnwc_8
+  vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6 bl[2]_6 vpw_7 vddc_6
+  vddpe_6 bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw_6 vddc_5 vddce_5 bl[1]_5
+  nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc_5 vddc_4 vddce_4
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc_3 bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc_2 vddpe_2
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc_1 vddpe_1
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw_1 vddc_0 nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_r_midb_row: 576 flat devices **
xmem_r_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_352 ncored01_354
+  ncored10_356 ncored11_358 ncored20_360 ncored21_362 ncored30_364
+  ncored31_366 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
.ends sram128x46mem_r_midb_row
****
.subckt sram128x46mem_r_test10row vpw_13 vnwc_13 bl[3]_11 nbl[3]_11 nbl[2]_11
+  bl[2]_11 vnwc_12 vddc_11 bl[3]_10 nbl[3]_10 nbl[2]_10 vddc_10 vddpe_10
+  nbl[1]_10 nbl[0]_10 bl[3]_9 vddc_9 vddpe_9 nbl[1]_9 bl[3]_8 vpw_9 vssc
+  vddc_8 vddpe_8 bl[3]_7 vpw_8 vddc_7 vddce_7 bl[3]_6 nbl[2]_6 vnwc_7 vddce_6
+  nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc_6 vddpe_5 nbl[3]_4 vpw_5 vddpe_4
+  nbl[1]_4 vpw_4 vnwc_4 vddce_3 vddpe_3 vpw_3 vnwc_3 vddce_2 bl[3]_1 vpw_2
+  vnwc_2 vddce_1 bl[0]_1 nbl[2]_0 vnwc_1 vddce_0 vddpe_0 bl[1]_0 vnwp_1
+  vpw_12 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10
+  vpw_11 vnwc_11 vddce_10 bl[1]_10 bl[0]_10 nbl[3]_9 nbl[2]_9 bl[2]_9 vpw_10
+  vnwc_10 vddce_9 bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8 nbl[2]_8 bl[2]_8 vnwc_9
+  vddce_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7 nbl[2]_7 bl[2]_7 vnwc_8
+  vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6 bl[2]_6 vpw_7 vddc_6
+  vddpe_6 bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw_6 vddc_5 vddce_5 bl[1]_5
+  nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc_5 vddc_4 vddce_4
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc_3 bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc_2 vddpe_2
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc_1 vddpe_1
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw_1 vddc_0 nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_r_test10row: 576 flat devices **
xmem_r_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_352 ncored01_354
+  ncored10_356 ncored11_358 ncored20_360 ncored21_362 ncored30_364
+  ncored31_366 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
.ends sram128x46mem_r_test10row
****
.subckt sram128x46mem_r_test11row vpw_13 vnwc_13 bl[3]_11 nbl[3]_11 nbl[2]_11
+  bl[2]_11 vnwc_12 vddc_11 bl[3]_10 nbl[3]_10 nbl[2]_10 vddc_10 vddpe_10
+  nbl[1]_10 nbl[0]_10 bl[3]_9 vddc_9 vddpe_9 nbl[1]_9 bl[3]_8 vpw_9 vssc
+  vddc_8 vddpe_8 bl[3]_7 vpw_8 vddc_7 vddce_7 bl[3]_6 nbl[2]_6 vnwc_7 vddce_6
+  nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc_6 vddpe_5 nbl[3]_4 vpw_5 vddpe_4
+  nbl[1]_4 vpw_4 vnwc_4 vddce_3 vddpe_3 vpw_3 vnwc_3 vddce_2 bl[3]_1 vpw_2
+  vnwc_2 vddce_1 bl[0]_1 nbl[2]_0 vnwc_1 vddce_0 vddpe_0 bl[1]_0 vnwp_1
+  vpw_12 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10
+  vpw_11 vnwc_11 vddce_10 bl[1]_10 bl[0]_10 nbl[3]_9 nbl[2]_9 bl[2]_9 vpw_10
+  vnwc_10 vddce_9 bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8 nbl[2]_8 bl[2]_8 vnwc_9
+  vddce_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7 nbl[2]_7 bl[2]_7 vnwc_8
+  vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6 bl[2]_6 vpw_7 vddc_6
+  vddpe_6 bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw_6 vddc_5 vddce_5 bl[1]_5
+  nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc_5 vddc_4 vddce_4
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc_3 bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc_2 vddpe_2
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc_1 vddpe_1
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw_1 vddc_0 nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_r_test11row: 576 flat devices **
xmem_r_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_352 ncored01_354
+  ncored10_356 ncored11_358 ncored20_360 ncored21_362 ncored30_364
+  ncored31_366 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
.ends sram128x46mem_r_test11row
****
.subckt sram128x46mem_r_test30row vpw_13 vnwc_13 bl[3]_11 nbl[3]_11 nbl[2]_11
+  bl[2]_11 vnwc_12 vddc_11 bl[3]_10 nbl[3]_10 nbl[2]_10 vddc_10 vddpe_10
+  nbl[1]_10 nbl[0]_10 bl[3]_9 vddc_9 vddpe_9 nbl[1]_9 bl[3]_8 vpw_9 vssc
+  vddc_8 vddpe_8 bl[3]_7 vpw_8 vddc_7 vddce_7 bl[3]_6 nbl[2]_6 vnwc_7 vddce_6
+  nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc_6 vddpe_5 nbl[3]_4 vpw_5 vddpe_4
+  nbl[1]_4 vpw_4 vnwc_4 vddce_3 vddpe_3 vpw_3 vnwc_3 vddce_2 bl[3]_1 vpw_2
+  vnwc_2 vddce_1 bl[0]_1 nbl[2]_0 vnwc_1 vddce_0 vddpe_0 bl[1]_0 vnwp_1
+  vpw_12 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10
+  vpw_11 vnwc_11 vddce_10 bl[1]_10 bl[0]_10 nbl[3]_9 nbl[2]_9 bl[2]_9 vpw_10
+  vnwc_10 vddce_9 bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8 nbl[2]_8 bl[2]_8 vnwc_9
+  vddce_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7 nbl[2]_7 bl[2]_7 vnwc_8
+  vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6 bl[2]_6 vpw_7 vddc_6
+  vddpe_6 bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw_6 vddc_5 vddce_5 bl[1]_5
+  nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc_5 vddc_4 vddce_4
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc_3 bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc_2 vddpe_2
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc_1 vddpe_1
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw_1 vddc_0 nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_r_test30row: 576 flat devices **
xmem_r_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_352 ncored01_354
+  ncored10_356 ncored11_358 ncored20_360 ncored21_362 ncored30_364
+  ncored31_366 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
.ends sram128x46mem_r_test30row
****
.subckt sram128x46mem_r_test12row vpw_13 vnwc_13 bl[3]_11 nbl[3]_11 nbl[2]_11
+  bl[2]_11 vnwc_12 vddc_11 bl[3]_10 nbl[3]_10 nbl[2]_10 vddc_10 vddpe_10
+  nbl[1]_10 nbl[0]_10 bl[3]_9 vddc_9 vddpe_9 nbl[1]_9 bl[3]_8 vpw_9 vssc
+  vddc_8 vddpe_8 bl[3]_7 vpw_8 vddc_7 vddce_7 bl[3]_6 nbl[2]_6 vnwc_7 vddce_6
+  nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc_6 vddpe_5 nbl[3]_4 vpw_5 vddpe_4
+  nbl[1]_4 vpw_4 vnwc_4 vddce_3 vddpe_3 vpw_3 vnwc_3 vddce_2 bl[3]_1 vpw_2
+  vnwc_2 vddce_1 bl[0]_1 nbl[2]_0 vnwc_1 vddce_0 vddpe_0 bl[1]_0 vnwp_1
+  vpw_12 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10
+  vpw_11 vnwc_11 vddce_10 bl[1]_10 bl[0]_10 nbl[3]_9 nbl[2]_9 bl[2]_9 vpw_10
+  vnwc_10 vddce_9 bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8 nbl[2]_8 bl[2]_8 vnwc_9
+  vddce_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7 nbl[2]_7 bl[2]_7 vnwc_8
+  vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6 bl[2]_6 vpw_7 vddc_6
+  vddpe_6 bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw_6 vddc_5 vddce_5 bl[1]_5
+  nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc_5 vddc_4 vddce_4
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc_3 bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc_2 vddpe_2
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc_1 vddpe_1
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw_1 vddc_0 nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_r_test12row: 576 flat devices **
xmem_r_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_352 ncored01_354
+  ncored10_356 ncored11_358 ncored20_360 ncored21_362 ncored30_364
+  ncored31_366 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
.ends sram128x46mem_r_test12row
****
.subckt sram128x46mem_r_test13row vpw_13 vnwc_13 bl[3]_11 nbl[3]_11 nbl[2]_11
+  bl[2]_11 vnwc_12 vddc_11 bl[3]_10 nbl[3]_10 nbl[2]_10 vddc_10 vddpe_10
+  nbl[1]_10 nbl[0]_10 bl[3]_9 vddc_9 vddpe_9 nbl[1]_9 bl[3]_8 vpw_9 vssc
+  vddc_8 vddpe_8 bl[3]_7 vpw_8 vddc_7 vddce_7 bl[3]_6 nbl[2]_6 vnwc_7 vddce_6
+  nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc_6 vddpe_5 nbl[3]_4 vpw_5 vddpe_4
+  nbl[1]_4 vpw_4 vnwc_4 vddce_3 vddpe_3 vpw_3 vnwc_3 vddce_2 bl[3]_1 vpw_2
+  vnwc_2 vddce_1 bl[0]_1 nbl[2]_0 vnwc_1 vddce_0 vddpe_0 bl[1]_0 vnwp_1
+  vpw_12 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10
+  vpw_11 vnwc_11 vddce_10 bl[1]_10 bl[0]_10 nbl[3]_9 nbl[2]_9 bl[2]_9 vpw_10
+  vnwc_10 vddce_9 bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8 nbl[2]_8 bl[2]_8 vnwc_9
+  vddce_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7 nbl[2]_7 bl[2]_7 vnwc_8
+  vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6 bl[2]_6 vpw_7 vddc_6
+  vddpe_6 bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw_6 vddc_5 vddce_5 bl[1]_5
+  nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc_5 vddc_4 vddce_4
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc_3 bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc_2 vddpe_2
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc_1 vddpe_1
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw_1 vddc_0 nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_r_test13row: 576 flat devices **
xmem_r_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_352 ncored01_354
+  ncored10_356 ncored11_358 ncored20_360 ncored21_362 ncored30_364
+  ncored31_366 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
.ends sram128x46mem_r_test13row
****
.subckt sram128x46mem_r_test17row vpw_13 vnwc_13 bl[3]_11 nbl[3]_11 nbl[2]_11
+  bl[2]_11 vnwc_12 vddc_11 bl[3]_10 nbl[3]_10 nbl[2]_10 vddc_10 vddpe_10
+  nbl[1]_10 nbl[0]_10 bl[3]_9 vddc_9 vddpe_9 nbl[1]_9 bl[3]_8 vpw_9 vssc
+  vddc_8 vddpe_8 bl[3]_7 vpw_8 vddc_7 vddce_7 bl[3]_6 nbl[2]_6 vnwc_7 vddce_6
+  nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc_6 vddpe_5 nbl[3]_4 vpw_5 vddpe_4
+  nbl[1]_4 vpw_4 vnwc_4 vddce_3 vddpe_3 vpw_3 vnwc_3 vddce_2 bl[3]_1 vpw_2
+  vnwc_2 vddce_1 bl[0]_1 nbl[2]_0 vnwc_1 vddce_0 vddpe_0 bl[1]_0 vnwp_1
+  vpw_12 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10
+  vpw_11 vnwc_11 vddce_10 bl[1]_10 bl[0]_10 nbl[3]_9 nbl[2]_9 bl[2]_9 vpw_10
+  vnwc_10 vddce_9 bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8 nbl[2]_8 bl[2]_8 vnwc_9
+  vddce_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7 nbl[2]_7 bl[2]_7 vnwc_8
+  vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6 bl[2]_6 vpw_7 vddc_6
+  vddpe_6 bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw_6 vddc_5 vddce_5 bl[1]_5
+  nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc_5 vddc_4 vddce_4
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc_3 bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc_2 vddpe_2
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc_1 vddpe_1
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw_1 vddc_0 nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_r_test17row: 576 flat devices **
xmem_r_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_352 ncored01_354
+  ncored10_356 ncored11_358 ncored20_360 ncored21_362 ncored30_364
+  ncored31_366 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
.ends sram128x46mem_r_test17row
****
.subckt sram128x46mem_r_test18row vpw_13 vnwc_13 bl[3]_11 nbl[3]_11 nbl[2]_11
+  bl[2]_11 vnwc_12 vddc_11 bl[3]_10 nbl[3]_10 nbl[2]_10 vddc_10 vddpe_10
+  nbl[1]_10 nbl[0]_10 bl[3]_9 vddc_9 vddpe_9 nbl[1]_9 bl[3]_8 vpw_9 vssc
+  vddc_8 vddpe_8 bl[3]_7 vpw_8 vddc_7 vddce_7 bl[3]_6 nbl[2]_6 vnwc_7 vddce_6
+  nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc_6 vddpe_5 nbl[3]_4 vpw_5 vddpe_4
+  nbl[1]_4 vpw_4 vnwc_4 vddce_3 vddpe_3 vpw_3 vnwc_3 vddce_2 bl[3]_1 vpw_2
+  vnwc_2 vddce_1 bl[0]_1 nbl[2]_0 vnwc_1 vddce_0 vddpe_0 bl[1]_0 vnwp_1
+  vpw_12 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10
+  vpw_11 vnwc_11 vddce_10 bl[1]_10 bl[0]_10 nbl[3]_9 nbl[2]_9 bl[2]_9 vpw_10
+  vnwc_10 vddce_9 bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8 nbl[2]_8 bl[2]_8 vnwc_9
+  vddce_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7 nbl[2]_7 bl[2]_7 vnwc_8
+  vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6 bl[2]_6 vpw_7 vddc_6
+  vddpe_6 bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw_6 vddc_5 vddce_5 bl[1]_5
+  nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc_5 vddc_4 vddce_4
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc_3 bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc_2 vddpe_2
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc_1 vddpe_1
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw_1 vddc_0 nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_r_test18row: 576 flat devices **
xmem_r_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_352 ncored01_354
+  ncored10_356 ncored11_358 ncored20_360 ncored21_362 ncored30_364
+  ncored31_366 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
.ends sram128x46mem_r_test18row
****
.subckt sram128x46mem_r_test19row vpw_13 vnwc_13 bl[3]_11 nbl[3]_11 nbl[2]_11
+  bl[2]_11 vnwc_12 vddc_11 bl[3]_10 nbl[3]_10 nbl[2]_10 vddc_10 vddpe_10
+  nbl[1]_10 nbl[0]_10 bl[3]_9 vddc_9 vddpe_9 nbl[1]_9 bl[3]_8 vpw_9 vssc
+  vddc_8 vddpe_8 bl[3]_7 vpw_8 vddc_7 vddce_7 bl[3]_6 nbl[2]_6 vnwc_7 vddce_6
+  nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc_6 vddpe_5 nbl[3]_4 vpw_5 vddpe_4
+  nbl[1]_4 vpw_4 vnwc_4 vddce_3 vddpe_3 vpw_3 vnwc_3 vddce_2 bl[3]_1 vpw_2
+  vnwc_2 vddce_1 bl[0]_1 nbl[2]_0 vnwc_1 vddce_0 vddpe_0 bl[1]_0 vnwp_1
+  vpw_12 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10
+  vpw_11 vnwc_11 vddce_10 bl[1]_10 bl[0]_10 nbl[3]_9 nbl[2]_9 bl[2]_9 vpw_10
+  vnwc_10 vddce_9 bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8 nbl[2]_8 bl[2]_8 vnwc_9
+  vddce_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7 nbl[2]_7 bl[2]_7 vnwc_8
+  vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6 bl[2]_6 vpw_7 vddc_6
+  vddpe_6 bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw_6 vddc_5 vddce_5 bl[1]_5
+  nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc_5 vddc_4 vddce_4
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc_3 bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc_2 vddpe_2
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc_1 vddpe_1
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw_1 vddc_0 nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_r_test19row: 576 flat devices **
xmem_r_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_352 ncored01_354
+  ncored10_356 ncored11_358 ncored20_360 ncored21_362 ncored30_364
+  ncored31_366 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
.ends sram128x46mem_r_test19row
****
.subckt sram128x46mem_r_midt_row vpw_13 vnwc_13 bl[3]_11 nbl[3]_11 nbl[2]_11
+  bl[2]_11 vnwc_12 vddc_11 bl[3]_10 nbl[3]_10 nbl[2]_10 vddc_10 vddpe_10
+  nbl[1]_10 nbl[0]_10 bl[3]_9 vddc_9 vddpe_9 nbl[1]_9 bl[3]_8 vpw_9 vssc
+  vddc_8 vddpe_8 bl[3]_7 vpw_8 vddc_7 vddce_7 bl[3]_6 nbl[2]_6 vnwc_7 vddce_6
+  nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc_6 vddpe_5 nbl[3]_4 vpw_5 vddpe_4
+  nbl[1]_4 vpw_4 vnwc_4 vddce_3 vddpe_3 vpw_3 vnwc_3 vddce_2 bl[3]_1 vpw_2
+  vnwc_2 vddce_1 bl[0]_1 nbl[2]_0 vnwc_1 vddce_0 vddpe_0 bl[1]_0 vnwp_1
+  vpw_12 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10
+  vpw_11 vnwc_11 vddce_10 bl[1]_10 bl[0]_10 nbl[3]_9 nbl[2]_9 bl[2]_9 vpw_10
+  vnwc_10 vddce_9 bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8 nbl[2]_8 bl[2]_8 vnwc_9
+  vddce_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7 nbl[2]_7 bl[2]_7 vnwc_8
+  vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6 bl[2]_6 vpw_7 vddc_6
+  vddpe_6 bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw_6 vddc_5 vddce_5 bl[1]_5
+  nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc_5 vddc_4 vddce_4
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc_3 bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc_2 vddpe_2
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc_1 vddpe_1
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw_1 vddc_0 nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_r_midt_row: 576 flat devices **
xmem_r_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_352 ncored01_354
+  ncored10_356 ncored11_358 ncored20_360 ncored21_362 ncored30_364
+  ncored31_366 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
.ends sram128x46mem_r_midt_row
****
.subckt sram128x46mem_r_mid_row vpw_13 vnwc_13 bl[3]_11 nbl[3]_11 nbl[2]_11
+  bl[2]_11 vnwc_12 vddc_11 bl[3]_10 nbl[3]_10 nbl[2]_10 vddc_10 vddpe_10
+  nbl[1]_10 nbl[0]_10 bl[3]_9 vddc_9 vddpe_9 nbl[1]_9 bl[3]_8 vpw_9 vssc
+  vddc_8 vddpe_8 bl[3]_7 vpw_8 vddc_7 vddce_7 bl[3]_6 nbl[2]_6 vnwc_7 vddce_6
+  nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc_6 vddpe_5 nbl[3]_4 vpw_5 vddpe_4
+  nbl[1]_4 vpw_4 vnwc_4 vddce_3 vddpe_3 vpw_3 vnwc_3 vddce_2 bl[3]_1 vpw_2
+  vnwc_2 vddce_1 bl[0]_1 nbl[2]_0 vnwc_1 vddce_0 vddpe_0 bl[1]_0 vnwp_1
+  vpw_12 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10
+  vpw_11 vnwc_11 vddce_10 bl[1]_10 bl[0]_10 nbl[3]_9 nbl[2]_9 bl[2]_9 vpw_10
+  vnwc_10 vddce_9 bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8 nbl[2]_8 bl[2]_8 vnwc_9
+  vddce_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7 nbl[2]_7 bl[2]_7 vnwc_8
+  vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6 bl[2]_6 vpw_7 vddc_6
+  vddpe_6 bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw_6 vddc_5 vddce_5 bl[1]_5
+  nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc_5 vddc_4 vddce_4
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc_3 bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc_2 vddpe_2
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc_1 vddpe_1
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw_1 vddc_0 nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_r_mid_row: 576 flat devices **
xmem_r_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_352 ncored01_354
+  ncored10_356 ncored11_358 ncored20_360 ncored21_362 ncored30_364
+  ncored31_366 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
.ends sram128x46mem_r_mid_row
****
.subckt sram128x46mem_r_test20row vpw_13 vnwc_13 bl[3]_11 nbl[3]_11 nbl[2]_11
+  bl[2]_11 vnwc_12 vddc_11 bl[3]_10 nbl[3]_10 nbl[2]_10 vddc_10 vddpe_10
+  nbl[1]_10 nbl[0]_10 bl[3]_9 vddc_9 vddpe_9 nbl[1]_9 bl[3]_8 vpw_9 vssc
+  vddc_8 vddpe_8 bl[3]_7 vpw_8 vddc_7 vddce_7 bl[3]_6 nbl[2]_6 vnwc_7 vddce_6
+  nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc_6 vddpe_5 nbl[3]_4 vpw_5 vddpe_4
+  nbl[1]_4 vpw_4 vnwc_4 vddce_3 vddpe_3 vpw_3 vnwc_3 vddce_2 bl[3]_1 vpw_2
+  vnwc_2 vddce_1 bl[0]_1 nbl[2]_0 vnwc_1 vddce_0 vddpe_0 bl[1]_0 vnwp_1
+  vpw_12 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10
+  vpw_11 vnwc_11 vddce_10 bl[1]_10 bl[0]_10 nbl[3]_9 nbl[2]_9 bl[2]_9 vpw_10
+  vnwc_10 vddce_9 bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8 nbl[2]_8 bl[2]_8 vnwc_9
+  vddce_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7 nbl[2]_7 bl[2]_7 vnwc_8
+  vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6 bl[2]_6 vpw_7 vddc_6
+  vddpe_6 bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw_6 vddc_5 vddce_5 bl[1]_5
+  nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc_5 vddc_4 vddce_4
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc_3 bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc_2 vddpe_2
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc_1 vddpe_1
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw_1 vddc_0 nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_r_test20row: 576 flat devices **
xmem_r_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_352 ncored01_354
+  ncored10_356 ncored11_358 ncored20_360 ncored21_362 ncored30_364
+  ncored31_366 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
.ends sram128x46mem_r_test20row
****
.subckt sram128x46mem_r_test21row vpw_13 vnwc_13 bl[3]_11 nbl[3]_11 nbl[2]_11
+  bl[2]_11 vnwc_12 vddc_11 bl[3]_10 nbl[3]_10 nbl[2]_10 vddc_10 vddpe_10
+  nbl[1]_10 nbl[0]_10 bl[3]_9 vddc_9 vddpe_9 nbl[1]_9 bl[3]_8 vpw_9 vssc
+  vddc_8 vddpe_8 bl[3]_7 vpw_8 vddc_7 vddce_7 bl[3]_6 nbl[2]_6 vnwc_7 vddce_6
+  nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc_6 vddpe_5 nbl[3]_4 vpw_5 vddpe_4
+  nbl[1]_4 vpw_4 vnwc_4 vddce_3 vddpe_3 vpw_3 vnwc_3 vddce_2 bl[3]_1 vpw_2
+  vnwc_2 vddce_1 bl[0]_1 nbl[2]_0 vnwc_1 vddce_0 vddpe_0 bl[1]_0 vnwp_1
+  vpw_12 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10
+  vpw_11 vnwc_11 vddce_10 bl[1]_10 bl[0]_10 nbl[3]_9 nbl[2]_9 bl[2]_9 vpw_10
+  vnwc_10 vddce_9 bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8 nbl[2]_8 bl[2]_8 vnwc_9
+  vddce_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7 nbl[2]_7 bl[2]_7 vnwc_8
+  vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6 bl[2]_6 vpw_7 vddc_6
+  vddpe_6 bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw_6 vddc_5 vddce_5 bl[1]_5
+  nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc_5 vddc_4 vddce_4
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc_3 bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc_2 vddpe_2
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc_1 vddpe_1
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw_1 vddc_0 nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_r_test21row: 576 flat devices **
xmem_r_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_352 ncored01_354
+  ncored10_356 ncored11_358 ncored20_360 ncored21_362 ncored30_364
+  ncored31_366 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
.ends sram128x46mem_r_test21row
****
.subckt sram128x46mem_r_test22row vpw_13 vnwc_13 bl[3]_11 nbl[3]_11 nbl[2]_11
+  bl[2]_11 vnwc_12 vddc_11 bl[3]_10 nbl[3]_10 nbl[2]_10 vddc_10 vddpe_10
+  nbl[1]_10 nbl[0]_10 bl[3]_9 vddc_9 vddpe_9 nbl[1]_9 bl[3]_8 vpw_9 vssc
+  vddc_8 vddpe_8 bl[3]_7 vpw_8 vddc_7 vddce_7 bl[3]_6 nbl[2]_6 vnwc_7 vddce_6
+  nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc_6 vddpe_5 nbl[3]_4 vpw_5 vddpe_4
+  nbl[1]_4 vpw_4 vnwc_4 vddce_3 vddpe_3 vpw_3 vnwc_3 vddce_2 bl[3]_1 vpw_2
+  vnwc_2 vddce_1 bl[0]_1 nbl[2]_0 vnwc_1 vddce_0 vddpe_0 bl[1]_0 vnwp_1
+  vpw_12 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10
+  vpw_11 vnwc_11 vddce_10 bl[1]_10 bl[0]_10 nbl[3]_9 nbl[2]_9 bl[2]_9 vpw_10
+  vnwc_10 vddce_9 bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8 nbl[2]_8 bl[2]_8 vnwc_9
+  vddce_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7 nbl[2]_7 bl[2]_7 vnwc_8
+  vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6 bl[2]_6 vpw_7 vddc_6
+  vddpe_6 bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw_6 vddc_5 vddce_5 bl[1]_5
+  nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc_5 vddc_4 vddce_4
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc_3 bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc_2 vddpe_2
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc_1 vddpe_1
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw_1 vddc_0 nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_r_test22row: 576 flat devices **
xmem_r_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_352 ncored01_354
+  ncored10_356 ncored11_358 ncored20_360 ncored21_362 ncored30_364
+  ncored31_366 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
.ends sram128x46mem_r_test22row
****
.subckt sram128x46mem_r_test23row vpw_13 vnwc_13 bl[3]_11 nbl[3]_11 nbl[2]_11
+  bl[2]_11 vnwc_12 vddc_11 bl[3]_10 nbl[3]_10 nbl[2]_10 vddc_10 vddpe_10
+  nbl[1]_10 nbl[0]_10 bl[3]_9 vddc_9 vddpe_9 nbl[1]_9 bl[3]_8 vpw_9 vssc
+  vddc_8 vddpe_8 bl[3]_7 vpw_8 vddc_7 vddce_7 bl[3]_6 nbl[2]_6 vnwc_7 vddce_6
+  nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc_6 vddpe_5 nbl[3]_4 vpw_5 vddpe_4
+  nbl[1]_4 vpw_4 vnwc_4 vddce_3 vddpe_3 vpw_3 vnwc_3 vddce_2 bl[3]_1 vpw_2
+  vnwc_2 vddce_1 bl[0]_1 nbl[2]_0 vnwc_1 vddce_0 vddpe_0 bl[1]_0 vnwp_1
+  vpw_12 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10
+  vpw_11 vnwc_11 vddce_10 bl[1]_10 bl[0]_10 nbl[3]_9 nbl[2]_9 bl[2]_9 vpw_10
+  vnwc_10 vddce_9 bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8 nbl[2]_8 bl[2]_8 vnwc_9
+  vddce_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7 nbl[2]_7 bl[2]_7 vnwc_8
+  vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6 bl[2]_6 vpw_7 vddc_6
+  vddpe_6 bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw_6 vddc_5 vddce_5 bl[1]_5
+  nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc_5 vddc_4 vddce_4
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc_3 bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc_2 vddpe_2
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc_1 vddpe_1
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw_1 vddc_0 nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_r_test23row: 576 flat devices **
xmem_r_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_352 ncored01_354
+  ncored10_356 ncored11_358 ncored20_360 ncored21_362 ncored30_364
+  ncored31_366 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
.ends sram128x46mem_r_test23row
****
.subckt sram128x46mem_r_bot_row vpw_13 vnwc_13 bl[3]_11 nbl[3]_11 nbl[2]_11
+  bl[2]_11 vnwc_12 vddc_11 bl[3]_10 nbl[3]_10 nbl[2]_10 vddc_10 vddpe_10
+  nbl[1]_10 nbl[0]_10 bl[3]_9 vddc_9 vddpe_9 nbl[1]_9 bl[3]_8 vpw_9 vssc
+  vddc_8 vddpe_8 bl[3]_7 vpw_8 vddc_7 vddce_7 bl[3]_6 nbl[2]_6 vnwc_7 vddce_6
+  nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc_6 vddpe_5 nbl[3]_4 vpw_5 vddpe_4
+  nbl[1]_4 vpw_4 vnwc_4 vddce_3 vddpe_3 vpw_3 vnwc_3 vddce_2 bl[3]_1 vpw_2
+  vnwc_2 vddce_1 bl[0]_1 nbl[2]_0 vsse_0 vnwc_1 vddce_0 vddpe_0 bl[1]_0
+  vnwp_1 vpw_12 vsse_1 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11
+  bl[0]_11 bl[2]_10 vpw_11 vnwc_11 vddce_10 bl[1]_10 bl[0]_10 nbl[3]_9
+  nbl[2]_9 bl[2]_9 vpw_10 vnwc_10 vddce_9 bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8
+  nbl[2]_8 bl[2]_8 vnwc_9 vddce_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7
+  nbl[2]_7 bl[2]_7 vnwc_8 vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6
+  bl[2]_6 vpw_7 vddc_6 vddpe_6 bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw_6 vddc_5
+  vddce_5 bl[1]_5 nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc_5
+  vddc_4 vddce_4 bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3
+  vddc_3 bl[1]_3 nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2
+  vddc_2 vddpe_2 bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1
+  vddc_1 vddpe_1 bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw_1
+  vddc_0 nbl[1]_0 nbl[0]_0 bl[0]_0 vnwp_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_r_bot_row: 576 flat devices **
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_bot_l bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0 ncored00_352 ncored01_354 ncored10_356
+  ncored11_358 ncored20_360 ncored21_362 ncored30_364 ncored31_366 vddc_0
+  vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vsse_0 wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_bot_r bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00 cored01 cored10
+  cored11 cored20 cored21 cored30 cored31 nbl[0]_11 nbl[1]_11 nbl[2]_11
+  nbl[3]_11 ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30
+  ncored31 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vsse_1 wl[0] wl[1]
+  sram128x46cchs4_ull
.ends sram128x46mem_r_bot_row
****
.subckt sram128x46mem_r_test24row vpw_13 vnwc_13 bl[3]_11 nbl[3]_11 nbl[2]_11
+  bl[2]_11 vnwc_12 vddc_11 bl[3]_10 nbl[3]_10 nbl[2]_10 vddc_10 vddpe_10
+  nbl[1]_10 nbl[0]_10 bl[3]_9 vddc_9 vddpe_9 nbl[1]_9 bl[3]_8 vpw_9 vssc
+  vddc_8 vddpe_8 bl[3]_7 vpw_8 vddc_7 vddce_7 bl[3]_6 nbl[2]_6 vnwc_7 vddce_6
+  nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc_6 vddpe_5 nbl[3]_4 vpw_5 vddpe_4
+  nbl[1]_4 vpw_4 vnwc_4 vddce_3 vddpe_3 vpw_3 vnwc_3 vddce_2 bl[3]_1 vpw_2
+  vnwc_2 vddce_1 bl[0]_1 nbl[2]_0 vnwc_1 vddce_0 vddpe_0 bl[1]_0 vnwp_1
+  vpw_12 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10
+  vpw_11 vnwc_11 vddce_10 bl[1]_10 bl[0]_10 nbl[3]_9 nbl[2]_9 bl[2]_9 vpw_10
+  vnwc_10 vddce_9 bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8 nbl[2]_8 bl[2]_8 vnwc_9
+  vddce_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7 nbl[2]_7 bl[2]_7 vnwc_8
+  vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6 bl[2]_6 vpw_7 vddc_6
+  vddpe_6 bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw_6 vddc_5 vddce_5 bl[1]_5
+  nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc_5 vddc_4 vddce_4
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc_3 bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc_2 vddpe_2
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc_1 vddpe_1
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw_1 vddc_0 nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_r_test24row: 576 flat devices **
xmem_r_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_352 ncored01_354
+  ncored10_356 ncored11_358 ncored20_360 ncored21_362 ncored30_364
+  ncored31_366 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
.ends sram128x46mem_r_test24row
****
.subckt sram128x46mem_r_test25row vpw_13 vnwc_13 bl[3]_11 nbl[3]_11 nbl[2]_11
+  bl[2]_11 vnwc_12 vddc_11 bl[3]_10 nbl[3]_10 nbl[2]_10 vddc_10 vddpe_10
+  nbl[1]_10 nbl[0]_10 bl[3]_9 vddc_9 vddpe_9 nbl[1]_9 bl[3]_8 vpw_9 vssc
+  vddc_8 vddpe_8 bl[3]_7 vpw_8 vddc_7 vddce_7 bl[3]_6 nbl[2]_6 vnwc_7 vddce_6
+  nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc_6 vddpe_5 nbl[3]_4 vpw_5 vddpe_4
+  nbl[1]_4 vpw_4 vnwc_4 vddce_3 vddpe_3 vpw_3 vnwc_3 vddce_2 bl[3]_1 vpw_2
+  vnwc_2 vddce_1 bl[0]_1 nbl[2]_0 vnwc_1 vddce_0 vddpe_0 bl[1]_0 vnwp_1
+  vpw_12 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10
+  vpw_11 vnwc_11 vddce_10 bl[1]_10 bl[0]_10 nbl[3]_9 nbl[2]_9 bl[2]_9 vpw_10
+  vnwc_10 vddce_9 bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8 nbl[2]_8 bl[2]_8 vnwc_9
+  vddce_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7 nbl[2]_7 bl[2]_7 vnwc_8
+  vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6 bl[2]_6 vpw_7 vddc_6
+  vddpe_6 bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw_6 vddc_5 vddce_5 bl[1]_5
+  nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc_5 vddc_4 vddce_4
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc_3 bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc_2 vddpe_2
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc_1 vddpe_1
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw_1 vddc_0 nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_r_test25row: 576 flat devices **
xmem_r_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_352 ncored01_354
+  ncored10_356 ncored11_358 ncored20_360 ncored21_362 ncored30_364
+  ncored31_366 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
.ends sram128x46mem_r_test25row
****
.subckt sram128x46mem_r_test26row vpw_13 vnwc_13 bl[3]_11 nbl[3]_11 nbl[2]_11
+  bl[2]_11 vnwc_12 vddc_11 bl[3]_10 nbl[3]_10 nbl[2]_10 vddc_10 vddpe_10
+  nbl[1]_10 nbl[0]_10 bl[3]_9 vddc_9 vddpe_9 nbl[1]_9 bl[3]_8 vpw_9 vssc
+  vddc_8 vddpe_8 bl[3]_7 vpw_8 vddc_7 vddce_7 bl[3]_6 nbl[2]_6 vnwc_7 vddce_6
+  nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc_6 vddpe_5 nbl[3]_4 vpw_5 vddpe_4
+  nbl[1]_4 vpw_4 vnwc_4 vddce_3 vddpe_3 vpw_3 vnwc_3 vddce_2 bl[3]_1 vpw_2
+  vnwc_2 vddce_1 bl[0]_1 nbl[2]_0 vnwc_1 vddce_0 vddpe_0 bl[1]_0 vnwp_1
+  vpw_12 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10
+  vpw_11 vnwc_11 vddce_10 bl[1]_10 bl[0]_10 nbl[3]_9 nbl[2]_9 bl[2]_9 vpw_10
+  vnwc_10 vddce_9 bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8 nbl[2]_8 bl[2]_8 vnwc_9
+  vddce_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7 nbl[2]_7 bl[2]_7 vnwc_8
+  vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6 bl[2]_6 vpw_7 vddc_6
+  vddpe_6 bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw_6 vddc_5 vddce_5 bl[1]_5
+  nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc_5 vddc_4 vddce_4
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc_3 bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc_2 vddpe_2
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc_1 vddpe_1
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw_1 vddc_0 nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_r_test26row: 576 flat devices **
xmem_r_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_352 ncored01_354
+  ncored10_356 ncored11_358 ncored20_360 ncored21_362 ncored30_364
+  ncored31_366 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
.ends sram128x46mem_r_test26row
****
.subckt sram128x46mem_r_test27row vpw_13 vnwc_13 bl[3]_11 nbl[3]_11 nbl[2]_11
+  bl[2]_11 vnwc_12 vddc_11 bl[3]_10 nbl[3]_10 nbl[2]_10 vddc_10 vddpe_10
+  nbl[1]_10 nbl[0]_10 bl[3]_9 vddc_9 vddpe_9 nbl[1]_9 bl[3]_8 vpw_9 vssc
+  vddc_8 vddpe_8 bl[3]_7 vpw_8 vddc_7 vddce_7 bl[3]_6 nbl[2]_6 vnwc_7 vddce_6
+  nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc_6 vddpe_5 nbl[3]_4 vpw_5 vddpe_4
+  nbl[1]_4 vpw_4 vnwc_4 vddce_3 vddpe_3 vpw_3 vnwc_3 vddce_2 bl[3]_1 vpw_2
+  vnwc_2 vddce_1 bl[0]_1 nbl[2]_0 vnwc_1 vddce_0 vddpe_0 bl[1]_0 vnwp_1
+  vpw_12 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10
+  vpw_11 vnwc_11 vddce_10 bl[1]_10 bl[0]_10 nbl[3]_9 nbl[2]_9 bl[2]_9 vpw_10
+  vnwc_10 vddce_9 bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8 nbl[2]_8 bl[2]_8 vnwc_9
+  vddce_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7 nbl[2]_7 bl[2]_7 vnwc_8
+  vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6 bl[2]_6 vpw_7 vddc_6
+  vddpe_6 bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw_6 vddc_5 vddce_5 bl[1]_5
+  nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc_5 vddc_4 vddce_4
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc_3 bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc_2 vddpe_2
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc_1 vddpe_1
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw_1 vddc_0 nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_r_test27row: 576 flat devices **
xmem_r_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_352 ncored01_354
+  ncored10_356 ncored11_358 ncored20_360 ncored21_362 ncored30_364
+  ncored31_366 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
.ends sram128x46mem_r_test27row
****
.subckt sram128x46mem_r_test28row vpw_13 vnwc_13 bl[3]_11 nbl[3]_11 nbl[2]_11
+  bl[2]_11 vnwc_12 vddc_11 bl[3]_10 nbl[3]_10 nbl[2]_10 vddc_10 vddpe_10
+  nbl[1]_10 nbl[0]_10 bl[3]_9 vddc_9 vddpe_9 nbl[1]_9 bl[3]_8 vpw_9 vssc
+  vddc_8 vddpe_8 bl[3]_7 vpw_8 vddc_7 vddce_7 bl[3]_6 nbl[2]_6 vnwc_7 vddce_6
+  nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc_6 vddpe_5 nbl[3]_4 vpw_5 vddpe_4
+  nbl[1]_4 vpw_4 vnwc_4 vddce_3 vddpe_3 vpw_3 vnwc_3 vddce_2 bl[3]_1 vpw_2
+  vnwc_2 vddce_1 bl[0]_1 nbl[2]_0 vnwc_1 vddce_0 vddpe_0 bl[1]_0 vnwp_1
+  vpw_12 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10
+  vpw_11 vnwc_11 vddce_10 bl[1]_10 bl[0]_10 nbl[3]_9 nbl[2]_9 bl[2]_9 vpw_10
+  vnwc_10 vddce_9 bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8 nbl[2]_8 bl[2]_8 vnwc_9
+  vddce_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7 nbl[2]_7 bl[2]_7 vnwc_8
+  vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6 bl[2]_6 vpw_7 vddc_6
+  vddpe_6 bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw_6 vddc_5 vddce_5 bl[1]_5
+  nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc_5 vddc_4 vddce_4
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc_3 bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc_2 vddpe_2
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc_1 vddpe_1
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw_1 vddc_0 nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_r_test28row: 576 flat devices **
xmem_r_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_352 ncored01_354
+  ncored10_356 ncored11_358 ncored20_360 ncored21_362 ncored30_364
+  ncored31_366 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
.ends sram128x46mem_r_test28row
****
.subckt sram128x46mem_r_test29row vpw_13 vnwc_13 bl[3]_11 nbl[3]_11 nbl[2]_11
+  bl[2]_11 vnwc_12 vddc_11 bl[3]_10 nbl[3]_10 nbl[2]_10 vddc_10 vddpe_10
+  nbl[1]_10 nbl[0]_10 bl[3]_9 vddc_9 vddpe_9 nbl[1]_9 bl[3]_8 vpw_9 vssc
+  vddc_8 vddpe_8 bl[3]_7 vpw_8 vddc_7 vddce_7 bl[3]_6 nbl[2]_6 vnwc_7 vddce_6
+  nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc_6 vddpe_5 nbl[3]_4 vpw_5 vddpe_4
+  nbl[1]_4 vpw_4 vnwc_4 vddce_3 vddpe_3 vpw_3 vnwc_3 vddce_2 bl[3]_1 vpw_2
+  vnwc_2 vddce_1 bl[0]_1 nbl[2]_0 vnwc_1 vddce_0 vddpe_0 bl[1]_0 vnwp_1
+  vpw_12 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10
+  vpw_11 vnwc_11 vddce_10 bl[1]_10 bl[0]_10 nbl[3]_9 nbl[2]_9 bl[2]_9 vpw_10
+  vnwc_10 vddce_9 bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8 nbl[2]_8 bl[2]_8 vnwc_9
+  vddce_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7 nbl[2]_7 bl[2]_7 vnwc_8
+  vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6 bl[2]_6 vpw_7 vddc_6
+  vddpe_6 bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw_6 vddc_5 vddce_5 bl[1]_5
+  nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc_5 vddc_4 vddce_4
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc_3 bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc_2 vddpe_2
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc_1 vddpe_1
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw_1 vddc_0 nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_r_test29row: 576 flat devices **
xmem_r_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_352 ncored01_354
+  ncored10_356 ncored11_358 ncored20_360 ncored21_362 ncored30_364
+  ncored31_366 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
.ends sram128x46mem_r_test29row
****
.subckt sram128x46mem_r_test1row vpw_13 vnwc_13 bl[3]_11 nbl[3]_11 nbl[2]_11
+  bl[2]_11 vnwc_12 vddc_11 bl[3]_10 nbl[3]_10 nbl[2]_10 vddc_10 vddpe_10
+  nbl[1]_10 nbl[0]_10 bl[3]_9 vddc_9 vddpe_9 nbl[1]_9 bl[3]_8 vpw_9 vssc
+  vddc_8 vddpe_8 bl[3]_7 vpw_8 vddc_7 vddce_7 bl[3]_6 nbl[2]_6 vnwc_7 vddce_6
+  nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc_6 vddpe_5 nbl[3]_4 vpw_5 vddpe_4
+  nbl[1]_4 vpw_4 vnwc_4 vddce_3 vddpe_3 vpw_3 vnwc_3 vddce_2 bl[3]_1 vpw_2
+  vnwc_2 vddce_1 bl[0]_1 nbl[2]_0 vnwc_1 vddce_0 vddpe_0 bl[1]_0 vnwp_1
+  vpw_12 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10
+  vpw_11 vnwc_11 vddce_10 bl[1]_10 bl[0]_10 nbl[3]_9 nbl[2]_9 bl[2]_9 vpw_10
+  vnwc_10 vddce_9 bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8 nbl[2]_8 bl[2]_8 vnwc_9
+  vddce_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7 nbl[2]_7 bl[2]_7 vnwc_8
+  vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6 bl[2]_6 vpw_7 vddc_6
+  vddpe_6 bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw_6 vddc_5 vddce_5 bl[1]_5
+  nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc_5 vddc_4 vddce_4
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc_3 bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc_2 vddpe_2
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc_1 vddpe_1
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw_1 vddc_0 nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_r_test1row: 576 flat devices **
xmem_r_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_352 ncored01_354
+  ncored10_356 ncored11_358 ncored20_360 ncored21_362 ncored30_364
+  ncored31_366 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
.ends sram128x46mem_r_test1row
****
.subckt sram128x46mem_r_test2row vpw_13 vnwc_13 bl[3]_11 nbl[3]_11 nbl[2]_11
+  bl[2]_11 vnwc_12 vddc_11 bl[3]_10 nbl[3]_10 nbl[2]_10 vddc_10 vddpe_10
+  nbl[1]_10 nbl[0]_10 bl[3]_9 vddc_9 vddpe_9 nbl[1]_9 bl[3]_8 vpw_9 vssc
+  vddc_8 vddpe_8 bl[3]_7 vpw_8 vddc_7 vddce_7 bl[3]_6 nbl[2]_6 vnwc_7 vddce_6
+  nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc_6 vddpe_5 nbl[3]_4 vpw_5 vddpe_4
+  nbl[1]_4 vpw_4 vnwc_4 vddce_3 vddpe_3 vpw_3 vnwc_3 vddce_2 bl[3]_1 vpw_2
+  vnwc_2 vddce_1 bl[0]_1 nbl[2]_0 vnwc_1 vddce_0 vddpe_0 bl[1]_0 vnwp_1
+  vpw_12 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10
+  vpw_11 vnwc_11 vddce_10 bl[1]_10 bl[0]_10 nbl[3]_9 nbl[2]_9 bl[2]_9 vpw_10
+  vnwc_10 vddce_9 bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8 nbl[2]_8 bl[2]_8 vnwc_9
+  vddce_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7 nbl[2]_7 bl[2]_7 vnwc_8
+  vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6 bl[2]_6 vpw_7 vddc_6
+  vddpe_6 bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw_6 vddc_5 vddce_5 bl[1]_5
+  nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc_5 vddc_4 vddce_4
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc_3 bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc_2 vddpe_2
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc_1 vddpe_1
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw_1 vddc_0 nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_r_test2row: 576 flat devices **
xmem_r_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_352 ncored01_354
+  ncored10_356 ncored11_358 ncored20_360 ncored21_362 ncored30_364
+  ncored31_366 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
.ends sram128x46mem_r_test2row
****
.subckt sram128x46mem_r_top_row vpw_13 vnwc_13 bl[3]_11 nbl[3]_11 nbl[2]_11
+  bl[2]_11 vnwc_12 vddc_11 bl[3]_10 nbl[3]_10 nbl[2]_10 vddc_10 vddpe_10
+  nbl[1]_10 nbl[0]_10 bl[3]_9 vddc_9 vddpe_9 nbl[1]_9 bl[3]_8 vpw_9 vssc
+  vddc_8 vddpe_8 bl[3]_7 vpw_8 vddc_7 vddce_7 bl[3]_6 nbl[2]_6 vnwc_7 vddce_6
+  nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc_6 vddpe_5 nbl[3]_4 vpw_5 vddpe_4
+  nbl[1]_4 vpw_4 vnwc_4 vddce_3 vddpe_3 vpw_3 vnwc_3 vddce_2 bl[3]_1 vpw_2
+  vnwc_2 vddce_1 bl[0]_1 nbl[2]_0 vsse_0 vnwc_1 vddce_0 vddpe_0 bl[1]_0
+  vnwp_1 vpw_12 vsse_1 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11
+  bl[0]_11 bl[2]_10 vpw_11 vnwc_11 vddce_10 bl[1]_10 bl[0]_10 nbl[3]_9
+  nbl[2]_9 bl[2]_9 vpw_10 vnwc_10 vddce_9 bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8
+  nbl[2]_8 bl[2]_8 vnwc_9 vddce_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7
+  nbl[2]_7 bl[2]_7 vnwc_8 vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6
+  bl[2]_6 vpw_7 vddc_6 vddpe_6 bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw_6 vddc_5
+  vddce_5 bl[1]_5 nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc_5
+  vddc_4 vddce_4 bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3
+  vddc_3 bl[1]_3 nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2
+  vddc_2 vddpe_2 bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1
+  vddc_1 vddpe_1 bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw_1
+  vddc_0 nbl[1]_0 nbl[0]_0 bl[0]_0 vnwp_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_r_top_row: 576 flat devices **
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_352 ncored01_354
+  ncored10_356 ncored11_358 ncored20_360 ncored21_362 ncored30_364
+  ncored31_366 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_3 nbl[1]_3 nbl[2]_3 nbl[3]_3 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_3
+  vddce_3 vddpe_3 vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_320 ncored01_322 ncored10_324
+  ncored11_326 ncored20_328 ncored21_330 ncored30_332 ncored31_334 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_top_l bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10
+  cored11 cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vsse_0 wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_top_r bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_16 cored01_18
+  cored10_20 cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_11
+  nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_32 ncored01_34 ncored10_36
+  ncored11_38 ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_11
+  vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vsse_1 wl[0] wl[1]
+  sram128x46cchs4_ull
.ends sram128x46mem_r_top_row
****
.subckt sram128x46mem_r_test3row vpw_13 vnwc_13 bl[3]_11 nbl[3]_11 nbl[2]_11
+  bl[2]_11 vnwc_12 vddc_11 bl[3]_10 nbl[3]_10 nbl[2]_10 vddc_10 vddpe_10
+  nbl[1]_10 nbl[0]_10 bl[3]_9 vddc_9 vddpe_9 nbl[1]_9 bl[3]_8 vpw_9 vssc
+  vddc_8 vddpe_8 bl[3]_7 vpw_8 vddc_7 vddce_7 bl[3]_6 nbl[2]_6 vnwc_7 vddce_6
+  nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc_6 vddpe_5 nbl[3]_4 vpw_5 vddpe_4
+  nbl[1]_4 vpw_4 vnwc_4 vddce_3 vddpe_3 vpw_3 vnwc_3 vddce_2 bl[3]_1 vpw_2
+  vnwc_2 vddce_1 bl[0]_1 nbl[2]_0 vnwc_1 vddce_0 vddpe_0 bl[1]_0 vnwp_1
+  vpw_12 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10
+  vpw_11 vnwc_11 vddce_10 bl[1]_10 bl[0]_10 nbl[3]_9 nbl[2]_9 bl[2]_9 vpw_10
+  vnwc_10 vddce_9 bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8 nbl[2]_8 bl[2]_8 vnwc_9
+  vddce_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7 nbl[2]_7 bl[2]_7 vnwc_8
+  vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6 bl[2]_6 vpw_7 vddc_6
+  vddpe_6 bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw_6 vddc_5 vddce_5 bl[1]_5
+  nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc_5 vddc_4 vddce_4
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc_3 bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc_2 vddpe_2
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc_1 vddpe_1
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw_1 vddc_0 nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_r_test3row: 576 flat devices **
xmem_r_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_352 ncored01_354
+  ncored10_356 ncored11_358 ncored20_360 ncored21_362 ncored30_364
+  ncored31_366 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
.ends sram128x46mem_r_test3row
****
.subckt sram128x46mem_r_test4row vpw_13 vnwc_13 bl[3]_11 nbl[3]_11 nbl[2]_11
+  bl[2]_11 vnwc_12 vddc_11 bl[3]_10 nbl[3]_10 nbl[2]_10 vddc_10 vddpe_10
+  nbl[1]_10 nbl[0]_10 bl[3]_9 vddc_9 vddpe_9 nbl[1]_9 bl[3]_8 vpw_9 vssc
+  vddc_8 vddpe_8 bl[3]_7 vpw_8 vddc_7 vddce_7 bl[3]_6 nbl[2]_6 vnwc_7 vddce_6
+  nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc_6 vddpe_5 nbl[3]_4 vpw_5 vddpe_4
+  nbl[1]_4 vpw_4 vnwc_4 vddce_3 vddpe_3 vpw_3 vnwc_3 vddce_2 bl[3]_1 vpw_2
+  vnwc_2 vddce_1 bl[0]_1 nbl[2]_0 vnwc_1 vddce_0 vddpe_0 bl[1]_0 vnwp_1
+  vpw_12 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10
+  vpw_11 vnwc_11 vddce_10 bl[1]_10 bl[0]_10 nbl[3]_9 nbl[2]_9 bl[2]_9 vpw_10
+  vnwc_10 vddce_9 bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8 nbl[2]_8 bl[2]_8 vnwc_9
+  vddce_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7 nbl[2]_7 bl[2]_7 vnwc_8
+  vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6 bl[2]_6 vpw_7 vddc_6
+  vddpe_6 bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw_6 vddc_5 vddce_5 bl[1]_5
+  nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc_5 vddc_4 vddce_4
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc_3 bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc_2 vddpe_2
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc_1 vddpe_1
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw_1 vddc_0 nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_r_test4row: 576 flat devices **
xmem_r_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_352 ncored01_354
+  ncored10_356 ncored11_358 ncored20_360 ncored21_362 ncored30_364
+  ncored31_366 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
.ends sram128x46mem_r_test4row
****
.subckt sram128x46mem_r_test5row vpw_13 vnwc_13 bl[3]_11 nbl[3]_11 nbl[2]_11
+  bl[2]_11 vnwc_12 vddc_11 bl[3]_10 nbl[3]_10 nbl[2]_10 vddc_10 vddpe_10
+  nbl[1]_10 nbl[0]_10 bl[3]_9 vddc_9 vddpe_9 nbl[1]_9 bl[3]_8 vpw_9 vssc
+  vddc_8 vddpe_8 bl[3]_7 vpw_8 vddc_7 vddce_7 bl[3]_6 nbl[2]_6 vnwc_7 vddce_6
+  nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc_6 vddpe_5 nbl[3]_4 vpw_5 vddpe_4
+  nbl[1]_4 vpw_4 vnwc_4 vddce_3 vddpe_3 vpw_3 vnwc_3 vddce_2 bl[3]_1 vpw_2
+  vnwc_2 vddce_1 bl[0]_1 nbl[2]_0 vnwc_1 vddce_0 vddpe_0 bl[1]_0 vnwp_1
+  vpw_12 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10
+  vpw_11 vnwc_11 vddce_10 bl[1]_10 bl[0]_10 nbl[3]_9 nbl[2]_9 bl[2]_9 vpw_10
+  vnwc_10 vddce_9 bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8 nbl[2]_8 bl[2]_8 vnwc_9
+  vddce_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7 nbl[2]_7 bl[2]_7 vnwc_8
+  vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6 bl[2]_6 vpw_7 vddc_6
+  vddpe_6 bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw_6 vddc_5 vddce_5 bl[1]_5
+  nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc_5 vddc_4 vddce_4
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc_3 bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc_2 vddpe_2
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc_1 vddpe_1
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw_1 vddc_0 nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_r_test5row: 576 flat devices **
xmem_r_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_352 ncored01_354
+  ncored10_356 ncored11_358 ncored20_360 ncored21_362 ncored30_364
+  ncored31_366 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
.ends sram128x46mem_r_test5row
****
.subckt sram128x46mem_r_test6row vpw_13 vnwc_13 bl[3]_11 nbl[3]_11 nbl[2]_11
+  bl[2]_11 vnwc_12 vddc_11 bl[3]_10 nbl[3]_10 nbl[2]_10 vddc_10 vddpe_10
+  nbl[1]_10 nbl[0]_10 bl[3]_9 vddc_9 vddpe_9 nbl[1]_9 bl[3]_8 vpw_9 vssc
+  vddc_8 vddpe_8 bl[3]_7 vpw_8 vddc_7 vddce_7 bl[3]_6 nbl[2]_6 vnwc_7 vddce_6
+  nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc_6 vddpe_5 nbl[3]_4 vpw_5 vddpe_4
+  nbl[1]_4 vpw_4 vnwc_4 vddce_3 vddpe_3 vpw_3 vnwc_3 vddce_2 bl[3]_1 vpw_2
+  vnwc_2 vddce_1 bl[0]_1 nbl[2]_0 vnwc_1 vddce_0 vddpe_0 bl[1]_0 vnwp_1
+  vpw_12 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10
+  vpw_11 vnwc_11 vddce_10 bl[1]_10 bl[0]_10 nbl[3]_9 nbl[2]_9 bl[2]_9 vpw_10
+  vnwc_10 vddce_9 bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8 nbl[2]_8 bl[2]_8 vnwc_9
+  vddce_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7 nbl[2]_7 bl[2]_7 vnwc_8
+  vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6 bl[2]_6 vpw_7 vddc_6
+  vddpe_6 bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw_6 vddc_5 vddce_5 bl[1]_5
+  nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc_5 vddc_4 vddce_4
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc_3 bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc_2 vddpe_2
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc_1 vddpe_1
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw_1 vddc_0 nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_r_test6row: 576 flat devices **
xmem_r_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_352 ncored01_354
+  ncored10_356 ncored11_358 ncored20_360 ncored21_362 ncored30_364
+  ncored31_366 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
.ends sram128x46mem_r_test6row
****
.subckt sram128x46mem_r_test7row vpw_13 vnwc_13 bl[3]_11 nbl[3]_11 nbl[2]_11
+  bl[2]_11 vnwc_12 vddc_11 bl[3]_10 nbl[3]_10 nbl[2]_10 vddc_10 vddpe_10
+  nbl[1]_10 nbl[0]_10 bl[3]_9 vddc_9 vddpe_9 nbl[1]_9 bl[3]_8 vpw_9 vssc
+  vddc_8 vddpe_8 bl[3]_7 vpw_8 vddc_7 vddce_7 bl[3]_6 nbl[2]_6 vnwc_7 vddce_6
+  nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc_6 vddpe_5 nbl[3]_4 vpw_5 vddpe_4
+  nbl[1]_4 vpw_4 vnwc_4 vddce_3 vddpe_3 vpw_3 vnwc_3 vddce_2 bl[3]_1 vpw_2
+  vnwc_2 vddce_1 bl[0]_1 nbl[2]_0 vnwc_1 vddce_0 vddpe_0 bl[1]_0 vnwp_1
+  vpw_12 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10
+  vpw_11 vnwc_11 vddce_10 bl[1]_10 bl[0]_10 nbl[3]_9 nbl[2]_9 bl[2]_9 vpw_10
+  vnwc_10 vddce_9 bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8 nbl[2]_8 bl[2]_8 vnwc_9
+  vddce_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7 nbl[2]_7 bl[2]_7 vnwc_8
+  vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6 bl[2]_6 vpw_7 vddc_6
+  vddpe_6 bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw_6 vddc_5 vddce_5 bl[1]_5
+  nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc_5 vddc_4 vddce_4
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc_3 bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc_2 vddpe_2
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc_1 vddpe_1
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw_1 vddc_0 nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_r_test7row: 576 flat devices **
xmem_r_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_352 ncored01_354
+  ncored10_356 ncored11_358 ncored20_360 ncored21_362 ncored30_364
+  ncored31_366 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
.ends sram128x46mem_r_test7row
****
.subckt sram128x46mem_r_test8row vpw_13 vnwc_13 bl[3]_11 nbl[3]_11 nbl[2]_11
+  bl[2]_11 vnwc_12 vddc_11 bl[3]_10 nbl[3]_10 nbl[2]_10 vddc_10 vddpe_10
+  nbl[1]_10 nbl[0]_10 bl[3]_9 vddc_9 vddpe_9 nbl[1]_9 bl[3]_8 vpw_9 vssc
+  vddc_8 vddpe_8 bl[3]_7 vpw_8 vddc_7 vddce_7 bl[3]_6 nbl[2]_6 vnwc_7 vddce_6
+  nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc_6 vddpe_5 nbl[3]_4 vpw_5 vddpe_4
+  nbl[1]_4 vpw_4 vnwc_4 vddce_3 vddpe_3 vpw_3 vnwc_3 vddce_2 bl[3]_1 vpw_2
+  vnwc_2 vddce_1 bl[0]_1 nbl[2]_0 vnwc_1 vddce_0 vddpe_0 bl[1]_0 vnwp_1
+  vpw_12 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10
+  vpw_11 vnwc_11 vddce_10 bl[1]_10 bl[0]_10 nbl[3]_9 nbl[2]_9 bl[2]_9 vpw_10
+  vnwc_10 vddce_9 bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8 nbl[2]_8 bl[2]_8 vnwc_9
+  vddce_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7 nbl[2]_7 bl[2]_7 vnwc_8
+  vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6 bl[2]_6 vpw_7 vddc_6
+  vddpe_6 bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw_6 vddc_5 vddce_5 bl[1]_5
+  nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc_5 vddc_4 vddce_4
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc_3 bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc_2 vddpe_2
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc_1 vddpe_1
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw_1 vddc_0 nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_r_test8row: 576 flat devices **
xmem_r_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_352 ncored01_354
+  ncored10_356 ncored11_358 ncored20_360 ncored21_362 ncored30_364
+  ncored31_366 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
.ends sram128x46mem_r_test8row
****
.subckt sram128x46mem_r_test9row vpw_13 vnwc_13 bl[3]_11 nbl[3]_11 nbl[2]_11
+  bl[2]_11 vnwc_12 vddc_11 bl[3]_10 nbl[3]_10 nbl[2]_10 vddc_10 vddpe_10
+  nbl[1]_10 nbl[0]_10 bl[3]_9 vddc_9 vddpe_9 nbl[1]_9 bl[3]_8 vpw_9 vssc
+  vddc_8 vddpe_8 bl[3]_7 vpw_8 vddc_7 vddce_7 bl[3]_6 nbl[2]_6 vnwc_7 vddce_6
+  nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc_6 vddpe_5 nbl[3]_4 vpw_5 vddpe_4
+  nbl[1]_4 vpw_4 vnwc_4 vddce_3 vddpe_3 vpw_3 vnwc_3 vddce_2 bl[3]_1 vpw_2
+  vnwc_2 vddce_1 bl[0]_1 nbl[2]_0 vnwc_1 vddce_0 vddpe_0 bl[1]_0 vnwp_1
+  vpw_12 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10
+  vpw_11 vnwc_11 vddce_10 bl[1]_10 bl[0]_10 nbl[3]_9 nbl[2]_9 bl[2]_9 vpw_10
+  vnwc_10 vddce_9 bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8 nbl[2]_8 bl[2]_8 vnwc_9
+  vddce_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7 nbl[2]_7 bl[2]_7 vnwc_8
+  vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6 bl[2]_6 vpw_7 vddc_6
+  vddpe_6 bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw_6 vddc_5 vddce_5 bl[1]_5
+  nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc_5 vddc_4 vddce_4
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc_3 bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc_2 vddpe_2
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc_1 vddpe_1
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw_1 vddc_0 nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_r_test9row: 576 flat devices **
xmem_r_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_352 ncored01_354
+  ncored10_356 ncored11_358 ncored20_360 ncored21_362 ncored30_364
+  ncored31_366 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
.ends sram128x46mem_r_test9row
****
.subckt sram128x46memcore_r nbl[2]_11 bl[1]_11 nbl[0]_11 bl[0]_11 nbl[3]_10
+  nbl[1]_10 bl[0]_10 nbl[0]_9 bl[0]_9 nbl[2]_8 bl[2]_8 bl[1]_8 nbl[1]_8
+  bl[0]_8 bl[3]_7 nbl[3]_7 nbl[2]_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7
+  nbl[3]_6 nbl[2]_6 vnwc nbl[1]_6 nbl[0]_6 nbl[3]_5 nbl[1]_5 nbl[0]_5 bl[2]_4
+  vpw bl[3]_3 bl[2]_3 vssc bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[1]_2 nbl[0]_2
+  bl[0]_2 nbl[3]_1 nbl[2]_1 nbl[1]_1 nbl[0]_1 nbl[1]_0 vnwp_1 bl[3]_11
+  nbl[3]_11 bl[2]_11 nbl[1]_11 bl[3]_10 nbl[2]_10 bl[2]_10 bl[1]_10 nbl[0]_10
+  bl[3]_9 nbl[3]_9 nbl[2]_9 bl[2]_9 bl[1]_9 nbl[1]_9 bl[3]_8 nbl[3]_8 vddc
+  nbl[0]_8 bl[2]_7 bl[3]_6 bl[2]_6 bl[1]_6 bl[0]_6 bl[3]_5 nbl[2]_5 bl[2]_5
+  bl[1]_5 bl[0]_5 bl[3]_4 nbl[3]_4 nbl[2]_4 bl[1]_4 nbl[1]_4 nbl[0]_4 bl[0]_4
+  nbl[3]_3 nbl[2]_3 vddpe bl[1]_3 nbl[1]_3 nbl[0]_3 bl[2]_2 nbl[1]_2 bl[3]_1
+  bl[2]_1 bl[1]_1 bl[0]_1 bl[3]_0 nbl[3]_0 nbl[2]_0 bl[2]_0 bl[1]_0 nbl[0]_0
+  bl[0]_0 vnwp_0 wl[1]_31 wl[0]_31 wl[1]_30 wl[0]_30 wl[1]_29 wl[0]_29
+  wl[1]_28 wl[0]_28 wl[1]_27 wl[0]_27 wl[1]_26 wl[0]_26 wl[1]_25 wl[0]_25
+  wl[1]_24 wl[0]_24 wl[1]_23 wl[0]_23 wl[1]_22 wl[0]_22 wl[1]_21 wl[0]_21
+  wl[1]_20 wl[0]_20 wl[1]_19 wl[0]_19 wl[1]_18 wl[0]_18 wl[1]_17 wl[0]_17
+  wl[1]_16 wl[0]_16 wl[1]_15 wl[0]_15 wl[1]_14 wl[0]_14 wl[1]_13 wl[0]_13
+  wl[1]_12 wl[0]_12 wl[1]_11 wl[0]_11 wl[1]_10 wl[0]_10 wl[1]_9 wl[0]_9
+  wl[1]_8 wl[0]_8 wl[1]_7 wl[0]_7 wl[1]_6 wl[0]_6 wl[1]_5 wl[0]_5 wl[1]_4
+  wl[0]_4 wl[1]_3 wl[0]_3 wl[1]_2 wl[0]_2 wl[1]_1 wl[0]_1 wl[1]_0 wl[0]_0
+  actp vss
** sram128x46memcore_r: 18432 flat devices **
xmem_r_row_1 vpw vnwc bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 vnwc vddc bl[3]_10
+  nbl[3]_10 nbl[2]_10 vddc vddpe nbl[1]_10 nbl[0]_10 bl[3]_9 vddc vddpe
+  nbl[1]_9 bl[3]_8 vpw vssc vddc vddpe bl[3]_7 vpw vddc vddc bl[3]_6 nbl[2]_6
+  vnwc vddc nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc vddpe nbl[3]_4 vpw vddpe
+  nbl[1]_4 vpw vnwc vddc vddpe vpw vnwc vddc bl[3]_1 vpw vnwc vddc bl[0]_1
+  nbl[2]_0 vnwc vddc vddpe bl[1]_0 vnwp_1 vpw vddc vddpe bl[1]_11 nbl[1]_11
+  nbl[0]_11 bl[0]_11 bl[2]_10 vpw vnwc vddc bl[1]_10 bl[0]_10 nbl[3]_9
+  nbl[2]_9 bl[2]_9 vpw vnwc vddc bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8 nbl[2]_8
+  bl[2]_8 vnwc vddc bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7 nbl[2]_7
+  bl[2]_7 vnwc vddpe bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6 bl[2]_6 vpw
+  vddc vddpe bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw vddc vddc bl[1]_5 nbl[1]_5
+  nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc vddc vddc bl[1]_4 nbl[0]_4
+  bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc bl[1]_3 nbl[1]_3 nbl[0]_3
+  bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc vddpe bl[1]_2 nbl[1]_2
+  nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc vddpe bl[1]_1 nbl[1]_1
+  nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw vddc nbl[1]_0 nbl[0]_0 bl[0]_0 vnwp_0
+  vnwc vpw wl[1]_1 wl[0]_1 sram128x46mem_r_test1row
xmem_r_row_10 vpw vnwc bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 vnwc vddc
+  bl[3]_10 nbl[3]_10 nbl[2]_10 vddc vddpe nbl[1]_10 nbl[0]_10 bl[3]_9 vddc
+  vddpe nbl[1]_9 bl[3]_8 vpw vssc vddc vddpe bl[3]_7 vpw vddc vddc bl[3]_6
+  nbl[2]_6 vnwc vddc nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc vddpe nbl[3]_4
+  vpw vddpe nbl[1]_4 vpw vnwc vddc vddpe vpw vnwc vddc bl[3]_1 vpw vnwc vddc
+  bl[0]_1 nbl[2]_0 vnwc vddc vddpe bl[1]_0 vnwp_1 vpw vddc vddpe bl[1]_11
+  nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10 vpw vnwc vddc bl[1]_10 bl[0]_10
+  nbl[3]_9 nbl[2]_9 bl[2]_9 vpw vnwc vddc bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8
+  nbl[2]_8 bl[2]_8 vnwc vddc bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7
+  nbl[2]_7 bl[2]_7 vnwc vddpe bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6
+  bl[2]_6 vpw vddc vddpe bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw vddc vddc
+  bl[1]_5 nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc vddc vddc
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc vddpe
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc vddpe
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw vddc nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc vpw wl[1]_10 wl[0]_10
+  sram128x46mem_r_test10row
xmem_r_row_11 vpw vnwc bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 vnwc vddc
+  bl[3]_10 nbl[3]_10 nbl[2]_10 vddc vddpe nbl[1]_10 nbl[0]_10 bl[3]_9 vddc
+  vddpe nbl[1]_9 bl[3]_8 vpw vssc vddc vddpe bl[3]_7 vpw vddc vddc bl[3]_6
+  nbl[2]_6 vnwc vddc nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc vddpe nbl[3]_4
+  vpw vddpe nbl[1]_4 vpw vnwc vddc vddpe vpw vnwc vddc bl[3]_1 vpw vnwc vddc
+  bl[0]_1 nbl[2]_0 vnwc vddc vddpe bl[1]_0 vnwp_1 vpw vddc vddpe bl[1]_11
+  nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10 vpw vnwc vddc bl[1]_10 bl[0]_10
+  nbl[3]_9 nbl[2]_9 bl[2]_9 vpw vnwc vddc bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8
+  nbl[2]_8 bl[2]_8 vnwc vddc bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7
+  nbl[2]_7 bl[2]_7 vnwc vddpe bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6
+  bl[2]_6 vpw vddc vddpe bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw vddc vddc
+  bl[1]_5 nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc vddc vddc
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc vddpe
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc vddpe
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw vddc nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc vpw wl[1]_11 wl[0]_11
+  sram128x46mem_r_test11row
xmem_r_row_12 vpw vnwc bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 vnwc vddc
+  bl[3]_10 nbl[3]_10 nbl[2]_10 vddc vddpe nbl[1]_10 nbl[0]_10 bl[3]_9 vddc
+  vddpe nbl[1]_9 bl[3]_8 vpw vssc vddc vddpe bl[3]_7 vpw vddc vddc bl[3]_6
+  nbl[2]_6 vnwc vddc nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc vddpe nbl[3]_4
+  vpw vddpe nbl[1]_4 vpw vnwc vddc vddpe vpw vnwc vddc bl[3]_1 vpw vnwc vddc
+  bl[0]_1 nbl[2]_0 vnwc vddc vddpe bl[1]_0 vnwp_1 vpw vddc vddpe bl[1]_11
+  nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10 vpw vnwc vddc bl[1]_10 bl[0]_10
+  nbl[3]_9 nbl[2]_9 bl[2]_9 vpw vnwc vddc bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8
+  nbl[2]_8 bl[2]_8 vnwc vddc bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7
+  nbl[2]_7 bl[2]_7 vnwc vddpe bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6
+  bl[2]_6 vpw vddc vddpe bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw vddc vddc
+  bl[1]_5 nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc vddc vddc
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc vddpe
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc vddpe
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw vddc nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc vpw wl[1]_12 wl[0]_12
+  sram128x46mem_r_test12row
xmem_r_row_13 vpw vnwc bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 vnwc vddc
+  bl[3]_10 nbl[3]_10 nbl[2]_10 vddc vddpe nbl[1]_10 nbl[0]_10 bl[3]_9 vddc
+  vddpe nbl[1]_9 bl[3]_8 vpw vssc vddc vddpe bl[3]_7 vpw vddc vddc bl[3]_6
+  nbl[2]_6 vnwc vddc nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc vddpe nbl[3]_4
+  vpw vddpe nbl[1]_4 vpw vnwc vddc vddpe vpw vnwc vddc bl[3]_1 vpw vnwc vddc
+  bl[0]_1 nbl[2]_0 vnwc vddc vddpe bl[1]_0 vnwp_1 vpw vddc vddpe bl[1]_11
+  nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10 vpw vnwc vddc bl[1]_10 bl[0]_10
+  nbl[3]_9 nbl[2]_9 bl[2]_9 vpw vnwc vddc bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8
+  nbl[2]_8 bl[2]_8 vnwc vddc bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7
+  nbl[2]_7 bl[2]_7 vnwc vddpe bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6
+  bl[2]_6 vpw vddc vddpe bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw vddc vddc
+  bl[1]_5 nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc vddc vddc
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc vddpe
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc vddpe
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw vddc nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc vpw wl[1]_13 wl[0]_13
+  sram128x46mem_r_test13row
xmem_r_row_17 vpw vnwc bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 vnwc vddc
+  bl[3]_10 nbl[3]_10 nbl[2]_10 vddc vddpe nbl[1]_10 nbl[0]_10 bl[3]_9 vddc
+  vddpe nbl[1]_9 bl[3]_8 vpw vssc vddc vddpe bl[3]_7 vpw vddc vddc bl[3]_6
+  nbl[2]_6 vnwc vddc nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc vddpe nbl[3]_4
+  vpw vddpe nbl[1]_4 vpw vnwc vddc vddpe vpw vnwc vddc bl[3]_1 vpw vnwc vddc
+  bl[0]_1 nbl[2]_0 vnwc vddc vddpe bl[1]_0 vnwp_1 vpw vddc vddpe bl[1]_11
+  nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10 vpw vnwc vddc bl[1]_10 bl[0]_10
+  nbl[3]_9 nbl[2]_9 bl[2]_9 vpw vnwc vddc bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8
+  nbl[2]_8 bl[2]_8 vnwc vddc bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7
+  nbl[2]_7 bl[2]_7 vnwc vddpe bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6
+  bl[2]_6 vpw vddc vddpe bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw vddc vddc
+  bl[1]_5 nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc vddc vddc
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc vddpe
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc vddpe
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw vddc nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc vpw wl[1]_17 wl[0]_17
+  sram128x46mem_r_test17row
xmem_r_row_18 vpw vnwc bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 vnwc vddc
+  bl[3]_10 nbl[3]_10 nbl[2]_10 vddc vddpe nbl[1]_10 nbl[0]_10 bl[3]_9 vddc
+  vddpe nbl[1]_9 bl[3]_8 vpw vssc vddc vddpe bl[3]_7 vpw vddc vddc bl[3]_6
+  nbl[2]_6 vnwc vddc nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc vddpe nbl[3]_4
+  vpw vddpe nbl[1]_4 vpw vnwc vddc vddpe vpw vnwc vddc bl[3]_1 vpw vnwc vddc
+  bl[0]_1 nbl[2]_0 vnwc vddc vddpe bl[1]_0 vnwp_1 vpw vddc vddpe bl[1]_11
+  nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10 vpw vnwc vddc bl[1]_10 bl[0]_10
+  nbl[3]_9 nbl[2]_9 bl[2]_9 vpw vnwc vddc bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8
+  nbl[2]_8 bl[2]_8 vnwc vddc bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7
+  nbl[2]_7 bl[2]_7 vnwc vddpe bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6
+  bl[2]_6 vpw vddc vddpe bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw vddc vddc
+  bl[1]_5 nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc vddc vddc
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc vddpe
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc vddpe
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw vddc nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc vpw wl[1]_18 wl[0]_18
+  sram128x46mem_r_test18row
xmem_r_row_19 vpw vnwc bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 vnwc vddc
+  bl[3]_10 nbl[3]_10 nbl[2]_10 vddc vddpe nbl[1]_10 nbl[0]_10 bl[3]_9 vddc
+  vddpe nbl[1]_9 bl[3]_8 vpw vssc vddc vddpe bl[3]_7 vpw vddc vddc bl[3]_6
+  nbl[2]_6 vnwc vddc nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc vddpe nbl[3]_4
+  vpw vddpe nbl[1]_4 vpw vnwc vddc vddpe vpw vnwc vddc bl[3]_1 vpw vnwc vddc
+  bl[0]_1 nbl[2]_0 vnwc vddc vddpe bl[1]_0 vnwp_1 vpw vddc vddpe bl[1]_11
+  nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10 vpw vnwc vddc bl[1]_10 bl[0]_10
+  nbl[3]_9 nbl[2]_9 bl[2]_9 vpw vnwc vddc bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8
+  nbl[2]_8 bl[2]_8 vnwc vddc bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7
+  nbl[2]_7 bl[2]_7 vnwc vddpe bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6
+  bl[2]_6 vpw vddc vddpe bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw vddc vddc
+  bl[1]_5 nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc vddc vddc
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc vddpe
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc vddpe
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw vddc nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc vpw wl[1]_19 wl[0]_19
+  sram128x46mem_r_test19row
xmem_r_row_2 vpw vnwc bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 vnwc vddc bl[3]_10
+  nbl[3]_10 nbl[2]_10 vddc vddpe nbl[1]_10 nbl[0]_10 bl[3]_9 vddc vddpe
+  nbl[1]_9 bl[3]_8 vpw vssc vddc vddpe bl[3]_7 vpw vddc vddc bl[3]_6 nbl[2]_6
+  vnwc vddc nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc vddpe nbl[3]_4 vpw vddpe
+  nbl[1]_4 vpw vnwc vddc vddpe vpw vnwc vddc bl[3]_1 vpw vnwc vddc bl[0]_1
+  nbl[2]_0 vnwc vddc vddpe bl[1]_0 vnwp_1 vpw vddc vddpe bl[1]_11 nbl[1]_11
+  nbl[0]_11 bl[0]_11 bl[2]_10 vpw vnwc vddc bl[1]_10 bl[0]_10 nbl[3]_9
+  nbl[2]_9 bl[2]_9 vpw vnwc vddc bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8 nbl[2]_8
+  bl[2]_8 vnwc vddc bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7 nbl[2]_7
+  bl[2]_7 vnwc vddpe bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6 bl[2]_6 vpw
+  vddc vddpe bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw vddc vddc bl[1]_5 nbl[1]_5
+  nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc vddc vddc bl[1]_4 nbl[0]_4
+  bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc bl[1]_3 nbl[1]_3 nbl[0]_3
+  bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc vddpe bl[1]_2 nbl[1]_2
+  nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc vddpe bl[1]_1 nbl[1]_1
+  nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw vddc nbl[1]_0 nbl[0]_0 bl[0]_0 vnwp_0
+  vnwc vpw wl[1]_2 wl[0]_2 sram128x46mem_r_test2row
xmem_r_row_20 vpw vnwc bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 vnwc vddc
+  bl[3]_10 nbl[3]_10 nbl[2]_10 vddc vddpe nbl[1]_10 nbl[0]_10 bl[3]_9 vddc
+  vddpe nbl[1]_9 bl[3]_8 vpw vssc vddc vddpe bl[3]_7 vpw vddc vddc bl[3]_6
+  nbl[2]_6 vnwc vddc nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc vddpe nbl[3]_4
+  vpw vddpe nbl[1]_4 vpw vnwc vddc vddpe vpw vnwc vddc bl[3]_1 vpw vnwc vddc
+  bl[0]_1 nbl[2]_0 vnwc vddc vddpe bl[1]_0 vnwp_1 vpw vddc vddpe bl[1]_11
+  nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10 vpw vnwc vddc bl[1]_10 bl[0]_10
+  nbl[3]_9 nbl[2]_9 bl[2]_9 vpw vnwc vddc bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8
+  nbl[2]_8 bl[2]_8 vnwc vddc bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7
+  nbl[2]_7 bl[2]_7 vnwc vddpe bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6
+  bl[2]_6 vpw vddc vddpe bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw vddc vddc
+  bl[1]_5 nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc vddc vddc
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc vddpe
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc vddpe
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw vddc nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc vpw wl[1]_20 wl[0]_20
+  sram128x46mem_r_test20row
xmem_r_row_21 vpw vnwc bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 vnwc vddc
+  bl[3]_10 nbl[3]_10 nbl[2]_10 vddc vddpe nbl[1]_10 nbl[0]_10 bl[3]_9 vddc
+  vddpe nbl[1]_9 bl[3]_8 vpw vssc vddc vddpe bl[3]_7 vpw vddc vddc bl[3]_6
+  nbl[2]_6 vnwc vddc nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc vddpe nbl[3]_4
+  vpw vddpe nbl[1]_4 vpw vnwc vddc vddpe vpw vnwc vddc bl[3]_1 vpw vnwc vddc
+  bl[0]_1 nbl[2]_0 vnwc vddc vddpe bl[1]_0 vnwp_1 vpw vddc vddpe bl[1]_11
+  nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10 vpw vnwc vddc bl[1]_10 bl[0]_10
+  nbl[3]_9 nbl[2]_9 bl[2]_9 vpw vnwc vddc bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8
+  nbl[2]_8 bl[2]_8 vnwc vddc bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7
+  nbl[2]_7 bl[2]_7 vnwc vddpe bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6
+  bl[2]_6 vpw vddc vddpe bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw vddc vddc
+  bl[1]_5 nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc vddc vddc
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc vddpe
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc vddpe
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw vddc nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc vpw wl[1]_21 wl[0]_21
+  sram128x46mem_r_test21row
xmem_r_row_22 vpw vnwc bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 vnwc vddc
+  bl[3]_10 nbl[3]_10 nbl[2]_10 vddc vddpe nbl[1]_10 nbl[0]_10 bl[3]_9 vddc
+  vddpe nbl[1]_9 bl[3]_8 vpw vssc vddc vddpe bl[3]_7 vpw vddc vddc bl[3]_6
+  nbl[2]_6 vnwc vddc nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc vddpe nbl[3]_4
+  vpw vddpe nbl[1]_4 vpw vnwc vddc vddpe vpw vnwc vddc bl[3]_1 vpw vnwc vddc
+  bl[0]_1 nbl[2]_0 vnwc vddc vddpe bl[1]_0 vnwp_1 vpw vddc vddpe bl[1]_11
+  nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10 vpw vnwc vddc bl[1]_10 bl[0]_10
+  nbl[3]_9 nbl[2]_9 bl[2]_9 vpw vnwc vddc bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8
+  nbl[2]_8 bl[2]_8 vnwc vddc bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7
+  nbl[2]_7 bl[2]_7 vnwc vddpe bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6
+  bl[2]_6 vpw vddc vddpe bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw vddc vddc
+  bl[1]_5 nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc vddc vddc
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc vddpe
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc vddpe
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw vddc nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc vpw wl[1]_22 wl[0]_22
+  sram128x46mem_r_test22row
xmem_r_row_23 vpw vnwc bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 vnwc vddc
+  bl[3]_10 nbl[3]_10 nbl[2]_10 vddc vddpe nbl[1]_10 nbl[0]_10 bl[3]_9 vddc
+  vddpe nbl[1]_9 bl[3]_8 vpw vssc vddc vddpe bl[3]_7 vpw vddc vddc bl[3]_6
+  nbl[2]_6 vnwc vddc nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc vddpe nbl[3]_4
+  vpw vddpe nbl[1]_4 vpw vnwc vddc vddpe vpw vnwc vddc bl[3]_1 vpw vnwc vddc
+  bl[0]_1 nbl[2]_0 vnwc vddc vddpe bl[1]_0 vnwp_1 vpw vddc vddpe bl[1]_11
+  nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10 vpw vnwc vddc bl[1]_10 bl[0]_10
+  nbl[3]_9 nbl[2]_9 bl[2]_9 vpw vnwc vddc bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8
+  nbl[2]_8 bl[2]_8 vnwc vddc bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7
+  nbl[2]_7 bl[2]_7 vnwc vddpe bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6
+  bl[2]_6 vpw vddc vddpe bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw vddc vddc
+  bl[1]_5 nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc vddc vddc
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc vddpe
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc vddpe
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw vddc nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc vpw wl[1]_23 wl[0]_23
+  sram128x46mem_r_test23row
xmem_r_row_24 vpw vnwc bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 vnwc vddc
+  bl[3]_10 nbl[3]_10 nbl[2]_10 vddc vddpe nbl[1]_10 nbl[0]_10 bl[3]_9 vddc
+  vddpe nbl[1]_9 bl[3]_8 vpw vssc vddc vddpe bl[3]_7 vpw vddc vddc bl[3]_6
+  nbl[2]_6 vnwc vddc nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc vddpe nbl[3]_4
+  vpw vddpe nbl[1]_4 vpw vnwc vddc vddpe vpw vnwc vddc bl[3]_1 vpw vnwc vddc
+  bl[0]_1 nbl[2]_0 vnwc vddc vddpe bl[1]_0 vnwp_1 vpw vddc vddpe bl[1]_11
+  nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10 vpw vnwc vddc bl[1]_10 bl[0]_10
+  nbl[3]_9 nbl[2]_9 bl[2]_9 vpw vnwc vddc bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8
+  nbl[2]_8 bl[2]_8 vnwc vddc bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7
+  nbl[2]_7 bl[2]_7 vnwc vddpe bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6
+  bl[2]_6 vpw vddc vddpe bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw vddc vddc
+  bl[1]_5 nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc vddc vddc
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc vddpe
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc vddpe
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw vddc nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc vpw wl[1]_24 wl[0]_24
+  sram128x46mem_r_test24row
xmem_r_row_25 vpw vnwc bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 vnwc vddc
+  bl[3]_10 nbl[3]_10 nbl[2]_10 vddc vddpe nbl[1]_10 nbl[0]_10 bl[3]_9 vddc
+  vddpe nbl[1]_9 bl[3]_8 vpw vssc vddc vddpe bl[3]_7 vpw vddc vddc bl[3]_6
+  nbl[2]_6 vnwc vddc nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc vddpe nbl[3]_4
+  vpw vddpe nbl[1]_4 vpw vnwc vddc vddpe vpw vnwc vddc bl[3]_1 vpw vnwc vddc
+  bl[0]_1 nbl[2]_0 vnwc vddc vddpe bl[1]_0 vnwp_1 vpw vddc vddpe bl[1]_11
+  nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10 vpw vnwc vddc bl[1]_10 bl[0]_10
+  nbl[3]_9 nbl[2]_9 bl[2]_9 vpw vnwc vddc bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8
+  nbl[2]_8 bl[2]_8 vnwc vddc bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7
+  nbl[2]_7 bl[2]_7 vnwc vddpe bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6
+  bl[2]_6 vpw vddc vddpe bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw vddc vddc
+  bl[1]_5 nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc vddc vddc
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc vddpe
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc vddpe
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw vddc nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc vpw wl[1]_25 wl[0]_25
+  sram128x46mem_r_test25row
xmem_r_row_26 vpw vnwc bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 vnwc vddc
+  bl[3]_10 nbl[3]_10 nbl[2]_10 vddc vddpe nbl[1]_10 nbl[0]_10 bl[3]_9 vddc
+  vddpe nbl[1]_9 bl[3]_8 vpw vssc vddc vddpe bl[3]_7 vpw vddc vddc bl[3]_6
+  nbl[2]_6 vnwc vddc nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc vddpe nbl[3]_4
+  vpw vddpe nbl[1]_4 vpw vnwc vddc vddpe vpw vnwc vddc bl[3]_1 vpw vnwc vddc
+  bl[0]_1 nbl[2]_0 vnwc vddc vddpe bl[1]_0 vnwp_1 vpw vddc vddpe bl[1]_11
+  nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10 vpw vnwc vddc bl[1]_10 bl[0]_10
+  nbl[3]_9 nbl[2]_9 bl[2]_9 vpw vnwc vddc bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8
+  nbl[2]_8 bl[2]_8 vnwc vddc bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7
+  nbl[2]_7 bl[2]_7 vnwc vddpe bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6
+  bl[2]_6 vpw vddc vddpe bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw vddc vddc
+  bl[1]_5 nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc vddc vddc
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc vddpe
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc vddpe
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw vddc nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc vpw wl[1]_26 wl[0]_26
+  sram128x46mem_r_test26row
xmem_r_row_27 vpw vnwc bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 vnwc vddc
+  bl[3]_10 nbl[3]_10 nbl[2]_10 vddc vddpe nbl[1]_10 nbl[0]_10 bl[3]_9 vddc
+  vddpe nbl[1]_9 bl[3]_8 vpw vssc vddc vddpe bl[3]_7 vpw vddc vddc bl[3]_6
+  nbl[2]_6 vnwc vddc nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc vddpe nbl[3]_4
+  vpw vddpe nbl[1]_4 vpw vnwc vddc vddpe vpw vnwc vddc bl[3]_1 vpw vnwc vddc
+  bl[0]_1 nbl[2]_0 vnwc vddc vddpe bl[1]_0 vnwp_1 vpw vddc vddpe bl[1]_11
+  nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10 vpw vnwc vddc bl[1]_10 bl[0]_10
+  nbl[3]_9 nbl[2]_9 bl[2]_9 vpw vnwc vddc bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8
+  nbl[2]_8 bl[2]_8 vnwc vddc bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7
+  nbl[2]_7 bl[2]_7 vnwc vddpe bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6
+  bl[2]_6 vpw vddc vddpe bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw vddc vddc
+  bl[1]_5 nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc vddc vddc
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc vddpe
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc vddpe
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw vddc nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc vpw wl[1]_27 wl[0]_27
+  sram128x46mem_r_test27row
xmem_r_row_28 vpw vnwc bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 vnwc vddc
+  bl[3]_10 nbl[3]_10 nbl[2]_10 vddc vddpe nbl[1]_10 nbl[0]_10 bl[3]_9 vddc
+  vddpe nbl[1]_9 bl[3]_8 vpw vssc vddc vddpe bl[3]_7 vpw vddc vddc bl[3]_6
+  nbl[2]_6 vnwc vddc nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc vddpe nbl[3]_4
+  vpw vddpe nbl[1]_4 vpw vnwc vddc vddpe vpw vnwc vddc bl[3]_1 vpw vnwc vddc
+  bl[0]_1 nbl[2]_0 vnwc vddc vddpe bl[1]_0 vnwp_1 vpw vddc vddpe bl[1]_11
+  nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10 vpw vnwc vddc bl[1]_10 bl[0]_10
+  nbl[3]_9 nbl[2]_9 bl[2]_9 vpw vnwc vddc bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8
+  nbl[2]_8 bl[2]_8 vnwc vddc bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7
+  nbl[2]_7 bl[2]_7 vnwc vddpe bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6
+  bl[2]_6 vpw vddc vddpe bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw vddc vddc
+  bl[1]_5 nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc vddc vddc
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc vddpe
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc vddpe
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw vddc nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc vpw wl[1]_28 wl[0]_28
+  sram128x46mem_r_test28row
xmem_r_row_29 vpw vnwc bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 vnwc vddc
+  bl[3]_10 nbl[3]_10 nbl[2]_10 vddc vddpe nbl[1]_10 nbl[0]_10 bl[3]_9 vddc
+  vddpe nbl[1]_9 bl[3]_8 vpw vssc vddc vddpe bl[3]_7 vpw vddc vddc bl[3]_6
+  nbl[2]_6 vnwc vddc nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc vddpe nbl[3]_4
+  vpw vddpe nbl[1]_4 vpw vnwc vddc vddpe vpw vnwc vddc bl[3]_1 vpw vnwc vddc
+  bl[0]_1 nbl[2]_0 vnwc vddc vddpe bl[1]_0 vnwp_1 vpw vddc vddpe bl[1]_11
+  nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10 vpw vnwc vddc bl[1]_10 bl[0]_10
+  nbl[3]_9 nbl[2]_9 bl[2]_9 vpw vnwc vddc bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8
+  nbl[2]_8 bl[2]_8 vnwc vddc bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7
+  nbl[2]_7 bl[2]_7 vnwc vddpe bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6
+  bl[2]_6 vpw vddc vddpe bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw vddc vddc
+  bl[1]_5 nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc vddc vddc
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc vddpe
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc vddpe
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw vddc nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc vpw wl[1]_29 wl[0]_29
+  sram128x46mem_r_test29row
xmem_r_row_3 vpw vnwc bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 vnwc vddc bl[3]_10
+  nbl[3]_10 nbl[2]_10 vddc vddpe nbl[1]_10 nbl[0]_10 bl[3]_9 vddc vddpe
+  nbl[1]_9 bl[3]_8 vpw vssc vddc vddpe bl[3]_7 vpw vddc vddc bl[3]_6 nbl[2]_6
+  vnwc vddc nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc vddpe nbl[3]_4 vpw vddpe
+  nbl[1]_4 vpw vnwc vddc vddpe vpw vnwc vddc bl[3]_1 vpw vnwc vddc bl[0]_1
+  nbl[2]_0 vnwc vddc vddpe bl[1]_0 vnwp_1 vpw vddc vddpe bl[1]_11 nbl[1]_11
+  nbl[0]_11 bl[0]_11 bl[2]_10 vpw vnwc vddc bl[1]_10 bl[0]_10 nbl[3]_9
+  nbl[2]_9 bl[2]_9 vpw vnwc vddc bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8 nbl[2]_8
+  bl[2]_8 vnwc vddc bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7 nbl[2]_7
+  bl[2]_7 vnwc vddpe bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6 bl[2]_6 vpw
+  vddc vddpe bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw vddc vddc bl[1]_5 nbl[1]_5
+  nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc vddc vddc bl[1]_4 nbl[0]_4
+  bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc bl[1]_3 nbl[1]_3 nbl[0]_3
+  bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc vddpe bl[1]_2 nbl[1]_2
+  nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc vddpe bl[1]_1 nbl[1]_1
+  nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw vddc nbl[1]_0 nbl[0]_0 bl[0]_0 vnwp_0
+  vnwc vpw wl[1]_3 wl[0]_3 sram128x46mem_r_test3row
xmem_r_row_30 vpw vnwc bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 vnwc vddc
+  bl[3]_10 nbl[3]_10 nbl[2]_10 vddc vddpe nbl[1]_10 nbl[0]_10 bl[3]_9 vddc
+  vddpe nbl[1]_9 bl[3]_8 vpw vssc vddc vddpe bl[3]_7 vpw vddc vddc bl[3]_6
+  nbl[2]_6 vnwc vddc nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc vddpe nbl[3]_4
+  vpw vddpe nbl[1]_4 vpw vnwc vddc vddpe vpw vnwc vddc bl[3]_1 vpw vnwc vddc
+  bl[0]_1 nbl[2]_0 vnwc vddc vddpe bl[1]_0 vnwp_1 vpw vddc vddpe bl[1]_11
+  nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10 vpw vnwc vddc bl[1]_10 bl[0]_10
+  nbl[3]_9 nbl[2]_9 bl[2]_9 vpw vnwc vddc bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8
+  nbl[2]_8 bl[2]_8 vnwc vddc bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7
+  nbl[2]_7 bl[2]_7 vnwc vddpe bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6
+  bl[2]_6 vpw vddc vddpe bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw vddc vddc
+  bl[1]_5 nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc vddc vddc
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc vddpe
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc vddpe
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw vddc nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc vpw wl[1]_30 wl[0]_30
+  sram128x46mem_r_test30row
xmem_r_row_4 vpw vnwc bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 vnwc vddc bl[3]_10
+  nbl[3]_10 nbl[2]_10 vddc vddpe nbl[1]_10 nbl[0]_10 bl[3]_9 vddc vddpe
+  nbl[1]_9 bl[3]_8 vpw vssc vddc vddpe bl[3]_7 vpw vddc vddc bl[3]_6 nbl[2]_6
+  vnwc vddc nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc vddpe nbl[3]_4 vpw vddpe
+  nbl[1]_4 vpw vnwc vddc vddpe vpw vnwc vddc bl[3]_1 vpw vnwc vddc bl[0]_1
+  nbl[2]_0 vnwc vddc vddpe bl[1]_0 vnwp_1 vpw vddc vddpe bl[1]_11 nbl[1]_11
+  nbl[0]_11 bl[0]_11 bl[2]_10 vpw vnwc vddc bl[1]_10 bl[0]_10 nbl[3]_9
+  nbl[2]_9 bl[2]_9 vpw vnwc vddc bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8 nbl[2]_8
+  bl[2]_8 vnwc vddc bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7 nbl[2]_7
+  bl[2]_7 vnwc vddpe bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6 bl[2]_6 vpw
+  vddc vddpe bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw vddc vddc bl[1]_5 nbl[1]_5
+  nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc vddc vddc bl[1]_4 nbl[0]_4
+  bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc bl[1]_3 nbl[1]_3 nbl[0]_3
+  bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc vddpe bl[1]_2 nbl[1]_2
+  nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc vddpe bl[1]_1 nbl[1]_1
+  nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw vddc nbl[1]_0 nbl[0]_0 bl[0]_0 vnwp_0
+  vnwc vpw wl[1]_4 wl[0]_4 sram128x46mem_r_test4row
xmem_r_row_5 vpw vnwc bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 vnwc vddc bl[3]_10
+  nbl[3]_10 nbl[2]_10 vddc vddpe nbl[1]_10 nbl[0]_10 bl[3]_9 vddc vddpe
+  nbl[1]_9 bl[3]_8 vpw vssc vddc vddpe bl[3]_7 vpw vddc vddc bl[3]_6 nbl[2]_6
+  vnwc vddc nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc vddpe nbl[3]_4 vpw vddpe
+  nbl[1]_4 vpw vnwc vddc vddpe vpw vnwc vddc bl[3]_1 vpw vnwc vddc bl[0]_1
+  nbl[2]_0 vnwc vddc vddpe bl[1]_0 vnwp_1 vpw vddc vddpe bl[1]_11 nbl[1]_11
+  nbl[0]_11 bl[0]_11 bl[2]_10 vpw vnwc vddc bl[1]_10 bl[0]_10 nbl[3]_9
+  nbl[2]_9 bl[2]_9 vpw vnwc vddc bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8 nbl[2]_8
+  bl[2]_8 vnwc vddc bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7 nbl[2]_7
+  bl[2]_7 vnwc vddpe bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6 bl[2]_6 vpw
+  vddc vddpe bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw vddc vddc bl[1]_5 nbl[1]_5
+  nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc vddc vddc bl[1]_4 nbl[0]_4
+  bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc bl[1]_3 nbl[1]_3 nbl[0]_3
+  bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc vddpe bl[1]_2 nbl[1]_2
+  nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc vddpe bl[1]_1 nbl[1]_1
+  nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw vddc nbl[1]_0 nbl[0]_0 bl[0]_0 vnwp_0
+  vnwc vpw wl[1]_5 wl[0]_5 sram128x46mem_r_test5row
xmem_r_row_6 vpw vnwc bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 vnwc vddc bl[3]_10
+  nbl[3]_10 nbl[2]_10 vddc vddpe nbl[1]_10 nbl[0]_10 bl[3]_9 vddc vddpe
+  nbl[1]_9 bl[3]_8 vpw vssc vddc vddpe bl[3]_7 vpw vddc vddc bl[3]_6 nbl[2]_6
+  vnwc vddc nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc vddpe nbl[3]_4 vpw vddpe
+  nbl[1]_4 vpw vnwc vddc vddpe vpw vnwc vddc bl[3]_1 vpw vnwc vddc bl[0]_1
+  nbl[2]_0 vnwc vddc vddpe bl[1]_0 vnwp_1 vpw vddc vddpe bl[1]_11 nbl[1]_11
+  nbl[0]_11 bl[0]_11 bl[2]_10 vpw vnwc vddc bl[1]_10 bl[0]_10 nbl[3]_9
+  nbl[2]_9 bl[2]_9 vpw vnwc vddc bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8 nbl[2]_8
+  bl[2]_8 vnwc vddc bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7 nbl[2]_7
+  bl[2]_7 vnwc vddpe bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6 bl[2]_6 vpw
+  vddc vddpe bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw vddc vddc bl[1]_5 nbl[1]_5
+  nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc vddc vddc bl[1]_4 nbl[0]_4
+  bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc bl[1]_3 nbl[1]_3 nbl[0]_3
+  bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc vddpe bl[1]_2 nbl[1]_2
+  nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc vddpe bl[1]_1 nbl[1]_1
+  nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw vddc nbl[1]_0 nbl[0]_0 bl[0]_0 vnwp_0
+  vnwc vpw wl[1]_6 wl[0]_6 sram128x46mem_r_test6row
xmem_r_row_7 vpw vnwc bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 vnwc vddc bl[3]_10
+  nbl[3]_10 nbl[2]_10 vddc vddpe nbl[1]_10 nbl[0]_10 bl[3]_9 vddc vddpe
+  nbl[1]_9 bl[3]_8 vpw vssc vddc vddpe bl[3]_7 vpw vddc vddc bl[3]_6 nbl[2]_6
+  vnwc vddc nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc vddpe nbl[3]_4 vpw vddpe
+  nbl[1]_4 vpw vnwc vddc vddpe vpw vnwc vddc bl[3]_1 vpw vnwc vddc bl[0]_1
+  nbl[2]_0 vnwc vddc vddpe bl[1]_0 vnwp_1 vpw vddc vddpe bl[1]_11 nbl[1]_11
+  nbl[0]_11 bl[0]_11 bl[2]_10 vpw vnwc vddc bl[1]_10 bl[0]_10 nbl[3]_9
+  nbl[2]_9 bl[2]_9 vpw vnwc vddc bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8 nbl[2]_8
+  bl[2]_8 vnwc vddc bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7 nbl[2]_7
+  bl[2]_7 vnwc vddpe bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6 bl[2]_6 vpw
+  vddc vddpe bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw vddc vddc bl[1]_5 nbl[1]_5
+  nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc vddc vddc bl[1]_4 nbl[0]_4
+  bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc bl[1]_3 nbl[1]_3 nbl[0]_3
+  bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc vddpe bl[1]_2 nbl[1]_2
+  nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc vddpe bl[1]_1 nbl[1]_1
+  nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw vddc nbl[1]_0 nbl[0]_0 bl[0]_0 vnwp_0
+  vnwc vpw wl[1]_7 wl[0]_7 sram128x46mem_r_test7row
xmem_r_row_8 vpw vnwc bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 vnwc vddc bl[3]_10
+  nbl[3]_10 nbl[2]_10 vddc vddpe nbl[1]_10 nbl[0]_10 bl[3]_9 vddc vddpe
+  nbl[1]_9 bl[3]_8 vpw vssc vddc vddpe bl[3]_7 vpw vddc vddc bl[3]_6 nbl[2]_6
+  vnwc vddc nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc vddpe nbl[3]_4 vpw vddpe
+  nbl[1]_4 vpw vnwc vddc vddpe vpw vnwc vddc bl[3]_1 vpw vnwc vddc bl[0]_1
+  nbl[2]_0 vnwc vddc vddpe bl[1]_0 vnwp_1 vpw vddc vddpe bl[1]_11 nbl[1]_11
+  nbl[0]_11 bl[0]_11 bl[2]_10 vpw vnwc vddc bl[1]_10 bl[0]_10 nbl[3]_9
+  nbl[2]_9 bl[2]_9 vpw vnwc vddc bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8 nbl[2]_8
+  bl[2]_8 vnwc vddc bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7 nbl[2]_7
+  bl[2]_7 vnwc vddpe bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6 bl[2]_6 vpw
+  vddc vddpe bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw vddc vddc bl[1]_5 nbl[1]_5
+  nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc vddc vddc bl[1]_4 nbl[0]_4
+  bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc bl[1]_3 nbl[1]_3 nbl[0]_3
+  bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc vddpe bl[1]_2 nbl[1]_2
+  nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc vddpe bl[1]_1 nbl[1]_1
+  nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw vddc nbl[1]_0 nbl[0]_0 bl[0]_0 vnwp_0
+  vnwc vpw wl[1]_8 wl[0]_8 sram128x46mem_r_test8row
xmem_r_row_9 vpw vnwc bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 vnwc vddc bl[3]_10
+  nbl[3]_10 nbl[2]_10 vddc vddpe nbl[1]_10 nbl[0]_10 bl[3]_9 vddc vddpe
+  nbl[1]_9 bl[3]_8 vpw vssc vddc vddpe bl[3]_7 vpw vddc vddc bl[3]_6 nbl[2]_6
+  vnwc vddc nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc vddpe nbl[3]_4 vpw vddpe
+  nbl[1]_4 vpw vnwc vddc vddpe vpw vnwc vddc bl[3]_1 vpw vnwc vddc bl[0]_1
+  nbl[2]_0 vnwc vddc vddpe bl[1]_0 vnwp_1 vpw vddc vddpe bl[1]_11 nbl[1]_11
+  nbl[0]_11 bl[0]_11 bl[2]_10 vpw vnwc vddc bl[1]_10 bl[0]_10 nbl[3]_9
+  nbl[2]_9 bl[2]_9 vpw vnwc vddc bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8 nbl[2]_8
+  bl[2]_8 vnwc vddc bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7 nbl[2]_7
+  bl[2]_7 vnwc vddpe bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6 bl[2]_6 vpw
+  vddc vddpe bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw vddc vddc bl[1]_5 nbl[1]_5
+  nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc vddc vddc bl[1]_4 nbl[0]_4
+  bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc bl[1]_3 nbl[1]_3 nbl[0]_3
+  bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc vddpe bl[1]_2 nbl[1]_2
+  nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc vddpe bl[1]_1 nbl[1]_1
+  nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw vddc nbl[1]_0 nbl[0]_0 bl[0]_0 vnwp_0
+  vnwc vpw wl[1]_9 wl[0]_9 sram128x46mem_r_test9row
xmem_r_row_bot vpw vnwc bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 vnwc vddc
+  bl[3]_10 nbl[3]_10 nbl[2]_10 vddc vddpe nbl[1]_10 nbl[0]_10 bl[3]_9 vddc
+  vddpe nbl[1]_9 bl[3]_8 vpw vssc vddc vddpe bl[3]_7 vpw vddc vddc bl[3]_6
+  nbl[2]_6 vnwc vddc nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc vddpe nbl[3]_4
+  vpw vddpe nbl[1]_4 vpw vnwc vddc vddpe vpw vnwc vddc bl[3]_1 vpw vnwc vddc
+  bl[0]_1 nbl[2]_0 vssc vnwc vddc vddpe bl[1]_0 vnwp_1 vpw vssc vddc vddpe
+  bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10 vpw vnwc vddc bl[1]_10
+  bl[0]_10 nbl[3]_9 nbl[2]_9 bl[2]_9 vpw vnwc vddc bl[1]_9 nbl[0]_9 bl[0]_9
+  nbl[3]_8 nbl[2]_8 bl[2]_8 vnwc vddc bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8
+  nbl[3]_7 nbl[2]_7 bl[2]_7 vnwc vddpe bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7
+  nbl[3]_6 bl[2]_6 vpw vddc vddpe bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw vddc
+  vddc bl[1]_5 nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc vddc
+  vddc bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc
+  bl[1]_3 nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc
+  vddpe bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc
+  vddpe bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw vddc nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc vpw wl[1]_0 wl[0]_0 sram128x46mem_r_bot_row
xmem_r_row_mid vpw vnwc bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 vnwc vddc
+  bl[3]_10 nbl[3]_10 nbl[2]_10 vddc vddpe nbl[1]_10 nbl[0]_10 bl[3]_9 vddc
+  vddpe nbl[1]_9 bl[3]_8 vpw vssc vddc vddpe bl[3]_7 vpw vddc vddc bl[3]_6
+  nbl[2]_6 vnwc vddc nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc vddpe nbl[3]_4
+  vpw vddpe nbl[1]_4 vpw vnwc vddc vddpe vpw vnwc vddc bl[3]_1 vpw vnwc vddc
+  bl[0]_1 nbl[2]_0 vnwc vddc vddpe bl[1]_0 vnwp_1 vpw vddc vddpe bl[1]_11
+  nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10 vpw vnwc vddc bl[1]_10 bl[0]_10
+  nbl[3]_9 nbl[2]_9 bl[2]_9 vpw vnwc vddc bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8
+  nbl[2]_8 bl[2]_8 vnwc vddc bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7
+  nbl[2]_7 bl[2]_7 vnwc vddpe bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6
+  bl[2]_6 vpw vddc vddpe bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw vddc vddc
+  bl[1]_5 nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc vddc vddc
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc vddpe
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc vddpe
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw vddc nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc vpw wl[1]_15 wl[0]_15 sram128x46mem_r_mid_row
xmem_r_row_midb vpw vnwc bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 vnwc vddc
+  bl[3]_10 nbl[3]_10 nbl[2]_10 vddc vddpe nbl[1]_10 nbl[0]_10 bl[3]_9 vddc
+  vddpe nbl[1]_9 bl[3]_8 vpw vssc vddc vddpe bl[3]_7 vpw vddc vddc bl[3]_6
+  nbl[2]_6 vnwc vddc nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc vddpe nbl[3]_4
+  vpw vddpe nbl[1]_4 vpw vnwc vddc vddpe vpw vnwc vddc bl[3]_1 vpw vnwc vddc
+  bl[0]_1 nbl[2]_0 vnwc vddc vddpe bl[1]_0 vnwp_1 vpw vddc vddpe bl[1]_11
+  nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10 vpw vnwc vddc bl[1]_10 bl[0]_10
+  nbl[3]_9 nbl[2]_9 bl[2]_9 vpw vnwc vddc bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8
+  nbl[2]_8 bl[2]_8 vnwc vddc bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7
+  nbl[2]_7 bl[2]_7 vnwc vddpe bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6
+  bl[2]_6 vpw vddc vddpe bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw vddc vddc
+  bl[1]_5 nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc vddc vddc
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc vddpe
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc vddpe
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw vddc nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc vpw wl[1]_14 wl[0]_14 sram128x46mem_r_midb_row
xmem_r_row_midt vpw vnwc bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 vnwc vddc
+  bl[3]_10 nbl[3]_10 nbl[2]_10 vddc vddpe nbl[1]_10 nbl[0]_10 bl[3]_9 vddc
+  vddpe nbl[1]_9 bl[3]_8 vpw vssc vddc vddpe bl[3]_7 vpw vddc vddc bl[3]_6
+  nbl[2]_6 vnwc vddc nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc vddpe nbl[3]_4
+  vpw vddpe nbl[1]_4 vpw vnwc vddc vddpe vpw vnwc vddc bl[3]_1 vpw vnwc vddc
+  bl[0]_1 nbl[2]_0 vnwc vddc vddpe bl[1]_0 vnwp_1 vpw vddc vddpe bl[1]_11
+  nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10 vpw vnwc vddc bl[1]_10 bl[0]_10
+  nbl[3]_9 nbl[2]_9 bl[2]_9 vpw vnwc vddc bl[1]_9 nbl[0]_9 bl[0]_9 nbl[3]_8
+  nbl[2]_8 bl[2]_8 vnwc vddc bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 nbl[3]_7
+  nbl[2]_7 bl[2]_7 vnwc vddpe bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 nbl[3]_6
+  bl[2]_6 vpw vddc vddpe bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw vddc vddc
+  bl[1]_5 nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc vddc vddc
+  bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc bl[1]_3
+  nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc vddpe
+  bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc vddpe
+  bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw vddc nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc vpw wl[1]_16 wl[0]_16 sram128x46mem_r_midt_row
xmem_r_row_top vpw vnwc bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 vnwc vddc
+  bl[3]_10 nbl[3]_10 nbl[2]_10 vddc vddpe nbl[1]_10 nbl[0]_10 bl[3]_9 vddc
+  vddpe nbl[1]_9 bl[3]_8 vpw vssc vddc vddpe bl[3]_7 vpw vddc vddc bl[3]_6
+  nbl[2]_6 vnwc vddc nbl[0]_6 bl[3]_5 nbl[3]_5 nbl[2]_5 vnwc vddpe nbl[3]_4
+  vpw vddpe nbl[1]_4 vpw vnwc vddc vddpe vpw vnwc vddc bl[3]_1 vpw vnwc vddc
+  bl[0]_1 nbl[2]_0 vssc vnwc vddc vddpe bl[1]_0 vnwp_1 vpw vssc vddc vddpe
+  bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 bl[2]_10 vpw vnwc vddc bl[1]_10
+  bl[0]_10 nbl[3]_9 nbl[2]_9 bl[2]_9 vpw vnwc vddc bl[1]_9 nbl[0]_9 bl[0]_9
+  nbl[3]_8 nbl[2]_8 bl[2]_8 vnwc vddc bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8
+  nbl[3]_7 nbl[2]_7 bl[2]_7 vnwc vddpe bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7
+  nbl[3]_6 bl[2]_6 vpw vddc vddpe bl[1]_6 nbl[1]_6 bl[0]_6 bl[2]_5 vpw vddc
+  vddc bl[1]_5 nbl[1]_5 nbl[0]_5 bl[0]_5 bl[3]_4 nbl[2]_4 bl[2]_4 vnwc vddc
+  vddc bl[1]_4 nbl[0]_4 bl[0]_4 bl[3]_3 nbl[3]_3 nbl[2]_3 bl[2]_3 vddc
+  bl[1]_3 nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 nbl[3]_2 nbl[2]_2 bl[2]_2 vddc
+  vddpe bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 nbl[3]_1 nbl[2]_1 bl[2]_1 vddc
+  vddpe bl[1]_1 nbl[1]_1 nbl[0]_1 bl[3]_0 nbl[3]_0 bl[2]_0 vpw vddc nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc vpw wl[1]_31 wl[0]_31 sram128x46mem_r_top_row
.ends sram128x46memcore_r
****
.subckt sram128x46wdbot nret ret actp dbl dbl_nbl_wa dbl_nbl_wa_turn dbl_term
+  dwl ema[0] ema[1] ema[2] gtpclk0 gtpclk1 la_p2[0] la_p2[1] log0 log0_sa
+  log1 nact_cc nactc nhdr_wl ni0_term ni1_term nla_p2[0] nla_p2[1] nra_p2[0]
+  nra_p2[1] nra_p2[2] nra_p2[3] nra_p2[4] nra_p2[5] nretnvt ra_en0 ra_en1
+  ra_p2[0] ra_p2[1] ra_p2[2] ra_p2[3] ra_p2[4] ra_p2[5] rawl rawlm0 rawlm1
+  vddc_l vddc_r vddce vddi vddp_nor vddpe vnwc vnwp vpw vss vssc_l vssc_r
+  vsse cen_p2 ret1n
** sram128x46wdbot: 40 flat devices **
mi35.mxna1 nret iret vsse vpw nch_mac W=1.6U L=0.035U NF=2
mi35.mxpa1 nret iret vddce vnwc pch_mac W=2U L=0.035U NF=2
mi40.mxna1 iret ret1n i40.n1 vpw nch_mac W=1.2U L=0.035U NF=1
mi40.mxna2 i40.n1 log1 vsse vpw nch_mac W=1.2U L=0.035U NF=1
mi40.mxpa1 iret ret1n vddce vnwc pch_mac W=0.4U L=0.035U NF=1
mi40.mxpa2 iret log1 vddce vnwc pch_mac W=0.4U L=0.035U NF=1
mi42.i0.mxna1 i42.nra_ast0 rawlm0 i42.i0.n1 vpw nch_mac W=0.31U L=0.035U NF=1
mi42.i0.mxna2 i42.i0.n1 rawl vss vpw nch_mac W=0.31U L=0.035U NF=1
mi42.i0.mxpa1 i42.nra_ast0 rawlm0 vddpe vnwp pch_mac W=0.26U L=0.035U NF=1
mi42.i0.mxpa2 i42.nra_ast0 rawl vddpe vnwp pch_mac W=0.26U L=0.035U NF=1
mi42.i115.mxna1 ra_en0 i42.ra_ast0 vsse vpw nch_mac W=0.4U L=0.035U NF=1
mi42.i115.mxpa1 ra_en0 i42.ra_ast0 vddce vnwc pch_mac W=0.26U L=0.035U NF=1
mi42.i162.mxna1 i42.ra_ast0 i42.nra_ast0 i42.i162.n1 vpw nch_mac W=0.55U
+  L=0.035U NF=1
mi42.i162.mxna2 i42.i162.n1 nret vss vpw nch_mac W=0.55U L=0.035U NF=1
mi42.i162.mxpa1 i42.ra_ast0 i42.nra_ast0 vddce vnwc pch_mac W=0.26U L=0.035U
+  NF=1
mi42.i162.mxpa2 i42.ra_ast0 nret vddce vnwc pch_mac W=0.26U L=0.035U NF=1
mi42.i163.mxna1 i42.nra_ast1 rawlm1 i42.i163.n1 vpw nch_mac W=0.31U L=0.035U
+  NF=1
mi42.i163.mxna2 i42.i163.n1 rawl vss vpw nch_mac W=0.31U L=0.035U NF=1
mi42.i163.mxpa1 i42.nra_ast1 rawlm1 vddpe vnwp pch_mac W=0.26U L=0.035U NF=1
mi42.i163.mxpa2 i42.nra_ast1 rawl vddpe vnwp pch_mac W=0.26U L=0.035U NF=1
mi42.i164.mxna1 i42.ra_ast1 i42.nra_ast1 i42.i164.n1 vpw nch_mac W=0.55U
+  L=0.035U NF=1
mi42.i164.mxna2 i42.i164.n1 nret vss vpw nch_mac W=0.55U L=0.035U NF=1
mi42.i164.mxpa1 i42.ra_ast1 i42.nra_ast1 vddce vnwc pch_mac W=0.26U L=0.035U
+  NF=1
mi42.i164.mxpa2 i42.ra_ast1 nret vddce vnwc pch_mac W=0.26U L=0.035U NF=1
mi42.i165.mxna1 ra_en1 i42.ra_ast1 vsse vpw nch_mac W=0.4U L=0.035U NF=1
mi42.i165.mxpa1 ra_en1 i42.ra_ast1 vddce vnwc pch_mac W=0.26U L=0.035U NF=1
mi50.mxna1 ret nret vsse vpw nch_mac W=4.02U L=0.035U NF=6
mi50.mxpa1 ret nret vddce vnwc pch_mac W=8.01U L=0.035U NF=6
mxp0 vddi nhdr_wl vddce vnwc pch_mac W=16U L=0.035U NF=10
m_hdr_ctl.i63.mxna1 _hdr_ctl.ce_p2 cen_p2 vss vpw nch_mac W=0.2U L=0.03U NF=1
m_hdr_ctl.i63.mxna2 _hdr_ctl.ce_p2 iret vss vpw nch_mac W=0.2U L=0.03U NF=1
m_hdr_ctl.i63.mxpa1 _hdr_ctl.ce_p2 cen_p2 _hdr_ctl.i63.p1 vnwp pch_mac W=1.25U
+  L=0.03U NF=1
m_hdr_ctl.i63.mxpa2 _hdr_ctl.i63.p1 iret vddpe vnwp pch_mac W=1.25U L=0.03U
+  NF=1
m_hdr_ctl.mxn2 _hdr_ctl.net4 cen_p2 vss vpw nch_mac W=1U L=0.03U NF=5
m_hdr_ctl.mxn3 nhdr_wl _hdr_ctl.ce_p2 vss vpw nch_mac W=9U L=0.03U NF=10
m_hdr_ctl.mxp10 nhdr_wl nret vddce vnwc pch_mac W=0.66U L=0.03U NF=1
m_hdr_ctl.mxp6 _hdr_ctl.net4 cen_p2 _hdr_ctl.net8 vnwc pch_mac W=0.33U L=0.03U
+  NF=1
m_hdr_ctl.mxp7 _hdr_ctl.net8 nhdr_wl vddce vnwc pch_mac W=0.33U L=0.03U NF=1
m_hdr_ctl.mxp8 _hdr_ctl.net7 _hdr_ctl.net4 vddce vnwc pch_mac W=0.66U L=0.03U
+  NF=1
m_hdr_ctl.mxp9 nhdr_wl _hdr_ctl.ce_p2 _hdr_ctl.net7 vnwc pch_mac W=0.66U
+  L=0.03U NF=1
.ends sram128x46wdbot
****
.subckt sram128x46wdtop actp dbl_ast log0 nhdr_wl ni1 ni0 niactc niretnvt
+  nxp0_0 nxp0_1 nxp0_2 nxp0_3 nxp0_4 nxp0_5 nxp0_6 nxp0_7 nxp1_0 nxp1_1
+  nxp1_2 nxp1_3 nxp1_4 nxp1_5 nxp1_6 nxp1_7 ra_en0_l_term ra_en0_r_term
+  ra_en1_l_term ra_en1_r_term ret rowclk1 rowclk0 rowclk2_term rowclk3_term
+  vddc_l vddc_r vddc_wl vddce vddp_nor vddpe vnwc vnwp vpw vss vssc_l vssc_r
+  vsse
** sram128x46wdtop: 9 flat devices **
mi32_0.mxna1 ni0 rowclk0 vss vpw nch_mac W=2U L=0.03U NF=2
mi32_0.mxpa1 ni0 rowclk0 vddc_wl vnwc pch_mac W=1.48U L=0.03U NF=2
mi32_1.mxna1 ni1 rowclk1 vss vpw nch_mac W=2U L=0.03U NF=2
mi32_1.mxpa1 ni1 rowclk1 vddc_wl vnwc pch_mac W=1.48U L=0.03U NF=2
mi44.mxna1 net61 dbl_ast vss vpw nch_mac W=0.63U L=0.035U NF=2
mi44.mxpa1 net61 dbl_ast vddpe vnwp pch_mac W=0.8U L=0.035U NF=2
mi45.mxna1 net60 net61 vss vpw nch_mac W=1.26U L=0.035U NF=2
mi45.mxpa1 net60 net61 vddpe vnwp pch_mac W=1.6U L=0.035U NF=2
mxp8 vddc_wl nhdr_wl vddce vnwc pch_mac W=21.1U L=0.035U NF=10
.ends sram128x46wdtop
****
.subckt sram128x46wdx64 log0_sa nact_cc actp dbl dbl_nbl_wa dbl_nbl_wa_turn
+  dwl ema2_e log0 log1 nhdr_wl ni0 ni1 niactc niretnvt nxp0_0 nxp0_1 nxp0_2
+  nxp0_3 nxp0_4 nxp0_5 nxp0_6 nxp0_7 nxp1_0 nxp1_1 nxp1_2 nxp1_3 nxp1_4
+  nxp1_5 nxp1_6 nxp1_7 rowclk0 rowclk1 rowclk2 rowclk3 vddce vddi vddp_nor
+  vddpe vnwc vnwp vpw vss vssc_l vssc_r vsse wl0_l wl0_r wl1_l wl1_r wl2_l
+  wl2_r wl3_l wl3_r wl4_l wl4_r wl5_l wl5_r wl6_l wl6_r wl7_l wl7_r wl8_l
+  wl8_r wl9_l wl9_r wl10_l wl10_r wl11_l wl11_r wl12_l wl12_r wl13_l wl13_r
+  wl14_l wl14_r wl15_l wl15_r wl16_l wl16_r wl17_l wl17_r wl18_l wl18_r
+  wl19_l wl19_r wl20_l wl20_r wl21_l wl21_r wl22_l wl22_r wl23_l wl23_r
+  wl24_l wl24_r wl25_l wl25_r wl26_l wl26_r wl27_l wl27_r wl28_l wl28_r
+  wl29_l wl29_r wl30_l wl30_r wl31_l wl31_r wl32_l wl32_r wl33_l wl33_r
+  wl34_l wl34_r wl35_l wl35_r wl36_l wl36_r wl37_l wl37_r wl38_l wl38_r
+  wl39_l wl39_r wl40_l wl40_r wl41_l wl41_r wl42_l wl42_r wl43_l wl43_r
+  wl44_l wl44_r wl45_l wl45_r wl46_l wl46_r wl47_l wl47_r wl48_l wl48_r
+  wl49_l wl49_r wl50_l wl50_r wl51_l wl51_r wl52_l wl52_r wl53_l wl53_r
+  wl54_l wl54_r wl55_l wl55_r wl56_l wl56_r wl57_l wl57_r wl58_l wl58_r
+  wl59_l wl59_r wl60_l wl60_r wl61_l wl61_r wl62_l wl62_r wl63_l wl63_r ema0
+  ema1 ema2 gtpclk0 gtpclk1 la_p2[0] la_p2[1] nla_p2[0] nla_p2[1] nra_p2[0]
+  nra_p2[1] nra_p2[2] nra_p2[3] nra_p2[4] nra_p2[5] ra_en0_l ra_en0_r
+  ra_en1_l ra_en1_r ra_p2[0] ra_p2[1] ra_p2[2] ra_p2[3] ra_p2[4] ra_p2[5] ret
** sram128x46wdx64: 1105 flat devices **
mi2_0.mxna1 nrowclk[0] gtpclk0 i2_0.n1 vpw nch_mac W=2.8U L=0.03U NF=4
mi2_0.mxna2 i2_0.n1 xrow[0] vss vpw nch_mac W=2.8U L=0.03U NF=4
mi2_0.mxpa1 nrowclk[0] gtpclk0 vddpe vnwp pch_mac W=1.2U L=0.03U NF=4
mi2_0.mxpa2 nrowclk[0] xrow[0] vddpe vnwp pch_mac W=1.2U L=0.03U NF=4
mi2_1.mxna1 nrowclk[1] gtpclk1 i2_1.n1 vpw nch_mac W=2.8U L=0.03U NF=4
mi2_1.mxna2 i2_1.n1 xrow[1] vss vpw nch_mac W=2.8U L=0.03U NF=4
mi2_1.mxpa1 nrowclk[1] gtpclk1 vddpe vnwp pch_mac W=1.2U L=0.03U NF=4
mi2_1.mxpa2 nrowclk[1] xrow[1] vddpe vnwp pch_mac W=1.2U L=0.03U NF=4
mi2_2.mxna1 nrowclk[2] gtpclk0 i2_2.n1 vpw nch_mac W=2.8U L=0.03U NF=4
mi2_2.mxna2 i2_2.n1 xrow[2] vss vpw nch_mac W=2.8U L=0.03U NF=4
mi2_2.mxpa1 nrowclk[2] gtpclk0 vddpe vnwp pch_mac W=1.2U L=0.03U NF=4
mi2_2.mxpa2 nrowclk[2] xrow[2] vddpe vnwp pch_mac W=1.2U L=0.03U NF=4
mi2_3.mxna1 nrowclk[3] gtpclk1 i2_3.n1 vpw nch_mac W=2.8U L=0.03U NF=4
mi2_3.mxna2 i2_3.n1 xrow[3] vss vpw nch_mac W=2.8U L=0.03U NF=4
mi2_3.mxpa1 nrowclk[3] gtpclk1 vddpe vnwp pch_mac W=1.2U L=0.03U NF=4
mi2_3.mxpa2 nrowclk[3] xrow[3] vddpe vnwp pch_mac W=1.2U L=0.03U NF=4
mi74.mxna1 act_cc ret vsse vpw nch_mac W=0.3U L=0.03U NF=2
mi74.mxpa1 act_cc ret vddpe vnwp pch_mac W=0.6U L=0.03U NF=2
mi82.mxna1 nact_cc act_cc vss vpw nch_mac W=1U L=0.03U NF=4
mi82.mxpa1 nact_cc act_cc vddpe vnwp pch_mac W=2U L=0.03U NF=4
miv_rdwrclk_0.mxna1 rowclk0 nrowclk[0] vss vpw nch_mac W=3U L=0.03U NF=8
miv_rdwrclk_0.mxpa1 rowclk0 nrowclk[0] vddpe vnwp pch_mac W=7U L=0.03U NF=8
miv_rdwrclk_1.mxna1 rowclk1 nrowclk[1] vss vpw nch_mac W=3U L=0.03U NF=8
miv_rdwrclk_1.mxpa1 rowclk1 nrowclk[1] vddpe vnwp pch_mac W=7U L=0.03U NF=8
miv_rdwrclk_2.mxna1 rowclk2 nrowclk[2] vss vpw nch_mac W=3U L=0.03U NF=8
miv_rdwrclk_2.mxpa1 rowclk2 nrowclk[2] vddpe vnwp pch_mac W=7U L=0.03U NF=8
miv_rdwrclk_3.mxna1 rowclk3 nrowclk[3] vss vpw nch_mac W=3U L=0.03U NF=8
miv_rdwrclk_3.mxpa1 rowclk3 nrowclk[3] vddpe vnwp pch_mac W=7U L=0.03U NF=8
m_dummy.i2.mxna1 _dummy.nsel0 ema2 vss vpw nch_mac W=0.1U L=0.03U NF=1
m_dummy.i2.mxna2 _dummy.nsel0 ema0 vss vpw nch_mac W=0.1U L=0.03U NF=1
m_dummy.i2.mxpa1 _dummy.nsel0 ema2 _dummy.i2.p1 vnwp pch_mac W=0.2U L=0.03U
+  NF=1
m_dummy.i2.mxpa2 _dummy.i2.p1 ema0 vddpe vnwp pch_mac W=0.2U L=0.03U NF=1
m_dummy.i77.mxna1 _dummy.nsel1 ema2 vss vpw nch_mac W=0.1U L=0.03U NF=1
m_dummy.i77.mxna2 _dummy.nsel1 ema1 vss vpw nch_mac W=0.1U L=0.03U NF=1
m_dummy.i77.mxpa1 _dummy.nsel1 ema2 _dummy.i77.p1 vnwp pch_mac W=0.2U L=0.03U
+  NF=1
m_dummy.i77.mxpa2 _dummy.i77.p1 ema1 vddpe vnwp pch_mac W=0.2U L=0.03U NF=1
m_dummy.i82.mxna1 _dummy.nema[2] ema2_e vss vpw nch_mac W=0.2U L=0.03U NF=1
m_dummy.i82.mxpa1 _dummy.nema[2] ema2_e vddpe vnwp pch_mac W=0.2U L=0.03U NF=1
m_dummy.mxn1 _dummy.net24 log1 vss vpw nch_mac W=0.24U L=0.04U NF=1
m_dummy.mxn22 dbl dwl _dummy.ia[1] vpw nch_mac W=0.24U L=0.04U NF=1
m_dummy.mxn23 _dummy.ia[1] _dummy.nsel0 _dummy.net24 vpw nch_mac W=0.24U
+  L=0.04U NF=1
m_dummy.mxn25 dbl dwl _dummy.ia[2] vpw nch_mac W=0.6U L=0.04U NF=2
m_dummy.mxn26 _dummy.ia[2] _dummy.nsel1 vss vpw nch_mac W=0.6U L=0.04U NF=2
m_dummy.mxn28 dbl dwl _dummy.ia[3] vpw nch_mac W=0.4U L=0.03U NF=1
m_dummy.mxn29 _dummy.ia[3] log0 vss vpw nch_mac W=0.4U L=0.03U NF=1
m_dummy.mxn31 dbl dbl _dummy.ia[4] vpw nch_mac W=0.3U L=0.03U NF=1
m_dummy.mxn32 _dummy.ia[4] dwl _dummy.mid vpw nch_mac W=0.3U L=0.03U NF=1
m_dummy.mxn33 _dummy.mid _dummy.nema[2] vss vpw nch_mac W=0.3U L=0.03U NF=1
m_dummy.mxp12 dbl dwl vddpe vnwp pch_mac W=2U L=0.03U NF=4
m_rowclk_dec.i0_0.mxna1 _rowclk_dec.ndec[0] nla_p2[0] _rowclk_dec.i0_0.n1 vpw
+  nch_mac W=0.24U L=0.03U NF=1
m_rowclk_dec.i0_0.mxna2 _rowclk_dec.i0_0.n1 nla_p2[1] vss vpw nch_mac W=0.24U
+  L=0.03U NF=1
m_rowclk_dec.i0_0.mxpa1 _rowclk_dec.ndec[0] nla_p2[0] vddpe vnwp pch_mac
+  W=0.24U L=0.03U NF=1
m_rowclk_dec.i0_0.mxpa2 _rowclk_dec.ndec[0] nla_p2[1] vddpe vnwp pch_mac
+  W=0.24U L=0.03U NF=1
m_rowclk_dec.i0_1.mxna1 _rowclk_dec.ndec[1] la_p2[0] _rowclk_dec.i0_1.n1 vpw
+  nch_mac W=0.24U L=0.03U NF=1
m_rowclk_dec.i0_1.mxna2 _rowclk_dec.i0_1.n1 nla_p2[1] vss vpw nch_mac W=0.24U
+  L=0.03U NF=1
m_rowclk_dec.i0_1.mxpa1 _rowclk_dec.ndec[1] la_p2[0] vddpe vnwp pch_mac
+  W=0.24U L=0.03U NF=1
m_rowclk_dec.i0_1.mxpa2 _rowclk_dec.ndec[1] nla_p2[1] vddpe vnwp pch_mac
+  W=0.24U L=0.03U NF=1
m_rowclk_dec.i0_2.mxna1 _rowclk_dec.ndec[2] nla_p2[0] _rowclk_dec.i0_2.n1 vpw
+  nch_mac W=0.24U L=0.03U NF=1
m_rowclk_dec.i0_2.mxna2 _rowclk_dec.i0_2.n1 la_p2[1] vss vpw nch_mac W=0.24U
+  L=0.03U NF=1
m_rowclk_dec.i0_2.mxpa1 _rowclk_dec.ndec[2] nla_p2[0] vddpe vnwp pch_mac
+  W=0.24U L=0.03U NF=1
m_rowclk_dec.i0_2.mxpa2 _rowclk_dec.ndec[2] la_p2[1] vddpe vnwp pch_mac
+  W=0.24U L=0.03U NF=1
m_rowclk_dec.i0_3.mxna1 _rowclk_dec.ndec[3] la_p2[0] _rowclk_dec.i0_3.n1 vpw
+  nch_mac W=0.24U L=0.03U NF=1
m_rowclk_dec.i0_3.mxna2 _rowclk_dec.i0_3.n1 la_p2[1] vss vpw nch_mac W=0.24U
+  L=0.03U NF=1
m_rowclk_dec.i0_3.mxpa1 _rowclk_dec.ndec[3] la_p2[0] vddpe vnwp pch_mac
+  W=0.24U L=0.03U NF=1
m_rowclk_dec.i0_3.mxpa2 _rowclk_dec.ndec[3] la_p2[1] vddpe vnwp pch_mac
+  W=0.24U L=0.03U NF=1
m_rowclk_dec.i1_0.mxna1 xrow[0] _rowclk_dec.ndec[0] vss vpw nch_mac W=0.45U
+  L=0.03U NF=2
m_rowclk_dec.i1_0.mxpa1 xrow[0] _rowclk_dec.ndec[0] vddpe vnwp pch_mac
+  W=0.675U L=0.03U NF=2
m_rowclk_dec.i1_1.mxna1 xrow[1] _rowclk_dec.ndec[1] vss vpw nch_mac W=0.45U
+  L=0.03U NF=2
m_rowclk_dec.i1_1.mxpa1 xrow[1] _rowclk_dec.ndec[1] vddpe vnwp pch_mac
+  W=0.675U L=0.03U NF=2
m_rowclk_dec.i1_2.mxna1 xrow[2] _rowclk_dec.ndec[2] vss vpw nch_mac W=0.45U
+  L=0.03U NF=2
m_rowclk_dec.i1_2.mxpa1 xrow[2] _rowclk_dec.ndec[2] vddpe vnwp pch_mac
+  W=0.675U L=0.03U NF=2
m_rowclk_dec.i1_3.mxna1 xrow[3] _rowclk_dec.ndec[3] vss vpw nch_mac W=0.45U
+  L=0.03U NF=2
m_rowclk_dec.i1_3.mxpa1 xrow[3] _rowclk_dec.ndec[3] vddpe vnwp pch_mac
+  W=0.675U L=0.03U NF=2
m_tiehilo.itiehilo.mxn0 _tiehilo.izero _tiehilo.itiehilo.nodeb vsse vpw
+  nch_mac W=0.36U L=0.03U NF=1
m_tiehilo.itiehilo.mxn1 _tiehilo.itiehilo.nodea _tiehilo.itiehilo.nodea vsse
+  vpw nch_mac W=0.21U L=0.03U NF=1
m_tiehilo.itiehilo.mxn2 _tiehilo.itiehilo.nodea _tiehilo.itiehilo.nodeb vsse
+  vpw nch_mac W=0.21U L=0.03U NF=1
m_tiehilo.itiehilo.mxp1 _tiehilo.itiehilo.nodeb _tiehilo.itiehilo.nodea vddpe
+  vnwp pch_mac W=0.275U L=0.03U NF=1
m_tiehilo.itiehilo.mxp4 _tiehilo.ione _tiehilo.itiehilo.nodea vddpe vnwp
+  pch_mac W=0.73U L=0.03U NF=2
m_tiehilo.mxn5 log0 _tiehilo.ione vsse vpw nch_mac W=2.5U L=0.03U NF=4
m_tiehilo.mxn7 log0_sa _tiehilo.ione vsse vpw nch_mac W=1.875U L=0.03U NF=3
m_tiehilo.mxp4 log1 _tiehilo.izero vddpe vnwp pch_mac W=3.6U L=0.03U NF=6
m_wd0.i69.mxn0 _wd0.rowsel nxp1_0 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd0.i69.mxn15 _wd0.rowsel nxp0_0 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd0.i69.mxp1 _wd0.rowsel nxp0_0 _wd0.i69.p1 vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd0.i69.mxp15 _wd0.i69.p1 nxp1_0 vddp_nor vnwp pch_mac W=1.35U L=0.035U NF=1
m_wd0.i69.mx_npd _wd0.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wd0.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U NF=1
m_wd0.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wd0.mxp12 wl1_r ra_en0_r wl0_r vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd0.mxp13 wl1_r ra_en1_r wl0_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd0.mxp14 wl1_l ra_en1_l wl0_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd0.mxp15 wl1_l ra_en0_l wl0_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd0._rowdrv_0.mxn0 wl0_r _wd0._rowdrv_0.nwl vsse vpw nch_mac W=1.2U L=0.035U
+  NF=2
m_wd0._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd0._rowdrv_0.mxn11 wl0_l _wd0._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd0._rowdrv_0.mxn8 _wd0._rowdrv_0.nwl _wd0.rowsel ni0 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd0._rowdrv_0.mxp0 wl0_r _wd0._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd0._rowdrv_0.mxp12 _wd0._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd0._rowdrv_0.mxp13 _wd0._rowdrv_0.nwl _wd0.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd0._rowdrv_0.mxp7 wl0_l _wd0._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd0._rowdrv_1.mxn0 wl1_r _wd0._rowdrv_1.nwl vsse vpw nch_mac W=1.2U L=0.035U
+  NF=2
m_wd0._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd0._rowdrv_1.mxn11 wl1_l _wd0._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd0._rowdrv_1.mxn8 _wd0._rowdrv_1.nwl _wd0.rowsel ni1 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd0._rowdrv_1.mxp0 wl1_r _wd0._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd0._rowdrv_1.mxp12 _wd0._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd0._rowdrv_1.mxp13 _wd0._rowdrv_1.nwl _wd0.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd0._rowdrv_1.mxp7 wl1_l _wd0._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd1.i69.mxn0 _wd1.rowsel nxp1_0 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd1.i69.mxn15 _wd1.rowsel nxp0_1 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd1.i69.mxp1 _wd1.rowsel nxp0_1 _wd1.i69.p1 vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd1.i69.mxp15 _wd1.i69.p1 nxp1_0 vddp_nor vnwp pch_mac W=1.35U L=0.035U NF=1
m_wd1.i69.mx_npd _wd1.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wd1.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U NF=1
m_wd1.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wd1.mxp12 wl3_r ra_en0_r wl2_r vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd1.mxp13 wl3_r ra_en1_r wl2_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd1.mxp14 wl3_l ra_en1_l wl2_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd1.mxp15 wl3_l ra_en0_l wl2_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd1._rowdrv_0.mxn0 wl2_r _wd1._rowdrv_0.nwl vsse vpw nch_mac W=1.2U L=0.035U
+  NF=2
m_wd1._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd1._rowdrv_0.mxn11 wl2_l _wd1._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd1._rowdrv_0.mxn8 _wd1._rowdrv_0.nwl _wd1.rowsel ni0 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd1._rowdrv_0.mxp0 wl2_r _wd1._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd1._rowdrv_0.mxp12 _wd1._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd1._rowdrv_0.mxp13 _wd1._rowdrv_0.nwl _wd1.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd1._rowdrv_0.mxp7 wl2_l _wd1._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd1._rowdrv_1.mxn0 wl3_r _wd1._rowdrv_1.nwl vsse vpw nch_mac W=1.2U L=0.035U
+  NF=2
m_wd1._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd1._rowdrv_1.mxn11 wl3_l _wd1._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd1._rowdrv_1.mxn8 _wd1._rowdrv_1.nwl _wd1.rowsel ni1 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd1._rowdrv_1.mxp0 wl3_r _wd1._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd1._rowdrv_1.mxp12 _wd1._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd1._rowdrv_1.mxp13 _wd1._rowdrv_1.nwl _wd1.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd1._rowdrv_1.mxp7 wl3_l _wd1._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd10.i69.mxn0 _wd10.rowsel nxp1_1 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd10.i69.mxn15 _wd10.rowsel nxp0_2 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd10.i69.mxp1 _wd10.rowsel nxp0_2 _wd10.i69.p1 vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd10.i69.mxp15 _wd10.i69.p1 nxp1_1 vddp_nor vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd10.i69.mx_npd _wd10.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wd10.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U NF=1
m_wd10.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wd10.mxp12 wl21_r ra_en0_r wl20_r vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd10.mxp13 wl21_r ra_en1_r wl20_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd10.mxp14 wl21_l ra_en1_l wl20_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd10.mxp15 wl21_l ra_en0_l wl20_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd10._rowdrv_0.mxn0 wl20_r _wd10._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd10._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd10._rowdrv_0.mxn11 wl20_l _wd10._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd10._rowdrv_0.mxn8 _wd10._rowdrv_0.nwl _wd10.rowsel ni0 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd10._rowdrv_0.mxp0 wl20_r _wd10._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd10._rowdrv_0.mxp12 _wd10._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd10._rowdrv_0.mxp13 _wd10._rowdrv_0.nwl _wd10.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd10._rowdrv_0.mxp7 wl20_l _wd10._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd10._rowdrv_1.mxn0 wl21_r _wd10._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd10._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd10._rowdrv_1.mxn11 wl21_l _wd10._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd10._rowdrv_1.mxn8 _wd10._rowdrv_1.nwl _wd10.rowsel ni1 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd10._rowdrv_1.mxp0 wl21_r _wd10._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd10._rowdrv_1.mxp12 _wd10._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd10._rowdrv_1.mxp13 _wd10._rowdrv_1.nwl _wd10.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd10._rowdrv_1.mxp7 wl21_l _wd10._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd11.i69.mxn0 _wd11.rowsel nxp1_1 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd11.i69.mxn15 _wd11.rowsel nxp0_3 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd11.i69.mxp1 _wd11.rowsel nxp0_3 _wd11.i69.p1 vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd11.i69.mxp15 _wd11.i69.p1 nxp1_1 vddp_nor vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd11.i69.mx_npd _wd11.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wd11.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U NF=1
m_wd11.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wd11.mxp12 wl23_r ra_en0_r wl22_r vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd11.mxp13 wl23_r ra_en1_r wl22_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd11.mxp14 wl23_l ra_en1_l wl22_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd11.mxp15 wl23_l ra_en0_l wl22_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd11._rowdrv_0.mxn0 wl22_r _wd11._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd11._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd11._rowdrv_0.mxn11 wl22_l _wd11._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd11._rowdrv_0.mxn8 _wd11._rowdrv_0.nwl _wd11.rowsel ni0 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd11._rowdrv_0.mxp0 wl22_r _wd11._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd11._rowdrv_0.mxp12 _wd11._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd11._rowdrv_0.mxp13 _wd11._rowdrv_0.nwl _wd11.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd11._rowdrv_0.mxp7 wl22_l _wd11._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd11._rowdrv_1.mxn0 wl23_r _wd11._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd11._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd11._rowdrv_1.mxn11 wl23_l _wd11._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd11._rowdrv_1.mxn8 _wd11._rowdrv_1.nwl _wd11.rowsel ni1 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd11._rowdrv_1.mxp0 wl23_r _wd11._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd11._rowdrv_1.mxp12 _wd11._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd11._rowdrv_1.mxp13 _wd11._rowdrv_1.nwl _wd11.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd11._rowdrv_1.mxp7 wl23_l _wd11._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd12.i69.mxn0 _wd12.rowsel nxp1_1 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd12.i69.mxn15 _wd12.rowsel nxp0_4 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd12.i69.mxp1 _wd12.rowsel nxp0_4 _wd12.i69.p1 vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd12.i69.mxp15 _wd12.i69.p1 nxp1_1 vddp_nor vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd12.i69.mx_npd _wd12.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wd12.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U NF=1
m_wd12.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wd12.mxp12 wl25_r ra_en0_r wl24_r vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd12.mxp13 wl25_r ra_en1_r wl24_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd12.mxp14 wl25_l ra_en1_l wl24_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd12.mxp15 wl25_l ra_en0_l wl24_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd12._rowdrv_0.mxn0 wl24_r _wd12._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd12._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd12._rowdrv_0.mxn11 wl24_l _wd12._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd12._rowdrv_0.mxn8 _wd12._rowdrv_0.nwl _wd12.rowsel ni0 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd12._rowdrv_0.mxp0 wl24_r _wd12._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd12._rowdrv_0.mxp12 _wd12._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd12._rowdrv_0.mxp13 _wd12._rowdrv_0.nwl _wd12.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd12._rowdrv_0.mxp7 wl24_l _wd12._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd12._rowdrv_1.mxn0 wl25_r _wd12._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd12._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd12._rowdrv_1.mxn11 wl25_l _wd12._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd12._rowdrv_1.mxn8 _wd12._rowdrv_1.nwl _wd12.rowsel ni1 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd12._rowdrv_1.mxp0 wl25_r _wd12._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd12._rowdrv_1.mxp12 _wd12._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd12._rowdrv_1.mxp13 _wd12._rowdrv_1.nwl _wd12.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd12._rowdrv_1.mxp7 wl25_l _wd12._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd13.i69.mxn0 _wd13.rowsel nxp1_1 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd13.i69.mxn15 _wd13.rowsel nxp0_5 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd13.i69.mxp1 _wd13.rowsel nxp0_5 _wd13.i69.p1 vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd13.i69.mxp15 _wd13.i69.p1 nxp1_1 vddp_nor vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd13.i69.mx_npd _wd13.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wd13.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U NF=1
m_wd13.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wd13.mxp12 wl27_r ra_en0_r wl26_r vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd13.mxp13 wl27_r ra_en1_r wl26_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd13.mxp14 wl27_l ra_en1_l wl26_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd13.mxp15 wl27_l ra_en0_l wl26_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd13._rowdrv_0.mxn0 wl26_r _wd13._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd13._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd13._rowdrv_0.mxn11 wl26_l _wd13._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd13._rowdrv_0.mxn8 _wd13._rowdrv_0.nwl _wd13.rowsel ni0 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd13._rowdrv_0.mxp0 wl26_r _wd13._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd13._rowdrv_0.mxp12 _wd13._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd13._rowdrv_0.mxp13 _wd13._rowdrv_0.nwl _wd13.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd13._rowdrv_0.mxp7 wl26_l _wd13._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd13._rowdrv_1.mxn0 wl27_r _wd13._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd13._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd13._rowdrv_1.mxn11 wl27_l _wd13._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd13._rowdrv_1.mxn8 _wd13._rowdrv_1.nwl _wd13.rowsel ni1 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd13._rowdrv_1.mxp0 wl27_r _wd13._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd13._rowdrv_1.mxp12 _wd13._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd13._rowdrv_1.mxp13 _wd13._rowdrv_1.nwl _wd13.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd13._rowdrv_1.mxp7 wl27_l _wd13._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd14.i69.mxn0 _wd14.rowsel nxp1_1 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd14.i69.mxn15 _wd14.rowsel nxp0_6 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd14.i69.mxp1 _wd14.rowsel nxp0_6 _wd14.i69.p1 vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd14.i69.mxp15 _wd14.i69.p1 nxp1_1 vddp_nor vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd14.i69.mx_npd _wd14.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wd14.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U NF=1
m_wd14.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wd14.mxp12 wl29_r ra_en0_r wl28_r vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd14.mxp13 wl29_r ra_en1_r wl28_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd14.mxp14 wl29_l ra_en1_l wl28_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd14.mxp15 wl29_l ra_en0_l wl28_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd14._rowdrv_0.mxn0 wl28_r _wd14._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd14._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd14._rowdrv_0.mxn11 wl28_l _wd14._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd14._rowdrv_0.mxn8 _wd14._rowdrv_0.nwl _wd14.rowsel ni0 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd14._rowdrv_0.mxp0 wl28_r _wd14._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd14._rowdrv_0.mxp12 _wd14._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd14._rowdrv_0.mxp13 _wd14._rowdrv_0.nwl _wd14.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd14._rowdrv_0.mxp7 wl28_l _wd14._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd14._rowdrv_1.mxn0 wl29_r _wd14._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd14._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd14._rowdrv_1.mxn11 wl29_l _wd14._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd14._rowdrv_1.mxn8 _wd14._rowdrv_1.nwl _wd14.rowsel ni1 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd14._rowdrv_1.mxp0 wl29_r _wd14._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd14._rowdrv_1.mxp12 _wd14._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd14._rowdrv_1.mxp13 _wd14._rowdrv_1.nwl _wd14.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd14._rowdrv_1.mxp7 wl29_l _wd14._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd15.i69.mxn0 _wd15.rowsel nxp1_1 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd15.i69.mxn15 _wd15.rowsel nxp0_7 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd15.i69.mxp1 _wd15.rowsel nxp0_7 _wd15.i69.p1 vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd15.i69.mxp15 _wd15.i69.p1 nxp1_1 vddp_nor vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd15.i69.mx_npd _wd15.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wd15.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U NF=1
m_wd15.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wd15.mxp12 wl31_r ra_en0_r wl30_r vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd15.mxp13 wl31_r ra_en1_r wl30_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd15.mxp14 wl31_l ra_en1_l wl30_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd15.mxp15 wl31_l ra_en0_l wl30_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd15._rowdrv_0.mxn0 wl30_r _wd15._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd15._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd15._rowdrv_0.mxn11 wl30_l _wd15._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd15._rowdrv_0.mxn8 _wd15._rowdrv_0.nwl _wd15.rowsel ni0 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd15._rowdrv_0.mxp0 wl30_r _wd15._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd15._rowdrv_0.mxp12 _wd15._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd15._rowdrv_0.mxp13 _wd15._rowdrv_0.nwl _wd15.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd15._rowdrv_0.mxp7 wl30_l _wd15._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd15._rowdrv_1.mxn0 wl31_r _wd15._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd15._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd15._rowdrv_1.mxn11 wl31_l _wd15._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd15._rowdrv_1.mxn8 _wd15._rowdrv_1.nwl _wd15.rowsel ni1 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd15._rowdrv_1.mxp0 wl31_r _wd15._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd15._rowdrv_1.mxp12 _wd15._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd15._rowdrv_1.mxp13 _wd15._rowdrv_1.nwl _wd15.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd15._rowdrv_1.mxp7 wl31_l _wd15._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd16.i69.mxn0 _wd16.rowsel nxp1_2 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd16.i69.mxn15 _wd16.rowsel nxp0_0 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd16.i69.mxp1 _wd16.rowsel nxp0_0 _wd16.i69.p1 vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd16.i69.mxp15 _wd16.i69.p1 nxp1_2 vddp_nor vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd16.i69.mx_npd _wd16.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wd16.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U NF=1
m_wd16.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wd16.mxp12 wl33_r ra_en0_r wl32_r vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd16.mxp13 wl33_r ra_en1_r wl32_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd16.mxp14 wl33_l ra_en1_l wl32_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd16.mxp15 wl33_l ra_en0_l wl32_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd16._rowdrv_0.mxn0 wl32_r _wd16._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd16._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd16._rowdrv_0.mxn11 wl32_l _wd16._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd16._rowdrv_0.mxn8 _wd16._rowdrv_0.nwl _wd16.rowsel ni0 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd16._rowdrv_0.mxp0 wl32_r _wd16._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd16._rowdrv_0.mxp12 _wd16._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd16._rowdrv_0.mxp13 _wd16._rowdrv_0.nwl _wd16.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd16._rowdrv_0.mxp7 wl32_l _wd16._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd16._rowdrv_1.mxn0 wl33_r _wd16._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd16._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd16._rowdrv_1.mxn11 wl33_l _wd16._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd16._rowdrv_1.mxn8 _wd16._rowdrv_1.nwl _wd16.rowsel ni1 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd16._rowdrv_1.mxp0 wl33_r _wd16._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd16._rowdrv_1.mxp12 _wd16._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd16._rowdrv_1.mxp13 _wd16._rowdrv_1.nwl _wd16.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd16._rowdrv_1.mxp7 wl33_l _wd16._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd17.i69.mxn0 _wd17.rowsel nxp1_2 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd17.i69.mxn15 _wd17.rowsel nxp0_1 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd17.i69.mxp1 _wd17.rowsel nxp0_1 _wd17.i69.p1 vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd17.i69.mxp15 _wd17.i69.p1 nxp1_2 vddp_nor vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd17.i69.mx_npd _wd17.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wd17.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U NF=1
m_wd17.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wd17.mxp12 wl35_r ra_en0_r wl34_r vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd17.mxp13 wl35_r ra_en1_r wl34_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd17.mxp14 wl35_l ra_en1_l wl34_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd17.mxp15 wl35_l ra_en0_l wl34_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd17._rowdrv_0.mxn0 wl34_r _wd17._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd17._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd17._rowdrv_0.mxn11 wl34_l _wd17._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd17._rowdrv_0.mxn8 _wd17._rowdrv_0.nwl _wd17.rowsel ni0 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd17._rowdrv_0.mxp0 wl34_r _wd17._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd17._rowdrv_0.mxp12 _wd17._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd17._rowdrv_0.mxp13 _wd17._rowdrv_0.nwl _wd17.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd17._rowdrv_0.mxp7 wl34_l _wd17._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd17._rowdrv_1.mxn0 wl35_r _wd17._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd17._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd17._rowdrv_1.mxn11 wl35_l _wd17._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd17._rowdrv_1.mxn8 _wd17._rowdrv_1.nwl _wd17.rowsel ni1 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd17._rowdrv_1.mxp0 wl35_r _wd17._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd17._rowdrv_1.mxp12 _wd17._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd17._rowdrv_1.mxp13 _wd17._rowdrv_1.nwl _wd17.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd17._rowdrv_1.mxp7 wl35_l _wd17._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd18.i69.mxn0 _wd18.rowsel nxp1_2 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd18.i69.mxn15 _wd18.rowsel nxp0_2 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd18.i69.mxp1 _wd18.rowsel nxp0_2 _wd18.i69.p1 vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd18.i69.mxp15 _wd18.i69.p1 nxp1_2 vddp_nor vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd18.i69.mx_npd _wd18.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wd18.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U NF=1
m_wd18.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wd18.mxp12 wl37_r ra_en0_r wl36_r vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd18.mxp13 wl37_r ra_en1_r wl36_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd18.mxp14 wl37_l ra_en1_l wl36_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd18.mxp15 wl37_l ra_en0_l wl36_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd18._rowdrv_0.mxn0 wl36_r _wd18._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd18._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd18._rowdrv_0.mxn11 wl36_l _wd18._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd18._rowdrv_0.mxn8 _wd18._rowdrv_0.nwl _wd18.rowsel ni0 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd18._rowdrv_0.mxp0 wl36_r _wd18._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd18._rowdrv_0.mxp12 _wd18._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd18._rowdrv_0.mxp13 _wd18._rowdrv_0.nwl _wd18.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd18._rowdrv_0.mxp7 wl36_l _wd18._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd18._rowdrv_1.mxn0 wl37_r _wd18._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd18._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd18._rowdrv_1.mxn11 wl37_l _wd18._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd18._rowdrv_1.mxn8 _wd18._rowdrv_1.nwl _wd18.rowsel ni1 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd18._rowdrv_1.mxp0 wl37_r _wd18._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd18._rowdrv_1.mxp12 _wd18._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd18._rowdrv_1.mxp13 _wd18._rowdrv_1.nwl _wd18.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd18._rowdrv_1.mxp7 wl37_l _wd18._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd19.i69.mxn0 _wd19.rowsel nxp1_2 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd19.i69.mxn15 _wd19.rowsel nxp0_3 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd19.i69.mxp1 _wd19.rowsel nxp0_3 _wd19.i69.p1 vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd19.i69.mxp15 _wd19.i69.p1 nxp1_2 vddp_nor vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd19.i69.mx_npd _wd19.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wd19.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U NF=1
m_wd19.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wd19.mxp12 wl39_r ra_en0_r wl38_r vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd19.mxp13 wl39_r ra_en1_r wl38_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd19.mxp14 wl39_l ra_en1_l wl38_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd19.mxp15 wl39_l ra_en0_l wl38_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd19._rowdrv_0.mxn0 wl38_r _wd19._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd19._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd19._rowdrv_0.mxn11 wl38_l _wd19._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd19._rowdrv_0.mxn8 _wd19._rowdrv_0.nwl _wd19.rowsel ni0 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd19._rowdrv_0.mxp0 wl38_r _wd19._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd19._rowdrv_0.mxp12 _wd19._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd19._rowdrv_0.mxp13 _wd19._rowdrv_0.nwl _wd19.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd19._rowdrv_0.mxp7 wl38_l _wd19._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd19._rowdrv_1.mxn0 wl39_r _wd19._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd19._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd19._rowdrv_1.mxn11 wl39_l _wd19._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd19._rowdrv_1.mxn8 _wd19._rowdrv_1.nwl _wd19.rowsel ni1 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd19._rowdrv_1.mxp0 wl39_r _wd19._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd19._rowdrv_1.mxp12 _wd19._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd19._rowdrv_1.mxp13 _wd19._rowdrv_1.nwl _wd19.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd19._rowdrv_1.mxp7 wl39_l _wd19._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd2.i69.mxn0 _wd2.rowsel nxp1_0 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd2.i69.mxn15 _wd2.rowsel nxp0_2 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd2.i69.mxp1 _wd2.rowsel nxp0_2 _wd2.i69.p1 vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd2.i69.mxp15 _wd2.i69.p1 nxp1_0 vddp_nor vnwp pch_mac W=1.35U L=0.035U NF=1
m_wd2.i69.mx_npd _wd2.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wd2.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U NF=1
m_wd2.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wd2.mxp12 wl5_r ra_en0_r wl4_r vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd2.mxp13 wl5_r ra_en1_r wl4_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd2.mxp14 wl5_l ra_en1_l wl4_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd2.mxp15 wl5_l ra_en0_l wl4_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd2._rowdrv_0.mxn0 wl4_r _wd2._rowdrv_0.nwl vsse vpw nch_mac W=1.2U L=0.035U
+  NF=2
m_wd2._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd2._rowdrv_0.mxn11 wl4_l _wd2._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd2._rowdrv_0.mxn8 _wd2._rowdrv_0.nwl _wd2.rowsel ni0 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd2._rowdrv_0.mxp0 wl4_r _wd2._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd2._rowdrv_0.mxp12 _wd2._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd2._rowdrv_0.mxp13 _wd2._rowdrv_0.nwl _wd2.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd2._rowdrv_0.mxp7 wl4_l _wd2._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd2._rowdrv_1.mxn0 wl5_r _wd2._rowdrv_1.nwl vsse vpw nch_mac W=1.2U L=0.035U
+  NF=2
m_wd2._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd2._rowdrv_1.mxn11 wl5_l _wd2._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd2._rowdrv_1.mxn8 _wd2._rowdrv_1.nwl _wd2.rowsel ni1 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd2._rowdrv_1.mxp0 wl5_r _wd2._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd2._rowdrv_1.mxp12 _wd2._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd2._rowdrv_1.mxp13 _wd2._rowdrv_1.nwl _wd2.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd2._rowdrv_1.mxp7 wl5_l _wd2._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd20.i69.mxn0 _wd20.rowsel nxp1_2 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd20.i69.mxn15 _wd20.rowsel nxp0_4 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd20.i69.mxp1 _wd20.rowsel nxp0_4 _wd20.i69.p1 vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd20.i69.mxp15 _wd20.i69.p1 nxp1_2 vddp_nor vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd20.i69.mx_npd _wd20.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wd20.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U NF=1
m_wd20.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wd20.mxp12 wl41_r ra_en0_r wl40_r vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd20.mxp13 wl41_r ra_en1_r wl40_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd20.mxp14 wl41_l ra_en1_l wl40_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd20.mxp15 wl41_l ra_en0_l wl40_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd20._rowdrv_0.mxn0 wl40_r _wd20._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd20._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd20._rowdrv_0.mxn11 wl40_l _wd20._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd20._rowdrv_0.mxn8 _wd20._rowdrv_0.nwl _wd20.rowsel ni0 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd20._rowdrv_0.mxp0 wl40_r _wd20._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd20._rowdrv_0.mxp12 _wd20._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd20._rowdrv_0.mxp13 _wd20._rowdrv_0.nwl _wd20.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd20._rowdrv_0.mxp7 wl40_l _wd20._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd20._rowdrv_1.mxn0 wl41_r _wd20._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd20._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd20._rowdrv_1.mxn11 wl41_l _wd20._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd20._rowdrv_1.mxn8 _wd20._rowdrv_1.nwl _wd20.rowsel ni1 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd20._rowdrv_1.mxp0 wl41_r _wd20._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd20._rowdrv_1.mxp12 _wd20._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd20._rowdrv_1.mxp13 _wd20._rowdrv_1.nwl _wd20.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd20._rowdrv_1.mxp7 wl41_l _wd20._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd21.i69.mxn0 _wd21.rowsel nxp1_2 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd21.i69.mxn15 _wd21.rowsel nxp0_5 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd21.i69.mxp1 _wd21.rowsel nxp0_5 _wd21.i69.p1 vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd21.i69.mxp15 _wd21.i69.p1 nxp1_2 vddp_nor vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd21.i69.mx_npd _wd21.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wd21.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U NF=1
m_wd21.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wd21.mxp12 wl43_r ra_en0_r wl42_r vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd21.mxp13 wl43_r ra_en1_r wl42_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd21.mxp14 wl43_l ra_en1_l wl42_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd21.mxp15 wl43_l ra_en0_l wl42_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd21._rowdrv_0.mxn0 wl42_r _wd21._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd21._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd21._rowdrv_0.mxn11 wl42_l _wd21._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd21._rowdrv_0.mxn8 _wd21._rowdrv_0.nwl _wd21.rowsel ni0 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd21._rowdrv_0.mxp0 wl42_r _wd21._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd21._rowdrv_0.mxp12 _wd21._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd21._rowdrv_0.mxp13 _wd21._rowdrv_0.nwl _wd21.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd21._rowdrv_0.mxp7 wl42_l _wd21._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd21._rowdrv_1.mxn0 wl43_r _wd21._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd21._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd21._rowdrv_1.mxn11 wl43_l _wd21._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd21._rowdrv_1.mxn8 _wd21._rowdrv_1.nwl _wd21.rowsel ni1 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd21._rowdrv_1.mxp0 wl43_r _wd21._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd21._rowdrv_1.mxp12 _wd21._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd21._rowdrv_1.mxp13 _wd21._rowdrv_1.nwl _wd21.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd21._rowdrv_1.mxp7 wl43_l _wd21._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd22.i69.mxn0 _wd22.rowsel nxp1_2 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd22.i69.mxn15 _wd22.rowsel nxp0_6 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd22.i69.mxp1 _wd22.rowsel nxp0_6 _wd22.i69.p1 vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd22.i69.mxp15 _wd22.i69.p1 nxp1_2 vddp_nor vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd22.i69.mx_npd _wd22.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wd22.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U NF=1
m_wd22.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wd22.mxp12 wl45_r ra_en0_r wl44_r vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd22.mxp13 wl45_r ra_en1_r wl44_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd22.mxp14 wl45_l ra_en1_l wl44_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd22.mxp15 wl45_l ra_en0_l wl44_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd22._rowdrv_0.mxn0 wl44_r _wd22._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd22._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd22._rowdrv_0.mxn11 wl44_l _wd22._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd22._rowdrv_0.mxn8 _wd22._rowdrv_0.nwl _wd22.rowsel ni0 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd22._rowdrv_0.mxp0 wl44_r _wd22._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd22._rowdrv_0.mxp12 _wd22._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd22._rowdrv_0.mxp13 _wd22._rowdrv_0.nwl _wd22.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd22._rowdrv_0.mxp7 wl44_l _wd22._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd22._rowdrv_1.mxn0 wl45_r _wd22._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd22._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd22._rowdrv_1.mxn11 wl45_l _wd22._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd22._rowdrv_1.mxn8 _wd22._rowdrv_1.nwl _wd22.rowsel ni1 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd22._rowdrv_1.mxp0 wl45_r _wd22._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd22._rowdrv_1.mxp12 _wd22._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd22._rowdrv_1.mxp13 _wd22._rowdrv_1.nwl _wd22.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd22._rowdrv_1.mxp7 wl45_l _wd22._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd23.i69.mxn0 _wd23.rowsel nxp1_2 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd23.i69.mxn15 _wd23.rowsel nxp0_7 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd23.i69.mxp1 _wd23.rowsel nxp0_7 _wd23.i69.p1 vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd23.i69.mxp15 _wd23.i69.p1 nxp1_2 vddp_nor vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd23.i69.mx_npd _wd23.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wd23.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U NF=1
m_wd23.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wd23.mxp12 wl47_r ra_en0_r wl46_r vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd23.mxp13 wl47_r ra_en1_r wl46_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd23.mxp14 wl47_l ra_en1_l wl46_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd23.mxp15 wl47_l ra_en0_l wl46_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd23._rowdrv_0.mxn0 wl46_r _wd23._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd23._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd23._rowdrv_0.mxn11 wl46_l _wd23._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd23._rowdrv_0.mxn8 _wd23._rowdrv_0.nwl _wd23.rowsel ni0 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd23._rowdrv_0.mxp0 wl46_r _wd23._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd23._rowdrv_0.mxp12 _wd23._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd23._rowdrv_0.mxp13 _wd23._rowdrv_0.nwl _wd23.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd23._rowdrv_0.mxp7 wl46_l _wd23._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd23._rowdrv_1.mxn0 wl47_r _wd23._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd23._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd23._rowdrv_1.mxn11 wl47_l _wd23._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd23._rowdrv_1.mxn8 _wd23._rowdrv_1.nwl _wd23.rowsel ni1 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd23._rowdrv_1.mxp0 wl47_r _wd23._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd23._rowdrv_1.mxp12 _wd23._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd23._rowdrv_1.mxp13 _wd23._rowdrv_1.nwl _wd23.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd23._rowdrv_1.mxp7 wl47_l _wd23._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd24.i69.mxn0 _wd24.rowsel nxp1_3 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd24.i69.mxn15 _wd24.rowsel nxp0_0 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd24.i69.mxp1 _wd24.rowsel nxp0_0 _wd24.i69.p1 vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd24.i69.mxp15 _wd24.i69.p1 nxp1_3 vddp_nor vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd24.i69.mx_npd _wd24.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wd24.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U NF=1
m_wd24.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wd24.mxp12 wl49_r ra_en0_r wl48_r vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd24.mxp13 wl49_r ra_en1_r wl48_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd24.mxp14 wl49_l ra_en1_l wl48_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd24.mxp15 wl49_l ra_en0_l wl48_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd24._rowdrv_0.mxn0 wl48_r _wd24._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd24._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd24._rowdrv_0.mxn11 wl48_l _wd24._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd24._rowdrv_0.mxn8 _wd24._rowdrv_0.nwl _wd24.rowsel ni0 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd24._rowdrv_0.mxp0 wl48_r _wd24._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd24._rowdrv_0.mxp12 _wd24._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd24._rowdrv_0.mxp13 _wd24._rowdrv_0.nwl _wd24.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd24._rowdrv_0.mxp7 wl48_l _wd24._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd24._rowdrv_1.mxn0 wl49_r _wd24._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd24._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd24._rowdrv_1.mxn11 wl49_l _wd24._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd24._rowdrv_1.mxn8 _wd24._rowdrv_1.nwl _wd24.rowsel ni1 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd24._rowdrv_1.mxp0 wl49_r _wd24._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd24._rowdrv_1.mxp12 _wd24._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd24._rowdrv_1.mxp13 _wd24._rowdrv_1.nwl _wd24.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd24._rowdrv_1.mxp7 wl49_l _wd24._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd25.i69.mxn0 _wd25.rowsel nxp1_3 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd25.i69.mxn15 _wd25.rowsel nxp0_1 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd25.i69.mxp1 _wd25.rowsel nxp0_1 _wd25.i69.p1 vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd25.i69.mxp15 _wd25.i69.p1 nxp1_3 vddp_nor vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd25.i69.mx_npd _wd25.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wd25.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U NF=1
m_wd25.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wd25.mxp12 wl51_r ra_en0_r wl50_r vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd25.mxp13 wl51_r ra_en1_r wl50_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd25.mxp14 wl51_l ra_en1_l wl50_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd25.mxp15 wl51_l ra_en0_l wl50_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd25._rowdrv_0.mxn0 wl50_r _wd25._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd25._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd25._rowdrv_0.mxn11 wl50_l _wd25._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd25._rowdrv_0.mxn8 _wd25._rowdrv_0.nwl _wd25.rowsel ni0 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd25._rowdrv_0.mxp0 wl50_r _wd25._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd25._rowdrv_0.mxp12 _wd25._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd25._rowdrv_0.mxp13 _wd25._rowdrv_0.nwl _wd25.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd25._rowdrv_0.mxp7 wl50_l _wd25._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd25._rowdrv_1.mxn0 wl51_r _wd25._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd25._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd25._rowdrv_1.mxn11 wl51_l _wd25._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd25._rowdrv_1.mxn8 _wd25._rowdrv_1.nwl _wd25.rowsel ni1 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd25._rowdrv_1.mxp0 wl51_r _wd25._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd25._rowdrv_1.mxp12 _wd25._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd25._rowdrv_1.mxp13 _wd25._rowdrv_1.nwl _wd25.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd25._rowdrv_1.mxp7 wl51_l _wd25._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd26.i69.mxn0 _wd26.rowsel nxp1_3 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd26.i69.mxn15 _wd26.rowsel nxp0_2 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd26.i69.mxp1 _wd26.rowsel nxp0_2 _wd26.i69.p1 vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd26.i69.mxp15 _wd26.i69.p1 nxp1_3 vddp_nor vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd26.i69.mx_npd _wd26.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wd26.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U NF=1
m_wd26.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wd26.mxp12 wl53_r ra_en0_r wl52_r vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd26.mxp13 wl53_r ra_en1_r wl52_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd26.mxp14 wl53_l ra_en1_l wl52_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd26.mxp15 wl53_l ra_en0_l wl52_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd26._rowdrv_0.mxn0 wl52_r _wd26._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd26._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd26._rowdrv_0.mxn11 wl52_l _wd26._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd26._rowdrv_0.mxn8 _wd26._rowdrv_0.nwl _wd26.rowsel ni0 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd26._rowdrv_0.mxp0 wl52_r _wd26._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd26._rowdrv_0.mxp12 _wd26._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd26._rowdrv_0.mxp13 _wd26._rowdrv_0.nwl _wd26.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd26._rowdrv_0.mxp7 wl52_l _wd26._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd26._rowdrv_1.mxn0 wl53_r _wd26._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd26._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd26._rowdrv_1.mxn11 wl53_l _wd26._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd26._rowdrv_1.mxn8 _wd26._rowdrv_1.nwl _wd26.rowsel ni1 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd26._rowdrv_1.mxp0 wl53_r _wd26._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd26._rowdrv_1.mxp12 _wd26._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd26._rowdrv_1.mxp13 _wd26._rowdrv_1.nwl _wd26.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd26._rowdrv_1.mxp7 wl53_l _wd26._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd27.i69.mxn0 _wd27.rowsel nxp1_3 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd27.i69.mxn15 _wd27.rowsel nxp0_3 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd27.i69.mxp1 _wd27.rowsel nxp0_3 _wd27.i69.p1 vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd27.i69.mxp15 _wd27.i69.p1 nxp1_3 vddp_nor vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd27.i69.mx_npd _wd27.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wd27.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U NF=1
m_wd27.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wd27.mxp12 wl55_r ra_en0_r wl54_r vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd27.mxp13 wl55_r ra_en1_r wl54_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd27.mxp14 wl55_l ra_en1_l wl54_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd27.mxp15 wl55_l ra_en0_l wl54_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd27._rowdrv_0.mxn0 wl54_r _wd27._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd27._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd27._rowdrv_0.mxn11 wl54_l _wd27._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd27._rowdrv_0.mxn8 _wd27._rowdrv_0.nwl _wd27.rowsel ni0 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd27._rowdrv_0.mxp0 wl54_r _wd27._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd27._rowdrv_0.mxp12 _wd27._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd27._rowdrv_0.mxp13 _wd27._rowdrv_0.nwl _wd27.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd27._rowdrv_0.mxp7 wl54_l _wd27._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd27._rowdrv_1.mxn0 wl55_r _wd27._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd27._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd27._rowdrv_1.mxn11 wl55_l _wd27._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd27._rowdrv_1.mxn8 _wd27._rowdrv_1.nwl _wd27.rowsel ni1 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd27._rowdrv_1.mxp0 wl55_r _wd27._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd27._rowdrv_1.mxp12 _wd27._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd27._rowdrv_1.mxp13 _wd27._rowdrv_1.nwl _wd27.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd27._rowdrv_1.mxp7 wl55_l _wd27._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd28.i69.mxn0 _wd28.rowsel nxp1_3 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd28.i69.mxn15 _wd28.rowsel nxp0_4 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd28.i69.mxp1 _wd28.rowsel nxp0_4 _wd28.i69.p1 vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd28.i69.mxp15 _wd28.i69.p1 nxp1_3 vddp_nor vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd28.i69.mx_npd _wd28.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wd28.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U NF=1
m_wd28.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wd28.mxp12 wl57_r ra_en0_r wl56_r vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd28.mxp13 wl57_r ra_en1_r wl56_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd28.mxp14 wl57_l ra_en1_l wl56_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd28.mxp15 wl57_l ra_en0_l wl56_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd28._rowdrv_0.mxn0 wl56_r _wd28._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd28._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd28._rowdrv_0.mxn11 wl56_l _wd28._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd28._rowdrv_0.mxn8 _wd28._rowdrv_0.nwl _wd28.rowsel ni0 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd28._rowdrv_0.mxp0 wl56_r _wd28._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd28._rowdrv_0.mxp12 _wd28._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd28._rowdrv_0.mxp13 _wd28._rowdrv_0.nwl _wd28.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd28._rowdrv_0.mxp7 wl56_l _wd28._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd28._rowdrv_1.mxn0 wl57_r _wd28._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd28._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd28._rowdrv_1.mxn11 wl57_l _wd28._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd28._rowdrv_1.mxn8 _wd28._rowdrv_1.nwl _wd28.rowsel ni1 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd28._rowdrv_1.mxp0 wl57_r _wd28._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd28._rowdrv_1.mxp12 _wd28._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd28._rowdrv_1.mxp13 _wd28._rowdrv_1.nwl _wd28.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd28._rowdrv_1.mxp7 wl57_l _wd28._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd29.i69.mxn0 _wd29.rowsel nxp1_3 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd29.i69.mxn15 _wd29.rowsel nxp0_5 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd29.i69.mxp1 _wd29.rowsel nxp0_5 _wd29.i69.p1 vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd29.i69.mxp15 _wd29.i69.p1 nxp1_3 vddp_nor vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd29.i69.mx_npd _wd29.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wd29.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U NF=1
m_wd29.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wd29.mxp12 wl59_r ra_en0_r wl58_r vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd29.mxp13 wl59_r ra_en1_r wl58_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd29.mxp14 wl59_l ra_en1_l wl58_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd29.mxp15 wl59_l ra_en0_l wl58_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd29._rowdrv_0.mxn0 wl58_r _wd29._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd29._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd29._rowdrv_0.mxn11 wl58_l _wd29._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd29._rowdrv_0.mxn8 _wd29._rowdrv_0.nwl _wd29.rowsel ni0 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd29._rowdrv_0.mxp0 wl58_r _wd29._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd29._rowdrv_0.mxp12 _wd29._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd29._rowdrv_0.mxp13 _wd29._rowdrv_0.nwl _wd29.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd29._rowdrv_0.mxp7 wl58_l _wd29._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd29._rowdrv_1.mxn0 wl59_r _wd29._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd29._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd29._rowdrv_1.mxn11 wl59_l _wd29._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd29._rowdrv_1.mxn8 _wd29._rowdrv_1.nwl _wd29.rowsel ni1 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd29._rowdrv_1.mxp0 wl59_r _wd29._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd29._rowdrv_1.mxp12 _wd29._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd29._rowdrv_1.mxp13 _wd29._rowdrv_1.nwl _wd29.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd29._rowdrv_1.mxp7 wl59_l _wd29._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd3.i69.mxn0 _wd3.rowsel nxp1_0 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd3.i69.mxn15 _wd3.rowsel nxp0_3 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd3.i69.mxp1 _wd3.rowsel nxp0_3 _wd3.i69.p1 vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd3.i69.mxp15 _wd3.i69.p1 nxp1_0 vddp_nor vnwp pch_mac W=1.35U L=0.035U NF=1
m_wd3.i69.mx_npd _wd3.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wd3.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U NF=1
m_wd3.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wd3.mxp12 wl7_r ra_en0_r wl6_r vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd3.mxp13 wl7_r ra_en1_r wl6_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd3.mxp14 wl7_l ra_en1_l wl6_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd3.mxp15 wl7_l ra_en0_l wl6_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd3._rowdrv_0.mxn0 wl6_r _wd3._rowdrv_0.nwl vsse vpw nch_mac W=1.2U L=0.035U
+  NF=2
m_wd3._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd3._rowdrv_0.mxn11 wl6_l _wd3._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd3._rowdrv_0.mxn8 _wd3._rowdrv_0.nwl _wd3.rowsel ni0 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd3._rowdrv_0.mxp0 wl6_r _wd3._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd3._rowdrv_0.mxp12 _wd3._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd3._rowdrv_0.mxp13 _wd3._rowdrv_0.nwl _wd3.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd3._rowdrv_0.mxp7 wl6_l _wd3._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd3._rowdrv_1.mxn0 wl7_r _wd3._rowdrv_1.nwl vsse vpw nch_mac W=1.2U L=0.035U
+  NF=2
m_wd3._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd3._rowdrv_1.mxn11 wl7_l _wd3._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd3._rowdrv_1.mxn8 _wd3._rowdrv_1.nwl _wd3.rowsel ni1 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd3._rowdrv_1.mxp0 wl7_r _wd3._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd3._rowdrv_1.mxp12 _wd3._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd3._rowdrv_1.mxp13 _wd3._rowdrv_1.nwl _wd3.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd3._rowdrv_1.mxp7 wl7_l _wd3._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd30.i69.mxn0 _wd30.rowsel nxp1_3 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd30.i69.mxn15 _wd30.rowsel nxp0_6 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd30.i69.mxp1 _wd30.rowsel nxp0_6 _wd30.i69.p1 vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd30.i69.mxp15 _wd30.i69.p1 nxp1_3 vddp_nor vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd30.i69.mx_npd _wd30.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wd30.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U NF=1
m_wd30.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wd30.mxp12 wl61_r ra_en0_r wl60_r vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd30.mxp13 wl61_r ra_en1_r wl60_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd30.mxp14 wl61_l ra_en1_l wl60_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd30.mxp15 wl61_l ra_en0_l wl60_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd30._rowdrv_0.mxn0 wl60_r _wd30._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd30._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd30._rowdrv_0.mxn11 wl60_l _wd30._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd30._rowdrv_0.mxn8 _wd30._rowdrv_0.nwl _wd30.rowsel ni0 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd30._rowdrv_0.mxp0 wl60_r _wd30._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd30._rowdrv_0.mxp12 _wd30._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd30._rowdrv_0.mxp13 _wd30._rowdrv_0.nwl _wd30.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd30._rowdrv_0.mxp7 wl60_l _wd30._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd30._rowdrv_1.mxn0 wl61_r _wd30._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd30._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd30._rowdrv_1.mxn11 wl61_l _wd30._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd30._rowdrv_1.mxn8 _wd30._rowdrv_1.nwl _wd30.rowsel ni1 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd30._rowdrv_1.mxp0 wl61_r _wd30._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd30._rowdrv_1.mxp12 _wd30._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd30._rowdrv_1.mxp13 _wd30._rowdrv_1.nwl _wd30.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd30._rowdrv_1.mxp7 wl61_l _wd30._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd4.i69.mxn0 _wd4.rowsel nxp1_0 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd4.i69.mxn15 _wd4.rowsel nxp0_4 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd4.i69.mxp1 _wd4.rowsel nxp0_4 _wd4.i69.p1 vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd4.i69.mxp15 _wd4.i69.p1 nxp1_0 vddp_nor vnwp pch_mac W=1.35U L=0.035U NF=1
m_wd4.i69.mx_npd _wd4.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wd4.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U NF=1
m_wd4.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wd4.mxp12 wl9_r ra_en0_r wl8_r vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd4.mxp13 wl9_r ra_en1_r wl8_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd4.mxp14 wl9_l ra_en1_l wl8_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd4.mxp15 wl9_l ra_en0_l wl8_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd4._rowdrv_0.mxn0 wl8_r _wd4._rowdrv_0.nwl vsse vpw nch_mac W=1.2U L=0.035U
+  NF=2
m_wd4._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd4._rowdrv_0.mxn11 wl8_l _wd4._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd4._rowdrv_0.mxn8 _wd4._rowdrv_0.nwl _wd4.rowsel ni0 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd4._rowdrv_0.mxp0 wl8_r _wd4._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd4._rowdrv_0.mxp12 _wd4._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd4._rowdrv_0.mxp13 _wd4._rowdrv_0.nwl _wd4.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd4._rowdrv_0.mxp7 wl8_l _wd4._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd4._rowdrv_1.mxn0 wl9_r _wd4._rowdrv_1.nwl vsse vpw nch_mac W=1.2U L=0.035U
+  NF=2
m_wd4._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd4._rowdrv_1.mxn11 wl9_l _wd4._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd4._rowdrv_1.mxn8 _wd4._rowdrv_1.nwl _wd4.rowsel ni1 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd4._rowdrv_1.mxp0 wl9_r _wd4._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd4._rowdrv_1.mxp12 _wd4._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd4._rowdrv_1.mxp13 _wd4._rowdrv_1.nwl _wd4.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd4._rowdrv_1.mxp7 wl9_l _wd4._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd5.i69.mxn0 _wd5.rowsel nxp1_0 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd5.i69.mxn15 _wd5.rowsel nxp0_5 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd5.i69.mxp1 _wd5.rowsel nxp0_5 _wd5.i69.p1 vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd5.i69.mxp15 _wd5.i69.p1 nxp1_0 vddp_nor vnwp pch_mac W=1.35U L=0.035U NF=1
m_wd5.i69.mx_npd _wd5.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wd5.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U NF=1
m_wd5.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wd5.mxp12 wl11_r ra_en0_r wl10_r vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd5.mxp13 wl11_r ra_en1_r wl10_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd5.mxp14 wl11_l ra_en1_l wl10_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd5.mxp15 wl11_l ra_en0_l wl10_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd5._rowdrv_0.mxn0 wl10_r _wd5._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd5._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd5._rowdrv_0.mxn11 wl10_l _wd5._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd5._rowdrv_0.mxn8 _wd5._rowdrv_0.nwl _wd5.rowsel ni0 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd5._rowdrv_0.mxp0 wl10_r _wd5._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd5._rowdrv_0.mxp12 _wd5._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd5._rowdrv_0.mxp13 _wd5._rowdrv_0.nwl _wd5.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd5._rowdrv_0.mxp7 wl10_l _wd5._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd5._rowdrv_1.mxn0 wl11_r _wd5._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd5._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd5._rowdrv_1.mxn11 wl11_l _wd5._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd5._rowdrv_1.mxn8 _wd5._rowdrv_1.nwl _wd5.rowsel ni1 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd5._rowdrv_1.mxp0 wl11_r _wd5._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd5._rowdrv_1.mxp12 _wd5._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd5._rowdrv_1.mxp13 _wd5._rowdrv_1.nwl _wd5.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd5._rowdrv_1.mxp7 wl11_l _wd5._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd6.i69.mxn0 _wd6.rowsel nxp1_0 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd6.i69.mxn15 _wd6.rowsel nxp0_6 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd6.i69.mxp1 _wd6.rowsel nxp0_6 _wd6.i69.p1 vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd6.i69.mxp15 _wd6.i69.p1 nxp1_0 vddp_nor vnwp pch_mac W=1.35U L=0.035U NF=1
m_wd6.i69.mx_npd _wd6.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wd6.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U NF=1
m_wd6.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wd6.mxp12 wl13_r ra_en0_r wl12_r vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd6.mxp13 wl13_r ra_en1_r wl12_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd6.mxp14 wl13_l ra_en1_l wl12_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd6.mxp15 wl13_l ra_en0_l wl12_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd6._rowdrv_0.mxn0 wl12_r _wd6._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd6._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd6._rowdrv_0.mxn11 wl12_l _wd6._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd6._rowdrv_0.mxn8 _wd6._rowdrv_0.nwl _wd6.rowsel ni0 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd6._rowdrv_0.mxp0 wl12_r _wd6._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd6._rowdrv_0.mxp12 _wd6._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd6._rowdrv_0.mxp13 _wd6._rowdrv_0.nwl _wd6.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd6._rowdrv_0.mxp7 wl12_l _wd6._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd6._rowdrv_1.mxn0 wl13_r _wd6._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd6._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd6._rowdrv_1.mxn11 wl13_l _wd6._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd6._rowdrv_1.mxn8 _wd6._rowdrv_1.nwl _wd6.rowsel ni1 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd6._rowdrv_1.mxp0 wl13_r _wd6._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd6._rowdrv_1.mxp12 _wd6._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd6._rowdrv_1.mxp13 _wd6._rowdrv_1.nwl _wd6.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd6._rowdrv_1.mxp7 wl13_l _wd6._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd7.i69.mxn0 _wd7.rowsel nxp1_0 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd7.i69.mxn15 _wd7.rowsel nxp0_7 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd7.i69.mxp1 _wd7.rowsel nxp0_7 _wd7.i69.p1 vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd7.i69.mxp15 _wd7.i69.p1 nxp1_0 vddp_nor vnwp pch_mac W=1.35U L=0.035U NF=1
m_wd7.i69.mx_npd _wd7.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wd7.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U NF=1
m_wd7.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wd7.mxp12 wl15_r ra_en0_r wl14_r vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd7.mxp13 wl15_r ra_en1_r wl14_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd7.mxp14 wl15_l ra_en1_l wl14_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd7.mxp15 wl15_l ra_en0_l wl14_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd7._rowdrv_0.mxn0 wl14_r _wd7._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd7._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd7._rowdrv_0.mxn11 wl14_l _wd7._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd7._rowdrv_0.mxn8 _wd7._rowdrv_0.nwl _wd7.rowsel ni0 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd7._rowdrv_0.mxp0 wl14_r _wd7._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd7._rowdrv_0.mxp12 _wd7._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd7._rowdrv_0.mxp13 _wd7._rowdrv_0.nwl _wd7.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd7._rowdrv_0.mxp7 wl14_l _wd7._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd7._rowdrv_1.mxn0 wl15_r _wd7._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd7._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd7._rowdrv_1.mxn11 wl15_l _wd7._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd7._rowdrv_1.mxn8 _wd7._rowdrv_1.nwl _wd7.rowsel ni1 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd7._rowdrv_1.mxp0 wl15_r _wd7._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd7._rowdrv_1.mxp12 _wd7._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd7._rowdrv_1.mxp13 _wd7._rowdrv_1.nwl _wd7.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd7._rowdrv_1.mxp7 wl15_l _wd7._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd8.i69.mxn0 _wd8.rowsel nxp1_1 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd8.i69.mxn15 _wd8.rowsel nxp0_0 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd8.i69.mxp1 _wd8.rowsel nxp0_0 _wd8.i69.p1 vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd8.i69.mxp15 _wd8.i69.p1 nxp1_1 vddp_nor vnwp pch_mac W=1.35U L=0.035U NF=1
m_wd8.i69.mx_npd _wd8.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wd8.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U NF=1
m_wd8.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wd8.mxp12 wl17_r ra_en0_r wl16_r vnwc pch_mac W=0.15U L=0.035U NF=1

* 
* Copyright (c) 1993 - 2025 ARM. All Rights Reserved
* This file has been provided pursuant to a License Agreement
* containing restrictions on its use.  This file contains valuable
* trade secrets and proprietary information of ARM,
* and is protected by patents, copyright law
* and international treaties
* 
* Generated by bif2cdl 3.24.0
* Version: r3p1
* Name: High Density Single Port Register File SHVT MVT Compiler | 22ULL_ULL 22nm Process, 256 Rows Per Bit Line, 0.192um^2 BitCell
* Comment: This is a memory instance
* Configuration:  -PG_PINS_domain VDDCE -activity_factor 50 -atf of\
* Configuration: f -back_biasing off -bit_blast off -bits 46 -bmux \
* Configuration: off -check_instname on -diodes on -drive 6 -ema on\
* Configuration:  -frequency 500 -instname sram128x46 -left_bus_del\
* Configuration: im "[" -mux 2 -mvt BASE -name_case lower -power_ga\
* Configuration: ting off -power_type otc -pwr_gnd_rename vddpe:VDD\
* Configuration: PE,vddce:VDDCE,vsse:VSSE -rcols 2 -redundancy off \
* Configuration: -retention on -right_bus_delim "]" -rrows 0 -ser n\
* Configuration: one -single_domain_only on -site_def off -top_laye\
* Configuration: r m5-m10 -vmin_assist on -words 128 -wp_size 1 -wr\
* Configuration: ite_mask off -write_thru off -corners ffg_cbestt_0\
* Configuration: p88v_0p88v_0c,ffg_cbestt_0p88v_0p88v_125c,ffg_cbes\
* Configuration: tt_0p88v_0p88v_m40c,ssg_cworstt_0p72v_0p72v_0c,ssg\
* Configuration: _cworstt_0p72v_0p72v_125c,ssg_cworstt_0p72v_0p72v_\
* Configuration: m40c,tt_typical_0p80v_0p80v_25c,tt_typical_0p80v_0\
* Configuration: p80v_85c
* Codefile: 
* 
*
*.BIPOLAR
*.DIOAREA
*.DIOPERI
*
****
.subckt sram128x46cap_64_m2 cap_ctrl00 cap_ctrl00_term cap_ctrl01
+  cap_ctrl01_term cap_ctrl02 cap_ctrl02_term cap_ctrl10 cap_ctrl10_term
+  cap_ctrl11 cap_ctrl11_term cap_ctrl12 cap_ctrl12_term d0 d1 q0 q1 td0 td1
+  twen0 twen1 vddce vddp vddpe vnwp vpw vss vss_ast0 vss_ast0_term vss_ast1
+  vss_ast1_term vsse wen0 wen1 wen_lat0_term wen_lat1_term weny0 weny1
** sram128x46cap_64_m2: 6 flat devices **
mxm11 cap_ctrl01 vss_ast0 cap_ctrl01 vnwp pch_mac W=2U L=0.035U NF=6
mxp0 cap_ctrl00 vss_ast0 cap_ctrl00 vnwp pch_mac W=2U L=0.035U NF=17
mxp1 cap_ctrl12 vss_ast1 cap_ctrl12 vnwp pch_mac W=2U L=0.035U NF=6
mxp2 cap_ctrl02 vss_ast0 cap_ctrl02 vnwp pch_mac W=2U L=0.035U NF=6
mxp3 cap_ctrl10 vss_ast1 cap_ctrl10 vnwp pch_mac W=2U L=0.035U NF=17
mxp4 cap_ctrl11 vss_ast1 cap_ctrl11 vnwp pch_mac W=2U L=0.035U NF=6
.ends sram128x46cap_64_m2
****
.subckt sram128x46cap_r q1_11 vpw_11 vsse_11 cap_ctrl00_11 cap_ctrl01_11
+  cap_ctrl02_11 vddpe_11 vss_ast1_11 vss_ast0_11 twen0_11 wen0_11 td0_11
+  vddp_11 vss_11 q0_11 cap_ctrl10_11 cap_ctrl11_11 cap_ctrl12_11 q1_10
+  cap_ctrl00_10 cap_ctrl01_10 cap_ctrl02_10 d1_10 td1_10 twen1_10 weny1_10
+  wen_lat1_term_10 vss_ast1_10 vss_ast0_10 twen0_10 td0_10 vddpe_10 vddp_10
+  cap_ctrl10_10 cap_ctrl11_10 cap_ctrl12_10 q1_9 cap_ctrl00_9 cap_ctrl01_9
+  cap_ctrl02_9 vddpe_9 d1_9 wen1_9 weny1_9 wen_lat1_term_9 vss_ast1_9
+  wen_lat0_term_9 vss_ast0_9 weny0_9 twen0_9 d0_9 cap_ctrl10_9 cap_ctrl11_9
+  cap_ctrl12_9 vddce_8 cap_ctrl00_8 cap_ctrl01_8 cap_ctrl02_8 vddpe_8 d1_8
+  td1_8 wen1_8 twen1_8 weny1_8 wen_lat1_term_8 vss_ast1_8 wen_lat0_term_8
+  vss_ast0_8 weny0_8 twen0_8 wen0_8 td0_8 d0_8 vddp_8 vpw_8 cap_ctrl10_8
+  cap_ctrl11_8 cap_ctrl12_8 q1_7 vddce_7 vss_7 cap_ctrl00_7 cap_ctrl01_7
+  cap_ctrl02_7 vddpe_7 d1_7 td1_7 wen1_7 twen1_7 weny1_7 wen_lat1_term_7
+  vss_ast1_7 wen_lat0_term_7 vss_ast0_7 weny0_7 twen0_7 wen0_7 td0_7 d0_7
+  vddp_7 vpw_7 cap_ctrl10_7 cap_ctrl11_7 cap_ctrl12_7 q1_6 vpw_6 vss_6
+  cap_ctrl00_6 cap_ctrl01_6 cap_ctrl02_6 vddpe_6 vss_ast1_6 vss_ast0_6
+  twen0_6 wen0_6 td0_6 vddce_6 vddp_6 cap_ctrl10_6 cap_ctrl11_6 cap_ctrl12_6
+  vddce_5 cap_ctrl00_5 cap_ctrl01_5 cap_ctrl02_5 vddpe_5 d1_5 td1_5 wen1_5
+  twen1_5 weny1_5 wen_lat1_term_5 vss_ast1_5 wen_lat0_term_5 vss_ast0_5
+  weny0_5 twen0_5 wen0_5 td0_5 d0_5 vddp_5 vpw_5 cap_ctrl10_5 cap_ctrl11_5
+  cap_ctrl12_5 q1_4 vddce_4 vpw_4 vss_4 cap_ctrl00_4 cap_ctrl01_4
+  cap_ctrl02_4 vddpe_4 d1_4 td1_4 wen1_4 weny1_4 wen_lat1_term_4 vss_ast1_4
+  wen_lat0_term_4 vss_ast0_4 weny0_4 wen0_4 td0_4 d0_4 vddp_4 cap_ctrl10_4
+  cap_ctrl11_4 cap_ctrl12_4 q1_3 vpw_3 cap_ctrl00_3 cap_ctrl01_3 cap_ctrl02_3
+  vss_ast1_3 vss_ast0_3 twen0_3 wen0_3 td0_3 d0_3 vddpe_3 vddp_3 cap_ctrl10_3
+  cap_ctrl11_3 cap_ctrl12_3 q1_2 vddce_2 vpw_2 vss_2 cap_ctrl00_2
+  cap_ctrl01_2 cap_ctrl02_2 vddpe_2 d1_2 td1_2 wen1_2 weny1_2 wen_lat1_term_2
+  vss_ast1_2 wen_lat0_term_2 vss_ast0_2 weny0_2 twen0_2 wen0_2 td0_2 d0_2
+  vddp_2 cap_ctrl10_2 cap_ctrl11_2 cap_ctrl12_2 q1_1 vddce_1 vpw_1 vss_1
+  cap_ctrl00_1 cap_ctrl01_1 cap_ctrl02_1 d1_1 td1_1 wen1_1 weny1_1
+  wen_lat1_term_1 vss_ast1_1 wen_lat0_term_1 vss_ast0_1 weny0_1 wen0_1 td0_1
+  d0_1 vddp_1 q0_1 cap_ctrl10_1 cap_ctrl11_1 cap_ctrl12_1 q1_0 vpw_0
+  cap_ctrl00_0 cap_ctrl01_0 cap_ctrl02_0 twen1_0 wen_lat1_term_0 vss_ast1_0
+  wen_lat0_term_0 vss_ast0_0 weny0_0 twen0_0 wen0_0 td0_0 d0_0 vddpe_0 vddp_0
+  cap_ctrl10_0 cap_ctrl11_0 cap_ctrl12_0 vddce_11 vnwp_11 cap_ctrl00_term_11
+  cap_ctrl01_term_11 cap_ctrl02_term_11 d1_11 td1_11 wen1_11 twen1_11
+  weny1_11 wen_lat1_term_11 vss_ast1_term_11 wen_lat0_term_11
+  vss_ast0_term_11 weny0_11 d0_11 cap_ctrl10_term_11 cap_ctrl11_term_11
+  cap_ctrl12_term_11 vddce_10 vpw_10 vss_10 vsse_10 cap_ctrl00_term_10
+  cap_ctrl01_term_10 cap_ctrl02_term_10 wen1_10 vss_ast1_term_10
+  wen_lat0_term_10 vss_ast0_term_10 weny0_10 wen0_10 d0_10 vnwp_10 q0_10
+  cap_ctrl10_term_10 cap_ctrl11_term_10 cap_ctrl12_term_10 vpw_9 vss_9
+  cap_ctrl00_term_9 cap_ctrl01_term_9 cap_ctrl02_term_9 td1_9 twen1_9
+  vss_ast1_term_9 vss_ast0_term_9 wen0_9 td0_9 vddce_9 vddp_9 vsse_9 vnwp_9
+  q0_9 cap_ctrl10_term_9 cap_ctrl11_term_9 cap_ctrl12_term_9 q1_8 vss_8
+  vsse_8 cap_ctrl00_term_8 cap_ctrl01_term_8 cap_ctrl02_term_8
+  vss_ast1_term_8 vss_ast0_term_8 vnwp_8 q0_8 cap_ctrl10_term_8
+  cap_ctrl11_term_8 cap_ctrl12_term_8 vsse_7 cap_ctrl00_term_7
+  cap_ctrl01_term_7 cap_ctrl02_term_7 vss_ast1_term_7 vss_ast0_term_7 vnwp_7
+  q0_7 cap_ctrl10_term_7 cap_ctrl11_term_7 cap_ctrl12_term_7
+  cap_ctrl00_term_6 cap_ctrl01_term_6 cap_ctrl02_term_6 d1_6 td1_6 wen1_6
+  twen1_6 weny1_6 wen_lat1_term_6 vss_ast1_term_6 wen_lat0_term_6
+  vss_ast0_term_6 weny0_6 d0_6 vsse_6 vnwp_6 q0_6 cap_ctrl10_term_6
+  cap_ctrl11_term_6 cap_ctrl12_term_6 q1_5 vss_5 vsse_5 cap_ctrl00_term_5
+  cap_ctrl01_term_5 cap_ctrl02_term_5 vss_ast1_term_5 vss_ast0_term_5 vnwp_5
+  q0_5 cap_ctrl10_term_5 cap_ctrl11_term_5 cap_ctrl12_term_5 vsse_4
+  cap_ctrl00_term_4 cap_ctrl01_term_4 cap_ctrl02_term_4 twen1_4
+  vss_ast1_term_4 vss_ast0_term_4 twen0_4 vnwp_4 q0_4 cap_ctrl10_term_4
+  cap_ctrl11_term_4 cap_ctrl12_term_4 vddce_3 vss_3 vsse_3 cap_ctrl00_term_3
+  cap_ctrl01_term_3 cap_ctrl02_term_3 d1_3 td1_3 wen1_3 twen1_3 weny1_3
+  wen_lat1_term_3 vss_ast1_term_3 wen_lat0_term_3 vss_ast0_term_3 weny0_3
+  vnwp_3 q0_3 cap_ctrl10_term_3 cap_ctrl11_term_3 cap_ctrl12_term_3 vsse_2
+  cap_ctrl00_term_2 cap_ctrl01_term_2 cap_ctrl02_term_2 twen1_2
+  vss_ast1_term_2 vss_ast0_term_2 vnwp_2 q0_2 cap_ctrl10_term_2
+  cap_ctrl11_term_2 cap_ctrl12_term_2 vsse_1 cap_ctrl00_term_1
+  cap_ctrl01_term_1 cap_ctrl02_term_1 twen1_1 vss_ast1_term_1 vss_ast0_term_1
+  twen0_1 vddpe_1 vnwp_1 cap_ctrl10_term_1 cap_ctrl11_term_1
+  cap_ctrl12_term_1 vddce_0 vss_0 vsse_0 cap_ctrl00_term_0 cap_ctrl01_term_0
+  cap_ctrl02_term_0 d1_0 td1_0 wen1_0 weny1_0 vss_ast1_term_0 vss_ast0_term_0
+  vnwp_0 q0_0 cap_ctrl10_term_0 cap_ctrl11_term_0 cap_ctrl12_term_0
** sram128x46cap_r: 72 flat devices **
xr_cap_1 cap_ctrl00_1 cap_ctrl00_term_1 cap_ctrl01_1 cap_ctrl01_term_1
+  cap_ctrl02_1 cap_ctrl02_term_1 cap_ctrl10_1 cap_ctrl10_term_1 cap_ctrl11_1
+  cap_ctrl11_term_1 cap_ctrl12_1 cap_ctrl12_term_1 d0_1 d1_1 q0_1 q1_1 td0_1
+  td1_1 twen0_1 twen1_1 vddce_1 vddp_1 vddpe_1 vnwp_1 vpw_1 vss_1 vss_ast0_1
+  vss_ast0_term_1 vss_ast1_1 vss_ast1_term_1 vsse_1 wen0_1 wen1_1
+  wen_lat0_term_1 wen_lat1_term_1 weny0_1 weny1_1 sram128x46cap_64_m2
xr_cap_10 cap_ctrl00_10 cap_ctrl00_term_10 cap_ctrl01_10 cap_ctrl01_term_10
+  cap_ctrl02_10 cap_ctrl02_term_10 cap_ctrl10_10 cap_ctrl10_term_10
+  cap_ctrl11_10 cap_ctrl11_term_10 cap_ctrl12_10 cap_ctrl12_term_10 d0_10
+  d1_10 q0_10 q1_10 td0_10 td1_10 twen0_10 twen1_10 vddce_10 vddp_10 vddpe_10
+  vnwp_10 vpw_10 vss_10 vss_ast0_10 vss_ast0_term_10 vss_ast1_10
+  vss_ast1_term_10 vsse_10 wen0_10 wen1_10 wen_lat0_term_10 wen_lat1_term_10
+  weny0_10 weny1_10 sram128x46cap_64_m2
xr_cap_2 cap_ctrl00_2 cap_ctrl00_term_2 cap_ctrl01_2 cap_ctrl01_term_2
+  cap_ctrl02_2 cap_ctrl02_term_2 cap_ctrl10_2 cap_ctrl10_term_2 cap_ctrl11_2
+  cap_ctrl11_term_2 cap_ctrl12_2 cap_ctrl12_term_2 d0_2 d1_2 q0_2 q1_2 td0_2
+  td1_2 twen0_2 twen1_2 vddce_2 vddp_2 vddpe_2 vnwp_2 vpw_2 vss_2 vss_ast0_2
+  vss_ast0_term_2 vss_ast1_2 vss_ast1_term_2 vsse_2 wen0_2 wen1_2
+  wen_lat0_term_2 wen_lat1_term_2 weny0_2 weny1_2 sram128x46cap_64_m2
xr_cap_3 cap_ctrl00_3 cap_ctrl00_term_3 cap_ctrl01_3 cap_ctrl01_term_3
+  cap_ctrl02_3 cap_ctrl02_term_3 cap_ctrl10_3 cap_ctrl10_term_3 cap_ctrl11_3
+  cap_ctrl11_term_3 cap_ctrl12_3 cap_ctrl12_term_3 d0_3 d1_3 q0_3 q1_3 td0_3
+  td1_3 twen0_3 twen1_3 vddce_3 vddp_3 vddpe_3 vnwp_3 vpw_3 vss_3 vss_ast0_3
+  vss_ast0_term_3 vss_ast1_3 vss_ast1_term_3 vsse_3 wen0_3 wen1_3
+  wen_lat0_term_3 wen_lat1_term_3 weny0_3 weny1_3 sram128x46cap_64_m2
xr_cap_4 cap_ctrl00_4 cap_ctrl00_term_4 cap_ctrl01_4 cap_ctrl01_term_4
+  cap_ctrl02_4 cap_ctrl02_term_4 cap_ctrl10_4 cap_ctrl10_term_4 cap_ctrl11_4
+  cap_ctrl11_term_4 cap_ctrl12_4 cap_ctrl12_term_4 d0_4 d1_4 q0_4 q1_4 td0_4
+  td1_4 twen0_4 twen1_4 vddce_4 vddp_4 vddpe_4 vnwp_4 vpw_4 vss_4 vss_ast0_4
+  vss_ast0_term_4 vss_ast1_4 vss_ast1_term_4 vsse_4 wen0_4 wen1_4
+  wen_lat0_term_4 wen_lat1_term_4 weny0_4 weny1_4 sram128x46cap_64_m2
xr_cap_5 cap_ctrl00_5 cap_ctrl00_term_5 cap_ctrl01_5 cap_ctrl01_term_5
+  cap_ctrl02_5 cap_ctrl02_term_5 cap_ctrl10_5 cap_ctrl10_term_5 cap_ctrl11_5
+  cap_ctrl11_term_5 cap_ctrl12_5 cap_ctrl12_term_5 d0_5 d1_5 q0_5 q1_5 td0_5
+  td1_5 twen0_5 twen1_5 vddce_5 vddp_5 vddpe_5 vnwp_5 vpw_5 vss_5 vss_ast0_5
+  vss_ast0_term_5 vss_ast1_5 vss_ast1_term_5 vsse_5 wen0_5 wen1_5
+  wen_lat0_term_5 wen_lat1_term_5 weny0_5 weny1_5 sram128x46cap_64_m2
xr_cap_6 cap_ctrl00_6 cap_ctrl00_term_6 cap_ctrl01_6 cap_ctrl01_term_6
+  cap_ctrl02_6 cap_ctrl02_term_6 cap_ctrl10_6 cap_ctrl10_term_6 cap_ctrl11_6
+  cap_ctrl11_term_6 cap_ctrl12_6 cap_ctrl12_term_6 d0_6 d1_6 q0_6 q1_6 td0_6
+  td1_6 twen0_6 twen1_6 vddce_6 vddp_6 vddpe_6 vnwp_6 vpw_6 vss_6 vss_ast0_6
+  vss_ast0_term_6 vss_ast1_6 vss_ast1_term_6 vsse_6 wen0_6 wen1_6
+  wen_lat0_term_6 wen_lat1_term_6 weny0_6 weny1_6 sram128x46cap_64_m2
xr_cap_7 cap_ctrl00_7 cap_ctrl00_term_7 cap_ctrl01_7 cap_ctrl01_term_7
+  cap_ctrl02_7 cap_ctrl02_term_7 cap_ctrl10_7 cap_ctrl10_term_7 cap_ctrl11_7
+  cap_ctrl11_term_7 cap_ctrl12_7 cap_ctrl12_term_7 d0_7 d1_7 q0_7 q1_7 td0_7
+  td1_7 twen0_7 twen1_7 vddce_7 vddp_7 vddpe_7 vnwp_7 vpw_7 vss_7 vss_ast0_7
+  vss_ast0_term_7 vss_ast1_7 vss_ast1_term_7 vsse_7 wen0_7 wen1_7
+  wen_lat0_term_7 wen_lat1_term_7 weny0_7 weny1_7 sram128x46cap_64_m2
xr_cap_8 cap_ctrl00_8 cap_ctrl00_term_8 cap_ctrl01_8 cap_ctrl01_term_8
+  cap_ctrl02_8 cap_ctrl02_term_8 cap_ctrl10_8 cap_ctrl10_term_8 cap_ctrl11_8
+  cap_ctrl11_term_8 cap_ctrl12_8 cap_ctrl12_term_8 d0_8 d1_8 q0_8 q1_8 td0_8
+  td1_8 twen0_8 twen1_8 vddce_8 vddp_8 vddpe_8 vnwp_8 vpw_8 vss_8 vss_ast0_8
+  vss_ast0_term_8 vss_ast1_8 vss_ast1_term_8 vsse_8 wen0_8 wen1_8
+  wen_lat0_term_8 wen_lat1_term_8 weny0_8 weny1_8 sram128x46cap_64_m2
xr_cap_9 cap_ctrl00_9 cap_ctrl00_term_9 cap_ctrl01_9 cap_ctrl01_term_9
+  cap_ctrl02_9 cap_ctrl02_term_9 cap_ctrl10_9 cap_ctrl10_term_9 cap_ctrl11_9
+  cap_ctrl11_term_9 cap_ctrl12_9 cap_ctrl12_term_9 d0_9 d1_9 q0_9 q1_9 td0_9
+  td1_9 twen0_9 twen1_9 vddce_9 vddp_9 vddpe_9 vnwp_9 vpw_9 vss_9 vss_ast0_9
+  vss_ast0_term_9 vss_ast1_9 vss_ast1_term_9 vsse_9 wen0_9 wen1_9
+  wen_lat0_term_9 wen_lat1_term_9 weny0_9 weny1_9 sram128x46cap_64_m2
xr_cap_l cap_ctrl00_0 cap_ctrl00_term_0 cap_ctrl01_0 cap_ctrl01_term_0
+  cap_ctrl02_0 cap_ctrl02_term_0 cap_ctrl10_0 cap_ctrl10_term_0 cap_ctrl11_0
+  cap_ctrl11_term_0 cap_ctrl12_0 cap_ctrl12_term_0 d0_0 d1_0 q0_0 q1_0 td0_0
+  td1_0 twen0_0 twen1_0 vddce_0 vddp_0 vddpe_0 vnwp_0 vpw_0 vss_0 vss_ast0_0
+  vss_ast0_term_0 vss_ast1_0 vss_ast1_term_0 vsse_0 wen0_0 wen1_0
+  wen_lat0_term_0 wen_lat1_term_0 weny0_0 weny1_0 sram128x46cap_64_m2
xr_cap_r cap_ctrl00_11 cap_ctrl00_term_11 cap_ctrl01_11 cap_ctrl01_term_11
+  cap_ctrl02_11 cap_ctrl02_term_11 cap_ctrl10_11 cap_ctrl10_term_11
+  cap_ctrl11_11 cap_ctrl11_term_11 cap_ctrl12_11 cap_ctrl12_term_11 d0_11
+  d1_11 q0_11 q1_11 td0_11 td1_11 twen0_11 twen1_11 vddce_11 vddp_11 vddpe_11
+  vnwp_11 vpw_11 vss_11 vss_ast0_11 vss_ast0_term_11 vss_ast1_11
+  vss_ast1_term_11 vsse_11 wen0_11 wen1_11 wen_lat0_term_11 wen_lat1_term_11
+  weny0_11 weny1_11 sram128x46cap_64_m2
.ends sram128x46cap_r
****
.subckt sram128x46cap_row_r vnwp_12 si psi q1_11 vpw_11 cap_ctrl00_11
+  cap_ctrl01_11 cap_ctrl02_11 vddpe_11 vss_ast1_11 vss_ast0_11 twen0_11
+  wen0_11 td0_11 vddp_11 vss_11 q0_11 cap_ctrl10_11 cap_ctrl11_11
+  cap_ctrl12_11 q1_10 cap_ctrl00_10 cap_ctrl01_10 cap_ctrl02_10 d1_10 td1_10
+  twen1_10 weny1_10 wen_lat1_term_10 vss_ast1_10 vss_ast0_10 twen0_10 td0_10
+  vddpe_10 vddp_10 cap_ctrl10_10 cap_ctrl11_10 cap_ctrl12_10 cap_ctrl00_9
+  cap_ctrl01_9 cap_ctrl02_9 vddpe_9 d1_9 wen1_9 weny1_9 wen_lat1_term_9
+  vss_ast1_9 wen_lat0_term_9 vss_ast0_9 weny0_9 twen0_9 d0_9 vddp_9 vpw_9
+  cap_ctrl10_9 cap_ctrl11_9 cap_ctrl12_9 vddce_8 cap_ctrl00_8 cap_ctrl01_8
+  cap_ctrl02_8 vddpe_8 d1_8 td1_8 wen1_8 twen1_8 weny1_8 wen_lat1_term_8
+  vss_ast1_8 wen_lat0_term_8 vss_ast0_8 weny0_8 twen0_8 wen0_8 td0_8 d0_8
+  vddp_8 vsse_8 vpw_8 cap_ctrl10_8 cap_ctrl11_8 cap_ctrl12_8 q1_7 vddce_7
+  vss_7 cap_ctrl00_7 cap_ctrl01_7 cap_ctrl02_7 vddpe_7 d1_7 td1_7 wen1_7
+  weny1_7 wen_lat1_term_7 vss_ast1_7 wen_lat0_term_7 vss_ast0_7 weny0_7
+  twen0_7 wen0_7 td0_7 d0_7 vddp_7 vsse_7 vpw_7 cap_ctrl10_7 cap_ctrl11_7
+  cap_ctrl12_7 q1_6 vpw_6 cap_ctrl00_6 cap_ctrl01_6 cap_ctrl02_6 vss_ast1_6
+  vss_ast0_6 weny0_6 twen0_6 wen0_6 td0_6 d0_6 vddpe_6 vddp_6 cap_ctrl10_6
+  cap_ctrl11_6 cap_ctrl12_6 vddce_5 vss_5 cap_ctrl00_5 cap_ctrl01_5
+  cap_ctrl02_5 vddpe_5 d1_5 td1_5 wen1_5 twen1_5 weny1_5 wen_lat1_term_5
+  vss_ast1_5 wen_lat0_term_5 vss_ast0_5 weny0_5 twen0_5 wen0_5 td0_5 d0_5
+  vddp_5 vsse_5 vpw_5 cap_ctrl10_5 cap_ctrl11_5 cap_ctrl12_5 q1_4 vddce_4
+  vpw_4 vss_4 cap_ctrl00_4 cap_ctrl01_4 cap_ctrl02_4 vddpe_4 d1_4 td1_4
+  wen1_4 weny1_4 wen_lat1_term_4 vss_ast1_4 wen_lat0_term_4 vss_ast0_4
+  weny0_4 wen0_4 td0_4 q0_4 cap_ctrl10_4 cap_ctrl11_4 cap_ctrl12_4 q1_3 vpw_3
+  cap_ctrl00_3 cap_ctrl01_3 cap_ctrl02_3 twen1_3 weny1_3 wen_lat1_term_3
+  vss_ast1_3 wen_lat0_term_3 vss_ast0_3 weny0_3 twen0_3 wen0_3 td0_3 d0_3
+  vddpe_3 vddp_3 vsse_3 cap_ctrl10_3 cap_ctrl11_3 cap_ctrl12_3 q1_2 vddce_2
+  vpw_2 vss_2 cap_ctrl00_2 cap_ctrl01_2 cap_ctrl02_2 d1_2 td1_2 wen1_2
+  weny1_2 wen_lat1_term_2 vss_ast1_2 wen_lat0_term_2 vss_ast0_2 weny0_2
+  wen0_2 td0_2 d0_2 vddp_2 vsse_2 cap_ctrl10_2 cap_ctrl11_2 cap_ctrl12_2 q1_1
+  vddce_1 vpw_1 vss_1 cap_ctrl00_1 cap_ctrl01_1 cap_ctrl02_1 vddpe_1 d1_1
+  td1_1 wen1_1 weny1_1 wen_lat1_term_1 vss_ast1_1 wen_lat0_term_1 vss_ast0_1
+  twen0_1 wen0_1 td0_1 q0_1 cap_ctrl10_1 cap_ctrl11_1 cap_ctrl12_1 q1_0 vpw_0
+  cap_ctrl00_0 cap_ctrl01_0 cap_ctrl02_0 vddpe_0 d1_0 td1_0 wen1_0 weny1_0
+  wen_lat1_term_0 vss_ast1_0 wen_lat0_term_0 vss_ast0_0 weny0_0 wen0_0 td0_0
+  d0_0 vddp_0 vsse_0 cap_ctrl10_0 cap_ctrl11_0 cap_ctrl12_0 vsse_12 vnwc
+  vpw_12 vddce_11 vnwp_11 cap_ctrl00_term_11 cap_ctrl01_term_11
+  cap_ctrl02_term_11 d1_11 td1_11 wen1_11 twen1_11 weny1_11 wen_lat1_term_11
+  vss_ast1_term_11 wen_lat0_term_11 vss_ast0_term_11 weny0_11 d0_11 vsse_11
+  cap_ctrl10_term_11 cap_ctrl11_term_11 cap_ctrl12_term_11 vddce_10 vpw_10
+  vss_10 vsse_10 cap_ctrl00_term_10 cap_ctrl01_term_10 cap_ctrl02_term_10
+  wen1_10 vss_ast1_term_10 wen_lat0_term_10 vss_ast0_term_10 weny0_10 wen0_10
+  d0_10 vnwp_10 q0_10 cap_ctrl10_term_10 cap_ctrl11_term_10
+  cap_ctrl12_term_10 q1_9 vddce_9 vss_9 cap_ctrl00_term_9 cap_ctrl01_term_9
+  cap_ctrl02_term_9 td1_9 twen1_9 vss_ast1_term_9 vss_ast0_term_9 wen0_9
+  td0_9 vsse_9 vnwp_9 q0_9 cap_ctrl10_term_9 cap_ctrl11_term_9
+  cap_ctrl12_term_9 q1_8 vss_8 cap_ctrl00_term_8 cap_ctrl01_term_8
+  cap_ctrl02_term_8 vss_ast1_term_8 vss_ast0_term_8 vnwp_8 q0_8
+  cap_ctrl10_term_8 cap_ctrl11_term_8 cap_ctrl12_term_8 cap_ctrl00_term_7
+  cap_ctrl01_term_7 cap_ctrl02_term_7 twen1_7 vss_ast1_term_7 vss_ast0_term_7
+  vnwp_7 q0_7 cap_ctrl10_term_7 cap_ctrl11_term_7 cap_ctrl12_term_7 vddce_6
+  vss_6 vsse_6 cap_ctrl00_term_6 cap_ctrl01_term_6 cap_ctrl02_term_6 d1_6
+  td1_6 wen1_6 twen1_6 weny1_6 wen_lat1_term_6 vss_ast1_term_6
+  wen_lat0_term_6 vss_ast0_term_6 vnwp_6 q0_6 cap_ctrl10_term_6
+  cap_ctrl11_term_6 cap_ctrl12_term_6 q1_5 cap_ctrl00_term_5
+  cap_ctrl01_term_5 cap_ctrl02_term_5 vss_ast1_term_5 vss_ast0_term_5 vnwp_5
+  q0_5 cap_ctrl10_term_5 cap_ctrl11_term_5 cap_ctrl12_term_5
+  cap_ctrl00_term_4 cap_ctrl01_term_4 cap_ctrl02_term_4 twen1_4
+  vss_ast1_term_4 vss_ast0_term_4 twen0_4 d0_4 vddp_4 vsse_4 vnwp_4
+  cap_ctrl10_term_4 cap_ctrl11_term_4 cap_ctrl12_term_4 vddce_3 vss_3
+  cap_ctrl00_term_3 cap_ctrl01_term_3 cap_ctrl02_term_3 d1_3 td1_3 wen1_3
+  vss_ast1_term_3 vss_ast0_term_3 vnwp_3 q0_3 cap_ctrl10_term_3
+  cap_ctrl11_term_3 cap_ctrl12_term_3 cap_ctrl00_term_2 cap_ctrl01_term_2
+  cap_ctrl02_term_2 twen1_2 vss_ast1_term_2 vss_ast0_term_2 twen0_2 vddpe_2
+  vnwp_2 q0_2 cap_ctrl10_term_2 cap_ctrl11_term_2 cap_ctrl12_term_2 vnwp_1
+  cap_ctrl00_term_1 cap_ctrl01_term_1 cap_ctrl02_term_1 twen1_1
+  vss_ast1_term_1 vss_ast0_term_1 weny0_1 d0_1 vddp_1 vsse_1
+  cap_ctrl10_term_1 cap_ctrl11_term_1 cap_ctrl12_term_1 vddce_0 vss_0
+  cap_ctrl00_term_0 cap_ctrl01_term_0 cap_ctrl02_term_0 twen1_0
+  vss_ast1_term_0 vss_ast0_term_0 twen0_0 vnwp_0 q0_0 cap_ctrl10_term_0
+  cap_ctrl11_term_0 cap_ctrl12_term_0
** sram128x46cap_row_r: 72 flat devices **
xcap_cdm_row_r q1_11 vpw_11 vsse_11 cap_ctrl00_11 cap_ctrl01_11 cap_ctrl02_11
+  vddpe_11 vss_ast1_11 vss_ast0_11 twen0_11 wen0_11 td0_11 vddp_11 vss_11
+  q0_11 cap_ctrl10_11 cap_ctrl11_11 cap_ctrl12_11 q1_10 cap_ctrl00_10
+  cap_ctrl01_10 cap_ctrl02_10 d1_10 td1_10 twen1_10 weny1_10 wen_lat1_term_10
+  vss_ast1_10 vss_ast0_10 twen0_10 td0_10 vddpe_10 vddp_10 cap_ctrl10_10
+  cap_ctrl11_10 cap_ctrl12_10 q1_9 cap_ctrl00_9 cap_ctrl01_9 cap_ctrl02_9
+  vddpe_9 d1_9 wen1_9 weny1_9 wen_lat1_term_9 vss_ast1_9 wen_lat0_term_9
+  vss_ast0_9 weny0_9 twen0_9 d0_9 cap_ctrl10_9 cap_ctrl11_9 cap_ctrl12_9
+  vddce_8 cap_ctrl00_8 cap_ctrl01_8 cap_ctrl02_8 vddpe_8 d1_8 td1_8 wen1_8
+  twen1_8 weny1_8 wen_lat1_term_8 vss_ast1_8 wen_lat0_term_8 vss_ast0_8
+  weny0_8 twen0_8 wen0_8 td0_8 d0_8 vddp_8 vpw_8 cap_ctrl10_8 cap_ctrl11_8
+  cap_ctrl12_8 q1_7 vddce_7 vss_7 cap_ctrl00_7 cap_ctrl01_7 cap_ctrl02_7
+  vddpe_7 d1_7 td1_7 wen1_7 twen1_7 weny1_7 wen_lat1_term_7 vss_ast1_7
+  wen_lat0_term_7 vss_ast0_7 weny0_7 twen0_7 wen0_7 td0_7 d0_7 vddp_7 vpw_7
+  cap_ctrl10_7 cap_ctrl11_7 cap_ctrl12_7 q1_6 vpw_6 vss_6 cap_ctrl00_6
+  cap_ctrl01_6 cap_ctrl02_6 vddpe_6 vss_ast1_6 vss_ast0_6 twen0_6 wen0_6
+  td0_6 vddce_6 vddp_6 cap_ctrl10_6 cap_ctrl11_6 cap_ctrl12_6 vddce_5
+  cap_ctrl00_5 cap_ctrl01_5 cap_ctrl02_5 vddpe_5 d1_5 td1_5 wen1_5 twen1_5
+  weny1_5 wen_lat1_term_5 vss_ast1_5 wen_lat0_term_5 vss_ast0_5 weny0_5
+  twen0_5 wen0_5 td0_5 d0_5 vddp_5 vpw_5 cap_ctrl10_5 cap_ctrl11_5
+  cap_ctrl12_5 q1_4 vddce_4 vpw_4 vss_4 cap_ctrl00_4 cap_ctrl01_4
+  cap_ctrl02_4 vddpe_4 d1_4 td1_4 wen1_4 weny1_4 wen_lat1_term_4 vss_ast1_4
+  wen_lat0_term_4 vss_ast0_4 weny0_4 wen0_4 td0_4 d0_4 vddp_4 cap_ctrl10_4
+  cap_ctrl11_4 cap_ctrl12_4 q1_3 vpw_3 cap_ctrl00_3 cap_ctrl01_3 cap_ctrl02_3
+  vss_ast1_3 vss_ast0_3 twen0_3 wen0_3 td0_3 d0_3 vddpe_3 vddp_3 cap_ctrl10_3
+  cap_ctrl11_3 cap_ctrl12_3 q1_2 vddce_2 vpw_2 vss_2 cap_ctrl00_2
+  cap_ctrl01_2 cap_ctrl02_2 vddpe_2 d1_2 td1_2 wen1_2 weny1_2 wen_lat1_term_2
+  vss_ast1_2 wen_lat0_term_2 vss_ast0_2 weny0_2 twen0_2 wen0_2 td0_2 d0_2
+  vddp_2 cap_ctrl10_2 cap_ctrl11_2 cap_ctrl12_2 q1_1 vddce_1 vpw_1 vss_1
+  cap_ctrl00_1 cap_ctrl01_1 cap_ctrl02_1 d1_1 td1_1 wen1_1 weny1_1
+  wen_lat1_term_1 vss_ast1_1 wen_lat0_term_1 vss_ast0_1 weny0_1 wen0_1 td0_1
+  d0_1 vddp_1 q0_1 cap_ctrl10_1 cap_ctrl11_1 cap_ctrl12_1 q1_0 vpw_0
+  cap_ctrl00_0 cap_ctrl01_0 cap_ctrl02_0 twen1_0 wen_lat1_term_0 vss_ast1_0
+  wen_lat0_term_0 vss_ast0_0 weny0_0 twen0_0 wen0_0 td0_0 d0_0 vddpe_0 vddp_0
+  cap_ctrl10_0 cap_ctrl11_0 cap_ctrl12_0 vddce_11 vnwp_11 cap_ctrl00_term_11
+  cap_ctrl01_term_11 cap_ctrl02_term_11 d1_11 td1_11 wen1_11 twen1_11
+  weny1_11 wen_lat1_term_11 vss_ast1_term_11 wen_lat0_term_11
+  vss_ast0_term_11 weny0_11 d0_11 cap_ctrl10_term_11 cap_ctrl11_term_11
+  cap_ctrl12_term_11 vddce_10 vpw_10 vss_10 vsse_10 cap_ctrl00_term_10
+  cap_ctrl01_term_10 cap_ctrl02_term_10 wen1_10 vss_ast1_term_10
+  wen_lat0_term_10 vss_ast0_term_10 weny0_10 wen0_10 d0_10 vnwp_10 q0_10
+  cap_ctrl10_term_10 cap_ctrl11_term_10 cap_ctrl12_term_10 vpw_9 vss_9
+  cap_ctrl00_term_9 cap_ctrl01_term_9 cap_ctrl02_term_9 td1_9 twen1_9
+  vss_ast1_term_9 vss_ast0_term_9 wen0_9 td0_9 vddce_9 vddp_9 vsse_9 vnwp_9
+  q0_9 cap_ctrl10_term_9 cap_ctrl11_term_9 cap_ctrl12_term_9 q1_8 vss_8
+  vsse_8 cap_ctrl00_term_8 cap_ctrl01_term_8 cap_ctrl02_term_8
+  vss_ast1_term_8 vss_ast0_term_8 vnwp_8 q0_8 cap_ctrl10_term_8
+  cap_ctrl11_term_8 cap_ctrl12_term_8 vsse_7 cap_ctrl00_term_7
+  cap_ctrl01_term_7 cap_ctrl02_term_7 vss_ast1_term_7 vss_ast0_term_7 vnwp_7
+  q0_7 cap_ctrl10_term_7 cap_ctrl11_term_7 cap_ctrl12_term_7
+  cap_ctrl00_term_6 cap_ctrl01_term_6 cap_ctrl02_term_6 d1_6 td1_6 wen1_6
+  twen1_6 weny1_6 wen_lat1_term_6 vss_ast1_term_6 wen_lat0_term_6
+  vss_ast0_term_6 weny0_6 d0_6 vsse_6 vnwp_6 q0_6 cap_ctrl10_term_6
+  cap_ctrl11_term_6 cap_ctrl12_term_6 q1_5 vss_5 vsse_5 cap_ctrl00_term_5
+  cap_ctrl01_term_5 cap_ctrl02_term_5 vss_ast1_term_5 vss_ast0_term_5 vnwp_5
+  q0_5 cap_ctrl10_term_5 cap_ctrl11_term_5 cap_ctrl12_term_5 vsse_4
+  cap_ctrl00_term_4 cap_ctrl01_term_4 cap_ctrl02_term_4 twen1_4
+  vss_ast1_term_4 vss_ast0_term_4 twen0_4 vnwp_4 q0_4 cap_ctrl10_term_4
+  cap_ctrl11_term_4 cap_ctrl12_term_4 vddce_3 vss_3 vsse_3 cap_ctrl00_term_3
+  cap_ctrl01_term_3 cap_ctrl02_term_3 d1_3 td1_3 wen1_3 twen1_3 weny1_3
+  wen_lat1_term_3 vss_ast1_term_3 wen_lat0_term_3 vss_ast0_term_3 weny0_3
+  vnwp_3 q0_3 cap_ctrl10_term_3 cap_ctrl11_term_3 cap_ctrl12_term_3 vsse_2
+  cap_ctrl00_term_2 cap_ctrl01_term_2 cap_ctrl02_term_2 twen1_2
+  vss_ast1_term_2 vss_ast0_term_2 vnwp_2 q0_2 cap_ctrl10_term_2
+  cap_ctrl11_term_2 cap_ctrl12_term_2 vsse_1 cap_ctrl00_term_1
+  cap_ctrl01_term_1 cap_ctrl02_term_1 twen1_1 vss_ast1_term_1 vss_ast0_term_1
+  twen0_1 vddpe_1 vnwp_1 cap_ctrl10_term_1 cap_ctrl11_term_1
+  cap_ctrl12_term_1 vddce_0 vss_0 vsse_0 cap_ctrl00_term_0 cap_ctrl01_term_0
+  cap_ctrl02_term_0 d1_0 td1_0 wen1_0 weny1_0 vss_ast1_term_0 vss_ast0_term_0
+  vnwp_0 q0_0 cap_ctrl10_term_0 cap_ctrl11_term_0 cap_ctrl12_term_0
+  sram128x46cap_r
.ends sram128x46cap_row_r
****
.subckt sram128x46cap_l cap_ctrl12_10 cap_ctrl11_10 cap_ctrl10_10 q0_10 vss_10
+  vddp_10 td0_10 wen0_10 twen0_10 vss_ast0_10 vss_ast1_10 vddpe_10
+  cap_ctrl02_10 cap_ctrl01_10 cap_ctrl00_10 vsse_10 vpw_10 q1_10 cap_ctrl12_9
+  cap_ctrl11_9 cap_ctrl10_9 vddp_9 vddpe_9 td0_9 twen0_9 vss_ast0_9
+  vss_ast1_9 wen_lat1_term_9 weny1_9 twen1_9 d1_9 cap_ctrl02_9 cap_ctrl01_9
+  cap_ctrl00_9 vnwp_9 cap_ctrl12_8 cap_ctrl11_8 cap_ctrl10_8 vddp_8 td0_8
+  twen0_8 weny0_8 vss_ast0_8 wen_lat0_term_8 vss_ast1_8 wen_lat1_term_8
+  weny1_8 twen1_8 wen1_8 d1_8 vddpe_8 cap_ctrl02_8 cap_ctrl01_8 cap_ctrl00_8
+  vddce_8 cap_ctrl12_7 cap_ctrl11_7 cap_ctrl10_7 vpw_7 vddp_7 wen0_7 twen0_7
+  weny0_7 vss_ast0_7 wen_lat0_term_7 vss_ast1_7 wen_lat1_term_7 weny1_7
+  twen1_7 wen1_7 td1_7 d1_7 vddpe_7 cap_ctrl02_7 cap_ctrl01_7 cap_ctrl00_7
+  cap_ctrl12_6 cap_ctrl11_6 cap_ctrl10_6 vsse_6 vddp_6 d0_6 td0_6 wen0_6
+  twen0_6 weny0_6 vss_ast0_6 wen_lat0_term_6 vss_ast1_6 wen_lat1_term_6
+  weny1_6 twen1_6 wen1_6 td1_6 d1_6 vddpe_6 cap_ctrl02_6 cap_ctrl01_6
+  cap_ctrl00_6 vss_6 vpw_6 q1_6 cap_ctrl12_5 cap_ctrl11_5 cap_ctrl10_5 vpw_5
+  vsse_5 vddp_5 d0_5 td0_5 wen0_5 twen0_5 weny0_5 vss_ast0_5 wen_lat0_term_5
+  vss_ast1_5 wen_lat1_term_5 weny1_5 wen1_5 td1_5 d1_5 vddpe_5 cap_ctrl02_5
+  cap_ctrl01_5 cap_ctrl00_5 vddce_5 cap_ctrl12_4 cap_ctrl11_4 cap_ctrl10_4
+  vsse_4 vddp_4 d0_4 td0_4 wen0_4 twen0_4 weny0_4 vss_ast0_4 wen_lat0_term_4
+  vss_ast1_4 wen_lat1_term_4 weny1_4 twen1_4 wen1_4 td1_4 d1_4 vddpe_4
+  cap_ctrl02_4 cap_ctrl01_4 cap_ctrl00_4 vss_4 vpw_4 q1_4 cap_ctrl12_3
+  cap_ctrl11_3 cap_ctrl10_3 vsse_3 vddp_3 d0_3 td0_3 wen0_3 twen0_3 weny0_3
+  vss_ast0_3 wen_lat0_term_3 vss_ast1_3 wen_lat1_term_3 weny1_3 twen1_3
+  wen1_3 td1_3 d1_3 vddpe_3 cap_ctrl02_3 cap_ctrl01_3 cap_ctrl00_3 vss_3
+  vpw_3 q1_3 cap_ctrl12_2 cap_ctrl11_2 cap_ctrl10_2 q0_2 vsse_2 vddp_2 d0_2
+  td0_2 wen0_2 weny0_2 vss_ast0_2 wen_lat0_term_2 vss_ast1_2 wen_lat1_term_2
+  weny1_2 wen1_2 td1_2 d1_2 vddpe_2 cap_ctrl02_2 cap_ctrl01_2 cap_ctrl00_2
+  vss_2 vpw_2 vddce_2 q1_2 cap_ctrl12_1 cap_ctrl11_1 cap_ctrl10_1 vsse_1
+  vddp_1 d0_1 td0_1 wen0_1 twen0_1 weny0_1 vss_ast0_1 wen_lat0_term_1
+  vss_ast1_1 wen_lat1_term_1 weny1_1 twen1_1 wen1_1 td1_1 d1_1 vddpe_1
+  cap_ctrl02_1 cap_ctrl01_1 cap_ctrl00_1 vss_1 vpw_1 q1_1 cap_ctrl12_0
+  cap_ctrl11_0 cap_ctrl10_0 vsse_0 vddp_0 d0_0 td0_0 wen0_0 twen0_0 weny0_0
+  vss_ast0_0 wen_lat0_term_0 vss_ast1_0 wen_lat1_term_0 weny1_0 wen1_0 td1_0
+  d1_0 vddpe_0 cap_ctrl02_0 cap_ctrl01_0 cap_ctrl00_0 vss_0 vpw_0 q1_0
+  cap_ctrl12_term_10 cap_ctrl11_term_10 cap_ctrl10_term_10 d0_10 weny0_10
+  vss_ast0_term_10 wen_lat0_term_10 vss_ast1_term_10 wen_lat1_term_10
+  weny1_10 twen1_10 wen1_10 td1_10 d1_10 cap_ctrl02_term_10
+  cap_ctrl01_term_10 cap_ctrl00_term_10 vnwp_10 vddce_10 cap_ctrl12_term_9
+  cap_ctrl11_term_9 cap_ctrl10_term_9 q0_9 vsse_9 d0_9 wen0_9 weny0_9
+  vss_ast0_term_9 wen_lat0_term_9 vss_ast1_term_9 wen1_9 td1_9
+  cap_ctrl02_term_9 cap_ctrl01_term_9 cap_ctrl00_term_9 vss_9 vpw_9 vddce_9
+  q1_9 cap_ctrl12_term_8 cap_ctrl11_term_8 cap_ctrl10_term_8 q0_8 vnwp_8 d0_8
+  wen0_8 vss_ast0_term_8 vss_ast1_term_8 td1_8 cap_ctrl02_term_8
+  cap_ctrl01_term_8 cap_ctrl00_term_8 vsse_8 vss_8 vpw_8 q1_8
+  cap_ctrl12_term_7 cap_ctrl11_term_7 cap_ctrl10_term_7 q0_7 vnwp_7 vsse_7
+  d0_7 td0_7 vss_ast0_term_7 vss_ast1_term_7 cap_ctrl02_term_7
+  cap_ctrl01_term_7 cap_ctrl00_term_7 vss_7 vddce_7 q1_7 cap_ctrl12_term_6
+  cap_ctrl11_term_6 cap_ctrl10_term_6 q0_6 vnwp_6 vss_ast0_term_6
+  vss_ast1_term_6 cap_ctrl02_term_6 cap_ctrl01_term_6 cap_ctrl00_term_6
+  vddce_6 cap_ctrl12_term_5 cap_ctrl11_term_5 cap_ctrl10_term_5 q0_5 vnwp_5
+  vss_ast0_term_5 vss_ast1_term_5 twen1_5 cap_ctrl02_term_5 cap_ctrl01_term_5
+  cap_ctrl00_term_5 vss_5 q1_5 cap_ctrl12_term_4 cap_ctrl11_term_4
+  cap_ctrl10_term_4 q0_4 vnwp_4 vss_ast0_term_4 vss_ast1_term_4
+  cap_ctrl02_term_4 cap_ctrl01_term_4 cap_ctrl00_term_4 vddce_4
+  cap_ctrl12_term_3 cap_ctrl11_term_3 cap_ctrl10_term_3 q0_3 vnwp_3
+  vss_ast0_term_3 vss_ast1_term_3 cap_ctrl02_term_3 cap_ctrl01_term_3
+  cap_ctrl00_term_3 vddce_3 cap_ctrl12_term_2 cap_ctrl11_term_2
+  cap_ctrl10_term_2 vnwp_2 twen0_2 vss_ast0_term_2 vss_ast1_term_2 twen1_2
+  cap_ctrl02_term_2 cap_ctrl01_term_2 cap_ctrl00_term_2 cap_ctrl12_term_1
+  cap_ctrl11_term_1 cap_ctrl10_term_1 q0_1 vnwp_1 vss_ast0_term_1
+  vss_ast1_term_1 cap_ctrl02_term_1 cap_ctrl01_term_1 cap_ctrl00_term_1
+  vddce_1 cap_ctrl12_term_0 cap_ctrl11_term_0 cap_ctrl10_term_0 q0_0 vnwp_0
+  vss_ast0_term_0 vss_ast1_term_0 twen1_0 cap_ctrl02_term_0 cap_ctrl01_term_0
+  cap_ctrl00_term_0 vddce_0
** sram128x46cap_l: 66 flat devices **
xl_cap_1 cap_ctrl00_1 cap_ctrl00_term_1 cap_ctrl01_1 cap_ctrl01_term_1
+  cap_ctrl02_1 cap_ctrl02_term_1 cap_ctrl10_1 cap_ctrl10_term_1 cap_ctrl11_1
+  cap_ctrl11_term_1 cap_ctrl12_1 cap_ctrl12_term_1 d0_1 d1_1 q0_1 q1_1 td0_1
+  td1_1 twen0_1 twen1_1 vddce_1 vddp_1 vddpe_1 vnwp_1 vpw_1 vss_1 vss_ast0_1
+  vss_ast0_term_1 vss_ast1_1 vss_ast1_term_1 vsse_1 wen0_1 wen1_1
+  wen_lat0_term_1 wen_lat1_term_1 weny0_1 weny1_1 sram128x46cap_64_m2
xl_cap_2 cap_ctrl00_2 cap_ctrl00_term_2 cap_ctrl01_2 cap_ctrl01_term_2
+  cap_ctrl02_2 cap_ctrl02_term_2 cap_ctrl10_2 cap_ctrl10_term_2 cap_ctrl11_2
+  cap_ctrl11_term_2 cap_ctrl12_2 cap_ctrl12_term_2 d0_2 d1_2 q0_2 q1_2 td0_2
+  td1_2 twen0_2 twen1_2 vddce_2 vddp_2 vddpe_2 vnwp_2 vpw_2 vss_2 vss_ast0_2
+  vss_ast0_term_2 vss_ast1_2 vss_ast1_term_2 vsse_2 wen0_2 wen1_2
+  wen_lat0_term_2 wen_lat1_term_2 weny0_2 weny1_2 sram128x46cap_64_m2
xl_cap_3 cap_ctrl00_3 cap_ctrl00_term_3 cap_ctrl01_3 cap_ctrl01_term_3
+  cap_ctrl02_3 cap_ctrl02_term_3 cap_ctrl10_3 cap_ctrl10_term_3 cap_ctrl11_3
+  cap_ctrl11_term_3 cap_ctrl12_3 cap_ctrl12_term_3 d0_3 d1_3 q0_3 q1_3 td0_3
+  td1_3 twen0_3 twen1_3 vddce_3 vddp_3 vddpe_3 vnwp_3 vpw_3 vss_3 vss_ast0_3
+  vss_ast0_term_3 vss_ast1_3 vss_ast1_term_3 vsse_3 wen0_3 wen1_3
+  wen_lat0_term_3 wen_lat1_term_3 weny0_3 weny1_3 sram128x46cap_64_m2
xl_cap_4 cap_ctrl00_4 cap_ctrl00_term_4 cap_ctrl01_4 cap_ctrl01_term_4
+  cap_ctrl02_4 cap_ctrl02_term_4 cap_ctrl10_4 cap_ctrl10_term_4 cap_ctrl11_4
+  cap_ctrl11_term_4 cap_ctrl12_4 cap_ctrl12_term_4 d0_4 d1_4 q0_4 q1_4 td0_4
+  td1_4 twen0_4 twen1_4 vddce_4 vddp_4 vddpe_4 vnwp_4 vpw_4 vss_4 vss_ast0_4
+  vss_ast0_term_4 vss_ast1_4 vss_ast1_term_4 vsse_4 wen0_4 wen1_4
+  wen_lat0_term_4 wen_lat1_term_4 weny0_4 weny1_4 sram128x46cap_64_m2
xl_cap_5 cap_ctrl00_5 cap_ctrl00_term_5 cap_ctrl01_5 cap_ctrl01_term_5
+  cap_ctrl02_5 cap_ctrl02_term_5 cap_ctrl10_5 cap_ctrl10_term_5 cap_ctrl11_5
+  cap_ctrl11_term_5 cap_ctrl12_5 cap_ctrl12_term_5 d0_5 d1_5 q0_5 q1_5 td0_5
+  td1_5 twen0_5 twen1_5 vddce_5 vddp_5 vddpe_5 vnwp_5 vpw_5 vss_5 vss_ast0_5
+  vss_ast0_term_5 vss_ast1_5 vss_ast1_term_5 vsse_5 wen0_5 wen1_5
+  wen_lat0_term_5 wen_lat1_term_5 weny0_5 weny1_5 sram128x46cap_64_m2
xl_cap_6 cap_ctrl00_6 cap_ctrl00_term_6 cap_ctrl01_6 cap_ctrl01_term_6
+  cap_ctrl02_6 cap_ctrl02_term_6 cap_ctrl10_6 cap_ctrl10_term_6 cap_ctrl11_6
+  cap_ctrl11_term_6 cap_ctrl12_6 cap_ctrl12_term_6 d0_6 d1_6 q0_6 q1_6 td0_6
+  td1_6 twen0_6 twen1_6 vddce_6 vddp_6 vddpe_6 vnwp_6 vpw_6 vss_6 vss_ast0_6
+  vss_ast0_term_6 vss_ast1_6 vss_ast1_term_6 vsse_6 wen0_6 wen1_6
+  wen_lat0_term_6 wen_lat1_term_6 weny0_6 weny1_6 sram128x46cap_64_m2
xl_cap_7 cap_ctrl00_7 cap_ctrl00_term_7 cap_ctrl01_7 cap_ctrl01_term_7
+  cap_ctrl02_7 cap_ctrl02_term_7 cap_ctrl10_7 cap_ctrl10_term_7 cap_ctrl11_7
+  cap_ctrl11_term_7 cap_ctrl12_7 cap_ctrl12_term_7 d0_7 d1_7 q0_7 q1_7 td0_7
+  td1_7 twen0_7 twen1_7 vddce_7 vddp_7 vddpe_7 vnwp_7 vpw_7 vss_7 vss_ast0_7
+  vss_ast0_term_7 vss_ast1_7 vss_ast1_term_7 vsse_7 wen0_7 wen1_7
+  wen_lat0_term_7 wen_lat1_term_7 weny0_7 weny1_7 sram128x46cap_64_m2
xl_cap_8 cap_ctrl00_8 cap_ctrl00_term_8 cap_ctrl01_8 cap_ctrl01_term_8
+  cap_ctrl02_8 cap_ctrl02_term_8 cap_ctrl10_8 cap_ctrl10_term_8 cap_ctrl11_8
+  cap_ctrl11_term_8 cap_ctrl12_8 cap_ctrl12_term_8 d0_8 d1_8 q0_8 q1_8 td0_8
+  td1_8 twen0_8 twen1_8 vddce_8 vddp_8 vddpe_8 vnwp_8 vpw_8 vss_8 vss_ast0_8
+  vss_ast0_term_8 vss_ast1_8 vss_ast1_term_8 vsse_8 wen0_8 wen1_8
+  wen_lat0_term_8 wen_lat1_term_8 weny0_8 weny1_8 sram128x46cap_64_m2
xl_cap_9 cap_ctrl00_9 cap_ctrl00_term_9 cap_ctrl01_9 cap_ctrl01_term_9
+  cap_ctrl02_9 cap_ctrl02_term_9 cap_ctrl10_9 cap_ctrl10_term_9 cap_ctrl11_9
+  cap_ctrl11_term_9 cap_ctrl12_9 cap_ctrl12_term_9 d0_9 d1_9 q0_9 q1_9 td0_9
+  td1_9 twen0_9 twen1_9 vddce_9 vddp_9 vddpe_9 vnwp_9 vpw_9 vss_9 vss_ast0_9
+  vss_ast0_term_9 vss_ast1_9 vss_ast1_term_9 vsse_9 wen0_9 wen1_9
+  wen_lat0_term_9 wen_lat1_term_9 weny0_9 weny1_9 sram128x46cap_64_m2
xl_cap_l cap_ctrl00_0 cap_ctrl00_term_0 cap_ctrl01_0 cap_ctrl01_term_0
+  cap_ctrl02_0 cap_ctrl02_term_0 cap_ctrl10_0 cap_ctrl10_term_0 cap_ctrl11_0
+  cap_ctrl11_term_0 cap_ctrl12_0 cap_ctrl12_term_0 d0_0 d1_0 q0_0 q1_0 td0_0
+  td1_0 twen0_0 twen1_0 vddce_0 vddp_0 vddpe_0 vnwp_0 vpw_0 vss_0 vss_ast0_0
+  vss_ast0_term_0 vss_ast1_0 vss_ast1_term_0 vsse_0 wen0_0 wen1_0
+  wen_lat0_term_0 wen_lat1_term_0 weny0_0 weny1_0 sram128x46cap_64_m2
xl_cap_r cap_ctrl00_10 cap_ctrl00_term_10 cap_ctrl01_10 cap_ctrl01_term_10
+  cap_ctrl02_10 cap_ctrl02_term_10 cap_ctrl10_10 cap_ctrl10_term_10
+  cap_ctrl11_10 cap_ctrl11_term_10 cap_ctrl12_10 cap_ctrl12_term_10 d0_10
+  d1_10 q0_10 q1_10 td0_10 td1_10 twen0_10 twen1_10 vddce_10 vddp_10 vddpe_10
+  vnwp_10 vpw_10 vss_10 vss_ast0_10 vss_ast0_term_10 vss_ast1_10
+  vss_ast1_term_10 vsse_10 wen0_10 wen1_10 wen_lat0_term_10 wen_lat1_term_10
+  weny0_10 weny1_10 sram128x46cap_64_m2
.ends sram128x46cap_l
****
.subckt sram128x46cap_row_l cap_ctrl12_10 cap_ctrl11_10 cap_ctrl10_10 q0_10
+  vss_10 vddp_10 td0_10 wen0_10 twen0_10 vss_ast0_10 vss_ast1_10 vddpe_10
+  cap_ctrl02_10 cap_ctrl01_10 cap_ctrl00_10 vpw_11 q1_10 cap_ctrl12_9
+  cap_ctrl11_9 cap_ctrl10_9 vddp_9 vddpe_9 td0_9 twen0_9 vss_ast0_9
+  vss_ast1_9 wen_lat1_term_9 weny1_9 twen1_9 d1_9 cap_ctrl02_9 cap_ctrl01_9
+  cap_ctrl00_9 cap_ctrl12_8 cap_ctrl11_8 cap_ctrl10_8 vddp_8 td0_8 twen0_8
+  weny0_8 vss_ast0_8 wen_lat0_term_8 vss_ast1_8 wen_lat1_term_8 weny1_8
+  twen1_8 wen1_8 d1_8 vddpe_8 cap_ctrl02_8 cap_ctrl01_8 cap_ctrl00_8 vddce_8
+  cap_ctrl12_7 cap_ctrl11_7 cap_ctrl10_7 vpw_8 vddp_7 wen0_7 twen0_7 weny0_7
+  vss_ast0_7 wen_lat0_term_7 vss_ast1_7 wen_lat1_term_7 weny1_7 twen1_7
+  wen1_7 td1_7 d1_7 vddpe_7 cap_ctrl02_7 cap_ctrl01_7 cap_ctrl00_7 vnwp_8
+  cap_ctrl12_6 cap_ctrl11_6 cap_ctrl10_6 vsse_7 vddp_6 d0_6 td0_6 wen0_6
+  twen0_6 weny0_6 vss_ast0_6 wen_lat0_term_6 vss_ast1_6 wen_lat1_term_6
+  weny1_6 twen1_6 wen1_6 td1_6 d1_6 vddpe_6 cap_ctrl02_6 cap_ctrl01_6
+  cap_ctrl00_6 vss_6 vpw_7 q1_6 cap_ctrl12_5 cap_ctrl11_5 cap_ctrl10_5 vpw_6
+  vsse_6 vddp_5 d0_5 td0_5 wen0_5 twen0_5 weny0_5 vss_ast0_5 wen_lat0_term_5
+  vss_ast1_5 wen_lat1_term_5 weny1_5 wen1_5 td1_5 d1_5 vddpe_5 cap_ctrl02_5
+  cap_ctrl01_5 cap_ctrl00_5 vddce_5 cap_ctrl12_4 cap_ctrl11_4 cap_ctrl10_4
+  vsse_5 vddp_4 d0_4 td0_4 wen0_4 twen0_4 weny0_4 vss_ast0_4 wen_lat0_term_4
+  vss_ast1_4 wen_lat1_term_4 weny1_4 twen1_4 wen1_4 td1_4 d1_4 vddpe_4
+  cap_ctrl02_4 cap_ctrl01_4 cap_ctrl00_4 vss_4 vpw_5 q1_4 cap_ctrl12_3
+  cap_ctrl11_3 cap_ctrl10_3 vsse_4 vddp_3 d0_3 td0_3 wen0_3 twen0_3 weny0_3
+  vss_ast0_3 wen_lat0_term_3 vss_ast1_3 wen_lat1_term_3 weny1_3 wen1_3 td1_3
+  d1_3 vddpe_3 cap_ctrl02_3 cap_ctrl01_3 cap_ctrl00_3 vss_3 vpw_4 q1_3
+  cap_ctrl12_2 cap_ctrl11_2 cap_ctrl10_2 q0_2 vddp_2 d0_2 td0_2 wen0_2
+  weny0_2 vss_ast0_2 wen_lat0_term_2 vss_ast1_2 wen_lat1_term_2 weny1_2
+  wen1_2 td1_2 d1_2 vddpe_2 cap_ctrl02_2 cap_ctrl01_2 cap_ctrl00_2 vss_2
+  vpw_3 q1_2 cap_ctrl12_1 cap_ctrl11_1 cap_ctrl10_1 vsse_2 vddp_1 d0_1 td0_1
+  wen0_1 twen0_1 weny0_1 vss_ast0_1 wen_lat0_term_1 vss_ast1_1
+  wen_lat1_term_1 weny1_1 twen1_1 wen1_1 td1_1 d1_1 vddpe_1 cap_ctrl02_1
+  cap_ctrl01_1 cap_ctrl00_1 vss_1 vpw_2 q1_1 cap_ctrl12_0 cap_ctrl11_0
+  cap_ctrl10_0 vsse_1 vddp_0 d0_0 td0_0 wen0_0 twen0_0 weny0_0 vss_ast0_0
+  wen_lat0_term_0 vss_ast1_0 wen_lat1_term_0 weny1_0 wen1_0 td1_0 d1_0
+  vddpe_0 cap_ctrl02_0 cap_ctrl01_0 cap_ctrl00_0 vss_0 vpw_1 q1_0 psi si
+  vnwp_0 cap_ctrl12_term_10 cap_ctrl11_term_10 cap_ctrl10_term_10 vsse_11
+  d0_10 weny0_10 vss_ast0_term_10 wen_lat0_term_10 vss_ast1_term_10
+  wen_lat1_term_10 weny1_10 twen1_10 wen1_10 td1_10 d1_10 cap_ctrl02_term_10
+  cap_ctrl01_term_10 cap_ctrl00_term_10 vnwp_11 vddce_10 cap_ctrl12_term_9
+  cap_ctrl11_term_9 cap_ctrl10_term_9 q0_9 vnwp_10 d0_9 wen0_9 weny0_9
+  vss_ast0_term_9 wen_lat0_term_9 vss_ast1_term_9 wen1_9 td1_9
+  cap_ctrl02_term_9 cap_ctrl01_term_9 cap_ctrl00_term_9 vsse_10 vss_9 vpw_10
+  vddce_9 q1_9 cap_ctrl12_term_8 cap_ctrl11_term_8 cap_ctrl10_term_8 q0_8
+  vnwp_9 d0_8 wen0_8 vss_ast0_term_8 vss_ast1_term_8 td1_8 cap_ctrl02_term_8
+  cap_ctrl01_term_8 cap_ctrl00_term_8 vsse_9 vss_8 vpw_9 q1_8
+  cap_ctrl12_term_7 cap_ctrl11_term_7 cap_ctrl10_term_7 q0_7 vsse_8 d0_7
+  td0_7 vss_ast0_term_7 vss_ast1_term_7 cap_ctrl02_term_7 cap_ctrl01_term_7
+  cap_ctrl00_term_7 vss_7 vddce_7 q1_7 cap_ctrl12_term_6 cap_ctrl11_term_6
+  cap_ctrl10_term_6 q0_6 vnwp_7 vss_ast0_term_6 vss_ast1_term_6
+  cap_ctrl02_term_6 cap_ctrl01_term_6 cap_ctrl00_term_6 vddce_6
+  cap_ctrl12_term_5 cap_ctrl11_term_5 cap_ctrl10_term_5 q0_5 vnwp_6
+  vss_ast0_term_5 vss_ast1_term_5 twen1_5 cap_ctrl02_term_5 cap_ctrl01_term_5
+  cap_ctrl00_term_5 vss_5 q1_5 cap_ctrl12_term_4 cap_ctrl11_term_4
+  cap_ctrl10_term_4 q0_4 vnwp_5 vss_ast0_term_4 vss_ast1_term_4
+  cap_ctrl02_term_4 cap_ctrl01_term_4 cap_ctrl00_term_4 vddce_4
+  cap_ctrl12_term_3 cap_ctrl11_term_3 cap_ctrl10_term_3 q0_3 vnwp_4
+  vss_ast0_term_3 vss_ast1_term_3 twen1_3 cap_ctrl02_term_3 cap_ctrl01_term_3
+  cap_ctrl00_term_3 vddce_3 cap_ctrl12_term_2 cap_ctrl11_term_2
+  cap_ctrl10_term_2 vnwp_3 twen0_2 vss_ast0_term_2 vss_ast1_term_2 twen1_2
+  cap_ctrl02_term_2 cap_ctrl01_term_2 cap_ctrl00_term_2 vsse_3 vddce_2
+  cap_ctrl12_term_1 cap_ctrl11_term_1 cap_ctrl10_term_1 q0_1 vnwp_2
+  vss_ast0_term_1 vss_ast1_term_1 cap_ctrl02_term_1 cap_ctrl01_term_1
+  cap_ctrl00_term_1 vddce_1 cap_ctrl12_term_0 cap_ctrl11_term_0
+  cap_ctrl10_term_0 q0_0 vnwp_1 vss_ast0_term_0 vss_ast1_term_0 twen1_0
+  cap_ctrl02_term_0 cap_ctrl01_term_0 cap_ctrl00_term_0 vddce_0 vpw_0 vnwc
+  vsse_0
** sram128x46cap_row_l: 66 flat devices **
xcap_cdm_row_l cap_ctrl12_10 cap_ctrl11_10 cap_ctrl10_10 q0_10 vss_10 vddp_10
+  td0_10 wen0_10 twen0_10 vss_ast0_10 vss_ast1_10 vddpe_10 cap_ctrl02_10
+  cap_ctrl01_10 cap_ctrl00_10 vsse_11 vpw_11 q1_10 cap_ctrl12_9 cap_ctrl11_9
+  cap_ctrl10_9 vddp_9 vddpe_9 td0_9 twen0_9 vss_ast0_9 vss_ast1_9
+  wen_lat1_term_9 weny1_9 twen1_9 d1_9 cap_ctrl02_9 cap_ctrl01_9 cap_ctrl00_9
+  vnwp_10 cap_ctrl12_8 cap_ctrl11_8 cap_ctrl10_8 vddp_8 td0_8 twen0_8 weny0_8
+  vss_ast0_8 wen_lat0_term_8 vss_ast1_8 wen_lat1_term_8 weny1_8 twen1_8
+  wen1_8 d1_8 vddpe_8 cap_ctrl02_8 cap_ctrl01_8 cap_ctrl00_8 vddce_8
+  cap_ctrl12_7 cap_ctrl11_7 cap_ctrl10_7 vpw_8 vddp_7 wen0_7 twen0_7 weny0_7
+  vss_ast0_7 wen_lat0_term_7 vss_ast1_7 wen_lat1_term_7 weny1_7 twen1_7
+  wen1_7 td1_7 d1_7 vddpe_7 cap_ctrl02_7 cap_ctrl01_7 cap_ctrl00_7
+  cap_ctrl12_6 cap_ctrl11_6 cap_ctrl10_6 vsse_7 vddp_6 d0_6 td0_6 wen0_6
+  twen0_6 weny0_6 vss_ast0_6 wen_lat0_term_6 vss_ast1_6 wen_lat1_term_6
+  weny1_6 twen1_6 wen1_6 td1_6 d1_6 vddpe_6 cap_ctrl02_6 cap_ctrl01_6
+  cap_ctrl00_6 vss_6 vpw_7 q1_6 cap_ctrl12_5 cap_ctrl11_5 cap_ctrl10_5 vpw_6
+  vsse_6 vddp_5 d0_5 td0_5 wen0_5 twen0_5 weny0_5 vss_ast0_5 wen_lat0_term_5
+  vss_ast1_5 wen_lat1_term_5 weny1_5 wen1_5 td1_5 d1_5 vddpe_5 cap_ctrl02_5
+  cap_ctrl01_5 cap_ctrl00_5 vddce_5 cap_ctrl12_4 cap_ctrl11_4 cap_ctrl10_4
+  vsse_5 vddp_4 d0_4 td0_4 wen0_4 twen0_4 weny0_4 vss_ast0_4 wen_lat0_term_4
+  vss_ast1_4 wen_lat1_term_4 weny1_4 twen1_4 wen1_4 td1_4 d1_4 vddpe_4
+  cap_ctrl02_4 cap_ctrl01_4 cap_ctrl00_4 vss_4 vpw_5 q1_4 cap_ctrl12_3
+  cap_ctrl11_3 cap_ctrl10_3 vsse_4 vddp_3 d0_3 td0_3 wen0_3 twen0_3 weny0_3
+  vss_ast0_3 wen_lat0_term_3 vss_ast1_3 wen_lat1_term_3 weny1_3 twen1_3
+  wen1_3 td1_3 d1_3 vddpe_3 cap_ctrl02_3 cap_ctrl01_3 cap_ctrl00_3 vss_3
+  vpw_4 q1_3 cap_ctrl12_2 cap_ctrl11_2 cap_ctrl10_2 q0_2 vsse_3 vddp_2 d0_2
+  td0_2 wen0_2 weny0_2 vss_ast0_2 wen_lat0_term_2 vss_ast1_2 wen_lat1_term_2
+  weny1_2 wen1_2 td1_2 d1_2 vddpe_2 cap_ctrl02_2 cap_ctrl01_2 cap_ctrl00_2
+  vss_2 vpw_3 vddce_2 q1_2 cap_ctrl12_1 cap_ctrl11_1 cap_ctrl10_1 vsse_2
+  vddp_1 d0_1 td0_1 wen0_1 twen0_1 weny0_1 vss_ast0_1 wen_lat0_term_1
+  vss_ast1_1 wen_lat1_term_1 weny1_1 twen1_1 wen1_1 td1_1 d1_1 vddpe_1
+  cap_ctrl02_1 cap_ctrl01_1 cap_ctrl00_1 vss_1 vpw_2 q1_1 cap_ctrl12_0
+  cap_ctrl11_0 cap_ctrl10_0 vsse_1 vddp_0 d0_0 td0_0 wen0_0 twen0_0 weny0_0
+  vss_ast0_0 wen_lat0_term_0 vss_ast1_0 wen_lat1_term_0 weny1_0 wen1_0 td1_0
+  d1_0 vddpe_0 cap_ctrl02_0 cap_ctrl01_0 cap_ctrl00_0 vss_0 vpw_1 q1_0
+  cap_ctrl12_term_10 cap_ctrl11_term_10 cap_ctrl10_term_10 d0_10 weny0_10
+  vss_ast0_term_10 wen_lat0_term_10 vss_ast1_term_10 wen_lat1_term_10
+  weny1_10 twen1_10 wen1_10 td1_10 d1_10 cap_ctrl02_term_10
+  cap_ctrl01_term_10 cap_ctrl00_term_10 vnwp_11 vddce_10 cap_ctrl12_term_9
+  cap_ctrl11_term_9 cap_ctrl10_term_9 q0_9 vsse_10 d0_9 wen0_9 weny0_9
+  vss_ast0_term_9 wen_lat0_term_9 vss_ast1_term_9 wen1_9 td1_9
+  cap_ctrl02_term_9 cap_ctrl01_term_9 cap_ctrl00_term_9 vss_9 vpw_10 vddce_9
+  q1_9 cap_ctrl12_term_8 cap_ctrl11_term_8 cap_ctrl10_term_8 q0_8 vnwp_9 d0_8
+  wen0_8 vss_ast0_term_8 vss_ast1_term_8 td1_8 cap_ctrl02_term_8
+  cap_ctrl01_term_8 cap_ctrl00_term_8 vsse_9 vss_8 vpw_9 q1_8
+  cap_ctrl12_term_7 cap_ctrl11_term_7 cap_ctrl10_term_7 q0_7 vnwp_8 vsse_8
+  d0_7 td0_7 vss_ast0_term_7 vss_ast1_term_7 cap_ctrl02_term_7
+  cap_ctrl01_term_7 cap_ctrl00_term_7 vss_7 vddce_7 q1_7 cap_ctrl12_term_6
+  cap_ctrl11_term_6 cap_ctrl10_term_6 q0_6 vnwp_7 vss_ast0_term_6
+  vss_ast1_term_6 cap_ctrl02_term_6 cap_ctrl01_term_6 cap_ctrl00_term_6
+  vddce_6 cap_ctrl12_term_5 cap_ctrl11_term_5 cap_ctrl10_term_5 q0_5 vnwp_6
+  vss_ast0_term_5 vss_ast1_term_5 twen1_5 cap_ctrl02_term_5 cap_ctrl01_term_5
+  cap_ctrl00_term_5 vss_5 q1_5 cap_ctrl12_term_4 cap_ctrl11_term_4
+  cap_ctrl10_term_4 q0_4 vnwp_5 vss_ast0_term_4 vss_ast1_term_4
+  cap_ctrl02_term_4 cap_ctrl01_term_4 cap_ctrl00_term_4 vddce_4
+  cap_ctrl12_term_3 cap_ctrl11_term_3 cap_ctrl10_term_3 q0_3 vnwp_4
+  vss_ast0_term_3 vss_ast1_term_3 cap_ctrl02_term_3 cap_ctrl01_term_3
+  cap_ctrl00_term_3 vddce_3 cap_ctrl12_term_2 cap_ctrl11_term_2
+  cap_ctrl10_term_2 vnwp_3 twen0_2 vss_ast0_term_2 vss_ast1_term_2 twen1_2
+  cap_ctrl02_term_2 cap_ctrl01_term_2 cap_ctrl00_term_2 cap_ctrl12_term_1
+  cap_ctrl11_term_1 cap_ctrl10_term_1 q0_1 vnwp_2 vss_ast0_term_1
+  vss_ast1_term_1 cap_ctrl02_term_1 cap_ctrl01_term_1 cap_ctrl00_term_1
+  vddce_1 cap_ctrl12_term_0 cap_ctrl11_term_0 cap_ctrl10_term_0 q0_0 vnwp_1
+  vss_ast0_term_0 vss_ast1_term_0 twen1_0 cap_ctrl02_term_0 cap_ctrl01_term_0
+  cap_ctrl00_term_0 vddce_0 sram128x46cap_l
.ends sram128x46cap_row_l
****
.subckt sram128x46cap_slice vnwp_25 si_1 psi_1 q1_22 vpw_24 cap_ctrl00_22
+  cap_ctrl01_22 cap_ctrl02_22 vddpe_23 vss_ast1_22 vss_ast0_22 twen0_22
+  wen0_22 td0_22 vddp_22 vss_23 q0_22 cap_ctrl10_22 cap_ctrl11_22
+  cap_ctrl12_22 q1_21 vddce_22 vpw_23 cap_ctrl00_21 cap_ctrl01_21
+  cap_ctrl02_21 d1_21 td1_21 weny1_21 wen_lat1_term_21 vss_ast1_21
+  vss_ast0_21 wen0_21 td0_21 vddpe_22 vddp_21 vsse_23 vss_22 q0_21
+  cap_ctrl10_21 cap_ctrl11_21 cap_ctrl12_21 q1_20 cap_ctrl00_20 cap_ctrl01_20
+  cap_ctrl02_20 d1_20 weny1_20 wen_lat1_term_20 vss_ast1_20 wen_lat0_term_20
+  vss_ast0_20 weny0_20 td0_20 d0_20 vddce_21 vddp_20 vpw_22 q0_20
+  cap_ctrl10_20 cap_ctrl11_20 cap_ctrl12_20 vddce_20 cap_ctrl00_19
+  cap_ctrl01_19 cap_ctrl02_19 vddpe_20 d1_19 td1_19 weny1_19 wen_lat1_term_19
+  vss_ast1_19 wen_lat0_term_19 vss_ast0_19 weny0_19 wen0_19 td0_19 d0_19
+  vsse_21 cap_ctrl10_19 cap_ctrl11_19 cap_ctrl12_19 q1_18 vddce_19 vss_19
+  cap_ctrl00_18 cap_ctrl01_18 cap_ctrl02_18 vddpe_19 d1_18 td1_18 weny1_18
+  vss_ast1_18 wen_lat0_term_18 vss_ast0_18 weny0_18 wen0_18 td0_18 d0_18
+  cap_ctrl10_18 cap_ctrl11_18 cap_ctrl12_18 q1_17 vpw_19 vss_18 cap_ctrl00_17
+  cap_ctrl01_17 cap_ctrl02_17 d1_17 td1_17 weny1_17 wen_lat1_term_17
+  vss_ast1_17 wen_lat0_term_17 vss_ast0_17 weny0_17 wen0_17 td0_17 d0_17
+  cap_ctrl10_17 cap_ctrl11_17 cap_ctrl12_17 vddce_17 vss_17 cap_ctrl00_16
+  cap_ctrl01_16 cap_ctrl02_16 vddpe_17 d1_16 td1_16 weny1_16 wen_lat1_term_16
+  vss_ast1_16 wen_lat0_term_16 vss_ast0_16 weny0_16 wen0_16 td0_16 d0_16
+  cap_ctrl10_16 cap_ctrl11_16 cap_ctrl12_16 q1_15 vddce_16 vpw_17
+  cap_ctrl00_15 cap_ctrl01_15 cap_ctrl02_15 vddpe_16 td1_15 vss_ast1_15
+  wen_lat0_term_15 vss_ast0_15 weny0_15 wen0_15 td0_15 d0_15 q0_15
+  cap_ctrl10_15 cap_ctrl11_15 cap_ctrl12_15 q1_14 vpw_16 vss_15 cap_ctrl00_14
+  cap_ctrl01_14 cap_ctrl02_14 d1_14 td1_14 twen1_14 weny1_14 wen_lat1_term_14
+  vss_ast1_14 wen_lat0_term_14 vss_ast0_14 weny0_14 wen0_14 td0_14 d0_14
+  vsse_16 cap_ctrl10_14 cap_ctrl11_14 cap_ctrl12_14 q1_13 vddce_14 vpw_15
+  cap_ctrl00_13 cap_ctrl01_13 cap_ctrl02_13 vddpe_14 d1_13 td1_13 vss_ast1_13
+  wen_lat0_term_13 vss_ast0_13 weny0_13 wen0_13 td0_13 d0_13 cap_ctrl10_13
+  cap_ctrl11_13 cap_ctrl12_13 q1_12 vddce_13 vpw_14 cap_ctrl00_12
+  cap_ctrl01_12 cap_ctrl02_12 vddpe_13 td1_12 vss_ast1_12 wen_lat0_term_12
+  vss_ast0_12 weny0_12 wen0_12 td0_12 d0_12 vnwp_14 q0_12 cap_ctrl10_12
+  cap_ctrl11_12 cap_ctrl12_12 q1_11 vpw_13 vss_12 cap_ctrl00_11 cap_ctrl01_11
+  cap_ctrl02_11 vddpe_12 d1_11 td1_11 weny1_11 vss_ast1_11 wen_lat0_term_11
+  vss_ast0_11 weny0_11 wen0_11 td0_11 d0_11 cap_ctrl10_11 cap_ctrl11_11
+  cap_ctrl12_11 vsse_12 nretnvt nactc actp fca2_6 fca2_5 fca2_4 fca2_3 fca2_2
+  fca2_1 cre2 fca1_0 vpw_12 vnwc_1 dbl_nbl_wa_turn ten dftrambyp_dum emas
+  ema[0] ema[1] ema[2] emaw[0] emaw[1] cap_ctrl12_10 cap_ctrl11_10
+  cap_ctrl10_10 q0_10 vsse_11 d0_10 td0_10 wen0_10 weny0_10 vss_ast0_10
+  wen_lat0_term_10 vss_ast1_10 twen1_10 td1_10 vddpe_10 cap_ctrl02_10
+  cap_ctrl01_10 cap_ctrl00_10 vpw_11 vddce_10 q1_10 cap_ctrl12_9 cap_ctrl11_9
+  cap_ctrl10_9 q0_9 td0_9 wen0_9 vss_ast0_9 wen_lat0_term_9 vss_ast1_9
+  twen1_9 td1_9 cap_ctrl02_9 cap_ctrl01_9 cap_ctrl00_9 vsse_10 vpw_10 vnwp_10
+  q1_9 cap_ctrl12_8 cap_ctrl11_8 cap_ctrl10_8 q0_8 vsse_9 d0_8 td0_8 wen0_8
+  weny0_8 vss_ast0_8 wen_lat0_term_8 vss_ast1_8 td1_8 vddpe_8 cap_ctrl02_8
+  cap_ctrl01_8 cap_ctrl00_8 vpw_9 vddce_8 q1_8 cap_ctrl12_7 cap_ctrl11_7
+  cap_ctrl10_7 q0_7 vnwp_8 td0_7 wen0_7 vss_ast0_7 wen_lat0_term_7 vss_ast1_7
+  twen1_7 vddpe_7 cap_ctrl02_7 cap_ctrl01_7 cap_ctrl00_7 vsse_8 vpw_8 vddce_7
+  q1_7 cap_ctrl12_6 cap_ctrl11_6 cap_ctrl10_6 q0_6 vss_6 wen0_6 weny0_6
+  vss_ast0_6 wen_lat0_term_6 vss_ast1_6 twen1_6 cap_ctrl02_6 cap_ctrl01_6
+  cap_ctrl00_6 vsse_7 vpw_7 vnwp_7 vddce_6 q1_6 cap_ctrl12_5 cap_ctrl11_5
+  cap_ctrl10_5 q0_5 d0_5 td0_5 wen0_5 weny0_5 vss_ast0_5 wen_lat0_term_5
+  vss_ast1_5 twen1_5 td1_5 vddpe_5 cap_ctrl02_5 cap_ctrl01_5 cap_ctrl00_5
+  vsse_6 vpw_6 vddce_5 q1_5 cap_ctrl12_4 cap_ctrl11_4 cap_ctrl10_4 q0_4 vss_4
+  td0_4 wen0_4 vss_ast0_4 vss_ast1_4 twen1_4 vddpe_4 cap_ctrl02_4
+  cap_ctrl01_4 cap_ctrl00_4 vsse_5 vpw_5 vnwp_5 vddce_4 q1_4 cap_ctrl12_3
+  cap_ctrl11_3 cap_ctrl10_3 q0_3 vnwp_4 vss_3 d0_3 td0_3 weny0_3 vss_ast0_3
+  wen_lat0_term_3 vss_ast1_3 twen1_3 td1_3 cap_ctrl02_3 cap_ctrl01_3
+  cap_ctrl00_3 vddce_3 q1_3 cap_ctrl12_2 cap_ctrl11_2 cap_ctrl10_2 q0_2 td0_2
+  wen0_2 vss_ast0_2 wen_lat0_term_2 vss_ast1_2 twen1_2 vddpe_2 cap_ctrl02_2
+  cap_ctrl01_2 cap_ctrl00_2 vsse_3 vpw_3 vnwp_3 vddce_2 q1_2 cap_ctrl12_1
+  cap_ctrl11_1 cap_ctrl10_1 q0_1 vss_1 wen0_1 vss_ast0_1 vss_ast1_1 twen1_1
+  vddpe_1 cap_ctrl02_1 cap_ctrl01_1 cap_ctrl00_1 vsse_2 vnwp_2 vddce_1 q1_1
+  cap_ctrl12_0 cap_ctrl11_0 cap_ctrl10_0 q0_0 vss_0 vddp_0 td0_0 twen0_0
+  vss_ast0_0 wen_lat0_term_0 vss_ast1_0 wen_lat1_term_0 twen1_0 wen1_0
+  vddpe_0 cap_ctrl02_0 cap_ctrl01_0 cap_ctrl00_0 vsse_1 vpw_1 vnwp_1 vddce_0
+  q1_0 si_0 vsse_0 vsse_25 vnwc_2 vpw_25 vddce_23 vnwp_24 vsse_24
+  cap_ctrl00_term_22 cap_ctrl01_term_22 cap_ctrl02_term_22 d1_22 td1_22
+  wen1_22 twen1_22 weny1_22 wen_lat1_term_22 vss_ast1_term_22
+  wen_lat0_term_22 vss_ast0_term_22 weny0_22 d0_22 cap_ctrl10_term_22
+  cap_ctrl11_term_22 cap_ctrl12_term_22 vnwp_23 cap_ctrl00_term_21
+  cap_ctrl01_term_21 cap_ctrl02_term_21 wen1_21 twen1_21 vss_ast1_term_21
+  wen_lat0_term_21 vss_ast0_term_21 weny0_21 twen0_21 d0_21
+  cap_ctrl10_term_21 cap_ctrl11_term_21 cap_ctrl12_term_21 vnwp_22
+  cap_ctrl00_term_20 cap_ctrl01_term_20 cap_ctrl02_term_20 vddpe_21 td1_20
+  wen1_20 twen1_20 vss_ast1_term_20 vss_ast0_term_20 twen0_20 wen0_20 vsse_22
+  vss_21 cap_ctrl10_term_20 cap_ctrl11_term_20 cap_ctrl12_term_20 q1_19
+  vpw_21 cap_ctrl00_term_19 cap_ctrl01_term_19 cap_ctrl02_term_19 wen1_19
+  twen1_19 vss_ast1_term_19 vss_ast0_term_19 twen0_19 vddp_19 vss_20 vnwp_21
+  q0_19 cap_ctrl10_term_19 cap_ctrl11_term_19 cap_ctrl12_term_19 vnwp_20
+  vpw_20 vsse_20 cap_ctrl00_term_18 cap_ctrl01_term_18 cap_ctrl02_term_18
+  wen1_18 twen1_18 wen_lat1_term_18 vss_ast1_term_18 vss_ast0_term_18
+  twen0_18 vddp_18 q0_18 cap_ctrl10_term_18 cap_ctrl11_term_18
+  cap_ctrl12_term_18 vddce_18 cap_ctrl00_term_17 cap_ctrl01_term_17
+  cap_ctrl02_term_17 vddpe_18 wen1_17 twen1_17 vss_ast1_term_17
+  vss_ast0_term_17 twen0_17 vddp_17 vsse_19 vnwp_19 q0_17 cap_ctrl10_term_17
+  cap_ctrl11_term_17 cap_ctrl12_term_17 q1_16 vnwp_18 vpw_18 vsse_18
+  cap_ctrl00_term_16 cap_ctrl01_term_16 cap_ctrl02_term_16 wen1_16 twen1_16
+  vss_ast1_term_16 vss_ast0_term_16 twen0_16 vddp_16 q0_16 cap_ctrl10_term_16
+  cap_ctrl11_term_16 cap_ctrl12_term_16 vnwp_17 vss_16 vsse_17
+  cap_ctrl00_term_15 cap_ctrl01_term_15 cap_ctrl02_term_15 d1_15 wen1_15
+  twen1_15 weny1_15 wen_lat1_term_15 vss_ast1_term_15 vss_ast0_term_15
+  twen0_15 vddp_15 cap_ctrl10_term_15 cap_ctrl11_term_15 cap_ctrl12_term_15
+  vddce_15 cap_ctrl00_term_14 cap_ctrl01_term_14 cap_ctrl02_term_14 vddpe_15
+  wen1_14 vss_ast1_term_14 vss_ast0_term_14 twen0_14 vddp_14 vnwp_16 q0_14
+  cap_ctrl10_term_14 cap_ctrl11_term_14 cap_ctrl12_term_14 vnwp_15 vss_14
+  vsse_15 cap_ctrl00_term_13 cap_ctrl01_term_13 cap_ctrl02_term_13 wen1_13
+  twen1_13 weny1_13 wen_lat1_term_13 vss_ast1_term_13 vss_ast0_term_13
+  twen0_13 vddp_13 q0_13 cap_ctrl10_term_13 cap_ctrl11_term_13
+  cap_ctrl12_term_13 vss_13 cap_ctrl00_term_12 cap_ctrl01_term_12
+  cap_ctrl02_term_12 d1_12 wen1_12 twen1_12 weny1_12 wen_lat1_term_12
+  vss_ast1_term_12 vss_ast0_term_12 twen0_12 vddp_12 vsse_14
+  cap_ctrl10_term_12 cap_ctrl11_term_12 cap_ctrl12_term_12 vddce_12 vnwp_13
+  vsse_13 cap_ctrl00_term_11 cap_ctrl01_term_11 cap_ctrl02_term_11 wen1_11
+  twen1_11 wen_lat1_term_11 vss_ast1_term_11 vss_ast0_term_11 twen0_11
+  vddp_11 q0_11 cap_ctrl10_term_11 cap_ctrl11_term_11 cap_ctrl12_term_11
+  fca2_0 fca1_6 fca1_5 fca1_4 fca1_3 fca1_2 fca1_1 cre1 vnwp_12 vddce_11
+  vddpe_11 vss_11 dft_p2_term gwen_p2_term gtp_term dbl_nbl_wa_turn_term
+  dbl_nbl_wa_term penso pensi tpen pen pso1 pso0 se so1 so0 log1 log0 wablm1
+  wablm0 wabl rawlm1 rawlm0 rawl nret ret2n_dum pgen_dum rdt gwen cen clk a0
+  a1 a2 a3 a4 a5 a6 a7 a8 a9 a10 tgwen tcen ta0 ta1 ta2 ta3 ta4 ta5 ta6 ta7
+  ta8 ta9 ta10 gweny ceny ay0 ay1 ay2 ay3 ay4 ay5 ay6 ay7 ay8 ay9 ay10
+  cap_ctrl12_term_10 cap_ctrl11_term_10 cap_ctrl10_term_10 vddp_10 twen0_10
+  vss_ast0_term_10 vss_ast1_term_10 wen_lat1_term_10 weny1_10 wen1_10 d1_10
+  cap_ctrl02_term_10 cap_ctrl01_term_10 cap_ctrl00_term_10 vss_10 vnwp_11
+  cap_ctrl12_term_9 cap_ctrl11_term_9 cap_ctrl10_term_9 vddp_9 d0_9 twen0_9
+  weny0_9 vss_ast0_term_9 vss_ast1_term_9 wen_lat1_term_9 weny1_9 wen1_9 d1_9
+  vddpe_9 cap_ctrl02_term_9 cap_ctrl01_term_9 cap_ctrl00_term_9 vss_9 vddce_9
+  cap_ctrl12_term_8 cap_ctrl11_term_8 cap_ctrl10_term_8 vddp_8 twen0_8
+  vss_ast0_term_8 vss_ast1_term_8 wen_lat1_term_8 weny1_8 twen1_8 wen1_8 d1_8
+  cap_ctrl02_term_8 cap_ctrl01_term_8 cap_ctrl00_term_8 vss_8 vnwp_9
+  cap_ctrl12_term_7 cap_ctrl11_term_7 cap_ctrl10_term_7 vddp_7 d0_7 twen0_7
+  weny0_7 vss_ast0_term_7 vss_ast1_term_7 wen_lat1_term_7 weny1_7 wen1_7
+  td1_7 d1_7 cap_ctrl02_term_7 cap_ctrl01_term_7 cap_ctrl00_term_7 vss_7
+  cap_ctrl12_term_6 cap_ctrl11_term_6 cap_ctrl10_term_6 vddp_6 d0_6 td0_6
+  twen0_6 vss_ast0_term_6 vss_ast1_term_6 wen_lat1_term_6 weny1_6 wen1_6
+  td1_6 d1_6 vddpe_6 cap_ctrl02_term_6 cap_ctrl01_term_6 cap_ctrl00_term_6
+  cap_ctrl12_term_5 cap_ctrl11_term_5 cap_ctrl10_term_5 vddp_5 twen0_5
+  vss_ast0_term_5 vss_ast1_term_5 wen_lat1_term_5 weny1_5 wen1_5 d1_5
+  cap_ctrl02_term_5 cap_ctrl01_term_5 cap_ctrl00_term_5 vss_5 vnwp_6
+  cap_ctrl12_term_4 cap_ctrl11_term_4 cap_ctrl10_term_4 vddp_4 d0_4 twen0_4
+  weny0_4 vss_ast0_term_4 wen_lat0_term_4 vss_ast1_term_4 wen_lat1_term_4
+  weny1_4 wen1_4 td1_4 d1_4 cap_ctrl02_term_4 cap_ctrl01_term_4
+  cap_ctrl00_term_4 cap_ctrl12_term_3 cap_ctrl11_term_3 cap_ctrl10_term_3
+  vpw_4 vddp_3 wen0_3 twen0_3 vss_ast0_term_3 vss_ast1_term_3 wen_lat1_term_3
+  weny1_3 wen1_3 d1_3 vddpe_3 cap_ctrl02_term_3 cap_ctrl01_term_3
+  cap_ctrl00_term_3 vsse_4 cap_ctrl12_term_2 cap_ctrl11_term_2
+  cap_ctrl10_term_2 vddp_2 d0_2 twen0_2 weny0_2 vss_ast0_term_2
+  vss_ast1_term_2 wen_lat1_term_2 weny1_2 wen1_2 td1_2 d1_2 cap_ctrl02_term_2
+  cap_ctrl01_term_2 cap_ctrl00_term_2 vss_2 cap_ctrl12_term_1
+  cap_ctrl11_term_1 cap_ctrl10_term_1 vpw_2 vddp_1 d0_1 td0_1 twen0_1 weny0_1
+  vss_ast0_term_1 wen_lat0_term_1 vss_ast1_term_1 wen_lat1_term_1 weny1_1
+  wen1_1 td1_1 d1_1 cap_ctrl02_term_1 cap_ctrl01_term_1 cap_ctrl00_term_1
+  cap_ctrl12_term_0 cap_ctrl11_term_0 cap_ctrl10_term_0 d0_0 wen0_0 weny0_0
+  vss_ast0_term_0 vss_ast1_term_0 weny1_0 td1_0 d1_0 cap_ctrl02_term_0
+  cap_ctrl01_term_0 cap_ctrl00_term_0 psi_0 vpw_0 vnwc_0 vnwp_0
** sram128x46cap_slice: 138 flat devices **
xcap_left cap_ctrl12_10 cap_ctrl11_10 cap_ctrl10_10 q0_10 vss_10 vddp_10
+  td0_10 wen0_10 twen0_10 vss_ast0_10 vss_ast1_10 vddpe_10 cap_ctrl02_10
+  cap_ctrl01_10 cap_ctrl00_10 vpw_11 q1_10 cap_ctrl12_9 cap_ctrl11_9
+  cap_ctrl10_9 vddp_9 vddpe_9 td0_9 twen0_9 vss_ast0_9 vss_ast1_9
+  wen_lat1_term_9 weny1_9 twen1_9 d1_9 cap_ctrl02_9 cap_ctrl01_9 cap_ctrl00_9
+  cap_ctrl12_8 cap_ctrl11_8 cap_ctrl10_8 vddp_8 td0_8 twen0_8 weny0_8
+  vss_ast0_8 wen_lat0_term_8 vss_ast1_8 wen_lat1_term_8 weny1_8 twen1_8
+  wen1_8 d1_8 vddpe_8 cap_ctrl02_8 cap_ctrl01_8 cap_ctrl00_8 vddce_8
+  cap_ctrl12_7 cap_ctrl11_7 cap_ctrl10_7 vpw_8 vddp_7 wen0_7 twen0_7 weny0_7
+  vss_ast0_7 wen_lat0_term_7 vss_ast1_7 wen_lat1_term_7 weny1_7 twen1_7
+  wen1_7 td1_7 d1_7 vddpe_7 cap_ctrl02_7 cap_ctrl01_7 cap_ctrl00_7 vnwp_8
+  cap_ctrl12_6 cap_ctrl11_6 cap_ctrl10_6 vsse_7 vddp_6 d0_6 td0_6 wen0_6
+  twen0_6 weny0_6 vss_ast0_6 wen_lat0_term_6 vss_ast1_6 wen_lat1_term_6
+  weny1_6 twen1_6 wen1_6 td1_6 d1_6 vddpe_6 cap_ctrl02_6 cap_ctrl01_6
+  cap_ctrl00_6 vss_6 vpw_7 q1_6 cap_ctrl12_5 cap_ctrl11_5 cap_ctrl10_5 vpw_6
+  vsse_6 vddp_5 d0_5 td0_5 wen0_5 twen0_5 weny0_5 vss_ast0_5 wen_lat0_term_5
+  vss_ast1_5 wen_lat1_term_5 weny1_5 wen1_5 td1_5 d1_5 vddpe_5 cap_ctrl02_5
+  cap_ctrl01_5 cap_ctrl00_5 vddce_5 cap_ctrl12_4 cap_ctrl11_4 cap_ctrl10_4
+  vsse_5 vddp_4 d0_4 td0_4 wen0_4 twen0_4 weny0_4 vss_ast0_4 wen_lat0_term_4
+  vss_ast1_4 wen_lat1_term_4 weny1_4 twen1_4 wen1_4 td1_4 d1_4 vddpe_4
+  cap_ctrl02_4 cap_ctrl01_4 cap_ctrl00_4 vss_4 vpw_5 q1_4 cap_ctrl12_3
+  cap_ctrl11_3 cap_ctrl10_3 vsse_4 vddp_3 d0_3 td0_3 wen0_3 twen0_3 weny0_3
+  vss_ast0_3 wen_lat0_term_3 vss_ast1_3 wen_lat1_term_3 weny1_3 wen1_3 td1_3
+  d1_3 vddpe_3 cap_ctrl02_3 cap_ctrl01_3 cap_ctrl00_3 vss_3 vpw_4 q1_3
+  cap_ctrl12_2 cap_ctrl11_2 cap_ctrl10_2 q0_2 vddp_2 d0_2 td0_2 wen0_2
+  weny0_2 vss_ast0_2 wen_lat0_term_2 vss_ast1_2 wen_lat1_term_2 weny1_2
+  wen1_2 td1_2 d1_2 vddpe_2 cap_ctrl02_2 cap_ctrl01_2 cap_ctrl00_2 vss_2
+  vpw_3 q1_2 cap_ctrl12_1 cap_ctrl11_1 cap_ctrl10_1 vsse_2 vddp_1 d0_1 td0_1
+  wen0_1 twen0_1 weny0_1 vss_ast0_1 wen_lat0_term_1 vss_ast1_1
+  wen_lat1_term_1 weny1_1 twen1_1 wen1_1 td1_1 d1_1 vddpe_1 cap_ctrl02_1
+  cap_ctrl01_1 cap_ctrl00_1 vss_1 vpw_2 q1_1 cap_ctrl12_0 cap_ctrl11_0
+  cap_ctrl10_0 vsse_1 vddp_0 d0_0 td0_0 wen0_0 twen0_0 weny0_0 vss_ast0_0
+  wen_lat0_term_0 vss_ast1_0 wen_lat1_term_0 weny1_0 wen1_0 td1_0 d1_0
+  vddpe_0 cap_ctrl02_0 cap_ctrl01_0 cap_ctrl00_0 vss_0 vpw_1 q1_0 psi_0 si_0
+  vnwp_0 cap_ctrl12_term_10 cap_ctrl11_term_10 cap_ctrl10_term_10 vsse_11
+  d0_10 weny0_10 vss_ast0_term_10 wen_lat0_term_10 vss_ast1_term_10
+  wen_lat1_term_10 weny1_10 twen1_10 wen1_10 td1_10 d1_10 cap_ctrl02_term_10
+  cap_ctrl01_term_10 cap_ctrl00_term_10 vnwp_11 vddce_10 cap_ctrl12_term_9
+  cap_ctrl11_term_9 cap_ctrl10_term_9 q0_9 vnwp_10 d0_9 wen0_9 weny0_9
+  vss_ast0_term_9 wen_lat0_term_9 vss_ast1_term_9 wen1_9 td1_9
+  cap_ctrl02_term_9 cap_ctrl01_term_9 cap_ctrl00_term_9 vsse_10 vss_9 vpw_10
+  vddce_9 q1_9 cap_ctrl12_term_8 cap_ctrl11_term_8 cap_ctrl10_term_8 q0_8
+  vnwp_9 d0_8 wen0_8 vss_ast0_term_8 vss_ast1_term_8 td1_8 cap_ctrl02_term_8
+  cap_ctrl01_term_8 cap_ctrl00_term_8 vsse_9 vss_8 vpw_9 q1_8
+  cap_ctrl12_term_7 cap_ctrl11_term_7 cap_ctrl10_term_7 q0_7 vsse_8 d0_7
+  td0_7 vss_ast0_term_7 vss_ast1_term_7 cap_ctrl02_term_7 cap_ctrl01_term_7
+  cap_ctrl00_term_7 vss_7 vddce_7 q1_7 cap_ctrl12_term_6 cap_ctrl11_term_6
+  cap_ctrl10_term_6 q0_6 vnwp_7 vss_ast0_term_6 vss_ast1_term_6
+  cap_ctrl02_term_6 cap_ctrl01_term_6 cap_ctrl00_term_6 vddce_6
+  cap_ctrl12_term_5 cap_ctrl11_term_5 cap_ctrl10_term_5 q0_5 vnwp_6
+  vss_ast0_term_5 vss_ast1_term_5 twen1_5 cap_ctrl02_term_5 cap_ctrl01_term_5
+  cap_ctrl00_term_5 vss_5 q1_5 cap_ctrl12_term_4 cap_ctrl11_term_4
+  cap_ctrl10_term_4 q0_4 vnwp_5 vss_ast0_term_4 vss_ast1_term_4
+  cap_ctrl02_term_4 cap_ctrl01_term_4 cap_ctrl00_term_4 vddce_4
+  cap_ctrl12_term_3 cap_ctrl11_term_3 cap_ctrl10_term_3 q0_3 vnwp_4
+  vss_ast0_term_3 vss_ast1_term_3 twen1_3 cap_ctrl02_term_3 cap_ctrl01_term_3
+  cap_ctrl00_term_3 vddce_3 cap_ctrl12_term_2 cap_ctrl11_term_2
+  cap_ctrl10_term_2 vnwp_3 twen0_2 vss_ast0_term_2 vss_ast1_term_2 twen1_2
+  cap_ctrl02_term_2 cap_ctrl01_term_2 cap_ctrl00_term_2 vsse_3 vddce_2
+  cap_ctrl12_term_1 cap_ctrl11_term_1 cap_ctrl10_term_1 q0_1 vnwp_2
+  vss_ast0_term_1 vss_ast1_term_1 cap_ctrl02_term_1 cap_ctrl01_term_1
+  cap_ctrl00_term_1 vddce_1 cap_ctrl12_term_0 cap_ctrl11_term_0
+  cap_ctrl10_term_0 q0_0 vnwp_1 vss_ast0_term_0 vss_ast1_term_0 twen1_0
+  cap_ctrl02_term_0 cap_ctrl01_term_0 cap_ctrl00_term_0 vddce_0 vpw_0 vnwc_0
+  vsse_0 sram128x46cap_row_l
xcap_right vnwp_25 si_1 psi_1 q1_22 vpw_24 cap_ctrl00_22 cap_ctrl01_22
+  cap_ctrl02_22 vddpe_23 vss_ast1_22 vss_ast0_22 twen0_22 wen0_22 td0_22
+  vddp_22 vss_23 q0_22 cap_ctrl10_22 cap_ctrl11_22 cap_ctrl12_22 q1_21
+  cap_ctrl00_21 cap_ctrl01_21 cap_ctrl02_21 d1_21 td1_21 twen1_21 weny1_21
+  wen_lat1_term_21 vss_ast1_21 vss_ast0_21 twen0_21 td0_21 vddpe_22 vddp_21
+  cap_ctrl10_21 cap_ctrl11_21 cap_ctrl12_21 cap_ctrl00_20 cap_ctrl01_20
+  cap_ctrl02_20 vddpe_21 d1_20 wen1_20 weny1_20 wen_lat1_term_20 vss_ast1_20
+  wen_lat0_term_20 vss_ast0_20 weny0_20 twen0_20 d0_20 vddp_20 vpw_22
+  cap_ctrl10_20 cap_ctrl11_20 cap_ctrl12_20 vddce_20 cap_ctrl00_19
+  cap_ctrl01_19 cap_ctrl02_19 vddpe_20 d1_19 td1_19 wen1_19 twen1_19 weny1_19
+  wen_lat1_term_19 vss_ast1_19 wen_lat0_term_19 vss_ast0_19 weny0_19 twen0_19
+  wen0_19 td0_19 d0_19 vddp_19 vsse_21 vpw_21 cap_ctrl10_19 cap_ctrl11_19
+  cap_ctrl12_19 q1_18 vddce_19 vss_19 cap_ctrl00_18 cap_ctrl01_18
+  cap_ctrl02_18 vddpe_19 d1_18 td1_18 wen1_18 weny1_18 wen_lat1_term_18
+  vss_ast1_18 wen_lat0_term_18 vss_ast0_18 weny0_18 twen0_18 wen0_18 td0_18
+  d0_18 vddp_18 vsse_20 vpw_20 cap_ctrl10_18 cap_ctrl11_18 cap_ctrl12_18
+  q1_17 vpw_19 cap_ctrl00_17 cap_ctrl01_17 cap_ctrl02_17 vss_ast1_17
+  vss_ast0_17 weny0_17 twen0_17 wen0_17 td0_17 d0_17 vddpe_18 vddp_17
+  cap_ctrl10_17 cap_ctrl11_17 cap_ctrl12_17 vddce_17 vss_17 cap_ctrl00_16
+  cap_ctrl01_16 cap_ctrl02_16 vddpe_17 d1_16 td1_16 wen1_16 twen1_16 weny1_16
+  wen_lat1_term_16 vss_ast1_16 wen_lat0_term_16 vss_ast0_16 weny0_16 twen0_16
+  wen0_16 td0_16 d0_16 vddp_16 vsse_18 vpw_18 cap_ctrl10_16 cap_ctrl11_16
+  cap_ctrl12_16 q1_15 vddce_16 vpw_17 vss_16 cap_ctrl00_15 cap_ctrl01_15
+  cap_ctrl02_15 vddpe_16 d1_15 td1_15 wen1_15 weny1_15 wen_lat1_term_15
+  vss_ast1_15 wen_lat0_term_15 vss_ast0_15 weny0_15 wen0_15 td0_15 q0_15
+  cap_ctrl10_15 cap_ctrl11_15 cap_ctrl12_15 q1_14 vpw_16 cap_ctrl00_14
+  cap_ctrl01_14 cap_ctrl02_14 twen1_14 weny1_14 wen_lat1_term_14 vss_ast1_14
+  wen_lat0_term_14 vss_ast0_14 weny0_14 twen0_14 wen0_14 td0_14 d0_14
+  vddpe_15 vddp_14 vsse_16 cap_ctrl10_14 cap_ctrl11_14 cap_ctrl12_14 q1_13
+  vddce_14 vpw_15 vss_14 cap_ctrl00_13 cap_ctrl01_13 cap_ctrl02_13 d1_13
+  td1_13 wen1_13 weny1_13 wen_lat1_term_13 vss_ast1_13 wen_lat0_term_13
+  vss_ast0_13 weny0_13 wen0_13 td0_13 d0_13 vddp_13 vsse_15 cap_ctrl10_13
+  cap_ctrl11_13 cap_ctrl12_13 q1_12 vddce_13 vpw_14 vss_13 cap_ctrl00_12
+  cap_ctrl01_12 cap_ctrl02_12 vddpe_13 d1_12 td1_12 wen1_12 weny1_12
+  wen_lat1_term_12 vss_ast1_12 wen_lat0_term_12 vss_ast0_12 twen0_12 wen0_12
+  td0_12 q0_12 cap_ctrl10_12 cap_ctrl11_12 cap_ctrl12_12 q1_11 vpw_13
+  cap_ctrl00_11 cap_ctrl01_11 cap_ctrl02_11 vddpe_12 d1_11 td1_11 wen1_11
+  weny1_11 wen_lat1_term_11 vss_ast1_11 wen_lat0_term_11 vss_ast0_11 weny0_11
+  wen0_11 td0_11 d0_11 vddp_11 vsse_13 cap_ctrl10_11 cap_ctrl11_11
+  cap_ctrl12_11 vsse_25 vnwc_2 vpw_25 vddce_23 vnwp_24 cap_ctrl00_term_22
+  cap_ctrl01_term_22 cap_ctrl02_term_22 d1_22 td1_22 wen1_22 twen1_22
+  weny1_22 wen_lat1_term_22 vss_ast1_term_22 wen_lat0_term_22
+  vss_ast0_term_22 weny0_22 d0_22 vsse_24 cap_ctrl10_term_22
+  cap_ctrl11_term_22 cap_ctrl12_term_22 vddce_22 vpw_23 vss_22 vsse_23
+  cap_ctrl00_term_21 cap_ctrl01_term_21 cap_ctrl02_term_21 wen1_21
+  vss_ast1_term_21 wen_lat0_term_21 vss_ast0_term_21 weny0_21 wen0_21 d0_21
+  vnwp_23 q0_21 cap_ctrl10_term_21 cap_ctrl11_term_21 cap_ctrl12_term_21
+  q1_20 vddce_21 vss_21 cap_ctrl00_term_20 cap_ctrl01_term_20
+  cap_ctrl02_term_20 td1_20 twen1_20 vss_ast1_term_20 vss_ast0_term_20
+  wen0_20 td0_20 vsse_22 vnwp_22 q0_20 cap_ctrl10_term_20 cap_ctrl11_term_20
+  cap_ctrl12_term_20 q1_19 vss_20 cap_ctrl00_term_19 cap_ctrl01_term_19
+  cap_ctrl02_term_19 vss_ast1_term_19 vss_ast0_term_19 vnwp_21 q0_19
+  cap_ctrl10_term_19 cap_ctrl11_term_19 cap_ctrl12_term_19 cap_ctrl00_term_18
+  cap_ctrl01_term_18 cap_ctrl02_term_18 twen1_18 vss_ast1_term_18
+  vss_ast0_term_18 vnwp_20 q0_18 cap_ctrl10_term_18 cap_ctrl11_term_18
+  cap_ctrl12_term_18 vddce_18 vss_18 vsse_19 cap_ctrl00_term_17
+  cap_ctrl01_term_17 cap_ctrl02_term_17 d1_17 td1_17 wen1_17 twen1_17
+  weny1_17 wen_lat1_term_17 vss_ast1_term_17 wen_lat0_term_17
+  vss_ast0_term_17 vnwp_19 q0_17 cap_ctrl10_term_17 cap_ctrl11_term_17
+  cap_ctrl12_term_17 q1_16 cap_ctrl00_term_16 cap_ctrl01_term_16
+  cap_ctrl02_term_16 vss_ast1_term_16 vss_ast0_term_16 vnwp_18 q0_16
+  cap_ctrl10_term_16 cap_ctrl11_term_16 cap_ctrl12_term_16 cap_ctrl00_term_15
+  cap_ctrl01_term_15 cap_ctrl02_term_15 twen1_15 vss_ast1_term_15
+  vss_ast0_term_15 twen0_15 d0_15 vddp_15 vsse_17 vnwp_17 cap_ctrl10_term_15
+  cap_ctrl11_term_15 cap_ctrl12_term_15 vddce_15 vss_15 cap_ctrl00_term_14
+  cap_ctrl01_term_14 cap_ctrl02_term_14 d1_14 td1_14 wen1_14 vss_ast1_term_14
+  vss_ast0_term_14 vnwp_16 q0_14 cap_ctrl10_term_14 cap_ctrl11_term_14
+  cap_ctrl12_term_14 cap_ctrl00_term_13 cap_ctrl01_term_13 cap_ctrl02_term_13
+  twen1_13 vss_ast1_term_13 vss_ast0_term_13 twen0_13 vddpe_14 vnwp_15 q0_13
+  cap_ctrl10_term_13 cap_ctrl11_term_13 cap_ctrl12_term_13 vnwp_14
+  cap_ctrl00_term_12 cap_ctrl01_term_12 cap_ctrl02_term_12 twen1_12
+  vss_ast1_term_12 vss_ast0_term_12 weny0_12 d0_12 vddp_12 vsse_14
+  cap_ctrl10_term_12 cap_ctrl11_term_12 cap_ctrl12_term_12 vddce_12 vss_12
+  cap_ctrl00_term_11 cap_ctrl01_term_11 cap_ctrl02_term_11 twen1_11
+  vss_ast1_term_11 vss_ast0_term_11 twen0_11 vnwp_13 q0_11 cap_ctrl10_term_11
+  cap_ctrl11_term_11 cap_ctrl12_term_11 sram128x46cap_row_r
.ends sram128x46cap_slice
****
.subckt sram128x46wa_cntl wa_en_left wa_en_right wablm0_left wablm0_right
+  wablm1_left wablm1_right a0 a1 a2 a3 a4 a5 a6 a7 a8 a9 a10 actp ay0 ay1 ay2
+  ay3 ay4 ay5 ay6 ay7 ay8 ay9 ay10 cen ceny clk cre1 cre2 dbl_nbl_wa
+  dbl_nbl_wa_el dbl_nbl_wa_term dbl_nbl_wa_turn dbl_nbl_wa_turn_term dft_p2
+  dft_p2_term dftrambyp_dum ema[0] ema[1] ema[2] emas emaw[0] emaw[1] fca1_0
+  fca1_1 fca1_2 fca1_3 fca1_4 fca1_5 fca1_6 fca2_0 fca2_1 fca2_2 fca2_3
+  fca2_4 fca2_5 fca2_6 gtp gtp_term gwen gwen_p2 gwen_p2_term gweny log0 log1
+  nactc nret nretnvt pen pensi penso pgen_dum pso0 pso1 rawl rawlm0 rawlm1
+  rdt ret2n_dum se so0 so1 ta0 ta1 ta2 ta3 ta4 ta5 ta6 ta7 ta8 ta9 ta10 tcen
+  ten tgwen tpen vddce vddpe vnwc vnwp vpw vss vsse wabl wablm0 wablm1
** sram128x46wa_cntl: 54 flat devices **
m_assist.i129.mxna1 _assist.net035 gtp vss vpw nch_mac W=0.22U L=0.035U NF=1
m_assist.i129.mxpa1 _assist.net035 gtp vddpe vnwp pch_mac W=0.3U L=0.035U NF=1
m_assist.i137.mxna1 _assist.nwablm[0] wablm0 vss vpw nch_mac W=0.22U L=0.035U
+  NF=1
m_assist.i137.mxpa1 _assist.nwablm[0] wablm0 vddpe vnwp pch_mac W=0.3U
+  L=0.035U NF=1
m_assist.i139.mxna1 _assist.nwablm[1] wablm1 vss vpw nch_mac W=0.22U L=0.035U
+  NF=1
m_assist.i139.mxpa1 _assist.nwablm[1] wablm1 vddpe vnwp pch_mac W=0.3U
+  L=0.035U NF=1
m_assist.i14.mxna1 wa_en_left _assist.net021 vss vpw nch_mac W=2.4U L=0.035U
+  NF=6
m_assist.i14.mxpa1 wa_en_left _assist.net021 vddpe vnwp pch_mac W=2.4U
+  L=0.035U NF=6
m_assist.i143.mxna1 wablm0_left _assist.nwablm0_out vss vpw nch_mac W=1U
+  L=0.035U NF=1
m_assist.i143.mxpa1 wablm0_left _assist.nwablm0_out vddpe vnwp pch_mac W=1U
+  L=0.035U NF=1
m_assist.i144.mxna1 wablm0_right _assist.nwablm0_out vss vpw nch_mac W=1U
+  L=0.035U NF=1
m_assist.i144.mxpa1 wablm0_right _assist.nwablm0_out vddpe vnwp pch_mac W=1U
+  L=0.035U NF=1
m_assist.i149.mxna1 wa_en_right _assist.net021 vss vpw nch_mac W=2.4U L=0.035U
+  NF=6
m_assist.i149.mxpa1 wa_en_right _assist.net021 vddpe vnwp pch_mac W=2.4U
+  L=0.035U NF=6
m_assist.i168.mxna1 _assist.wa_en gwen_p2 vss vpw nch_mac W=0.4U L=0.035U NF=1
m_assist.i168.mxna2 _assist.wa_en dft_p2 vss vpw nch_mac W=0.4U L=0.035U NF=1
m_assist.i168.mxna3 _assist.wa_en _assist.nwabl_lat vss vpw nch_mac W=0.4U
+  L=0.035U NF=1
m_assist.i168.mxpa1 _assist.wa_en gwen_p2 _assist.i168.p2 vnwp pch_mac W=0.4U
+  L=0.035U NF=1
m_assist.i168.mxpa2 _assist.i168.p2 dft_p2 _assist.i168.p1 vnwp pch_mac W=0.4U
+  L=0.035U NF=1
m_assist.i168.mxpa3 _assist.i168.p1 _assist.nwabl_lat vddpe vnwp pch_mac
+  W=0.4U L=0.035U NF=1
m_assist.i170.mxna1 _assist.wa_en_dly _assist.wablm1_p2 _assist.i170.n1 vpw
+  nch_mac W=0.3U L=0.035U NF=1
m_assist.i170.mxna2 _assist.i170.n1 _assist.net035 vss vpw nch_mac W=0.3U
+  L=0.035U NF=1
m_assist.i170.mxpa1 _assist.wa_en_dly _assist.wablm1_p2 vddpe vnwp pch_mac
+  W=0.2U L=0.035U NF=1
m_assist.i170.mxpa2 _assist.wa_en_dly _assist.net035 vddpe vnwp pch_mac W=0.2U
+  L=0.035U NF=1
m_assist.i171.mxna1 _assist.net041 _assist.wa_en _assist.i171.n1 vpw nch_mac
+  W=0.3U L=0.035U NF=1
m_assist.i171.mxna2 _assist.i171.n1 _assist.wa_en_dly vss vpw nch_mac W=0.3U
+  L=0.035U NF=1
m_assist.i171.mxpa1 _assist.net041 _assist.wa_en vddpe vnwp pch_mac W=0.2U
+  L=0.035U NF=1
m_assist.i171.mxpa2 _assist.net041 _assist.wa_en_dly vddpe vnwp pch_mac W=0.2U
+  L=0.035U NF=1
m_assist.i172.mxna1 _assist.wa_en_local _assist.net041 vss vpw nch_mac W=0.22U
+  L=0.035U NF=1
m_assist.i172.mxpa1 _assist.wa_en_local _assist.net041 vddpe vnwp pch_mac
+  W=0.3U L=0.035U NF=1
m_assist.i174.mxna1 _assist.nwablm0_out _assist.wablm0_p2 vss vpw nch_mac W=1U
+  L=0.035U NF=1
m_assist.i174.mxpa1 _assist.nwablm0_out _assist.wablm0_p2 vddpe vnwp pch_mac
+  W=1U L=0.035U NF=1
m_assist.i190.mxna1 _assist.wablm0_p2 _assist.nwablm[0] vss vpw nch_mac
+  W=0.22U L=0.035U NF=1
m_assist.i190.mxpa1 _assist.wablm0_p2 _assist.nwablm[0] vddpe vnwp pch_mac
+  W=0.3U L=0.035U NF=1
m_assist.i191.mxna1 _assist.wablm1_p2 _assist.nwablm[1] vss vpw nch_mac
+  W=0.22U L=0.035U NF=1
m_assist.i191.mxpa1 _assist.wablm1_p2 _assist.nwablm[1] vddpe vnwp pch_mac
+  W=0.3U L=0.035U NF=1
m_assist.i192.mxna1 _assist.nwablm1_out _assist.wablm1_p2 vss vpw nch_mac W=1U
+  L=0.035U NF=1
m_assist.i192.mxpa1 _assist.nwablm1_out _assist.wablm1_p2 vddpe vnwp pch_mac
+  W=1U L=0.035U NF=1
m_assist.i193.mxna1 wablm1_right _assist.nwablm1_out vss vpw nch_mac W=1U
+  L=0.035U NF=1
m_assist.i193.mxpa1 wablm1_right _assist.nwablm1_out vddpe vnwp pch_mac W=1U
+  L=0.035U NF=1
m_assist.i194.mxna1 wablm1_left _assist.nwablm1_out vss vpw nch_mac W=1U
+  L=0.035U NF=1
m_assist.i194.mxpa1 wablm1_left _assist.nwablm1_out vddpe vnwp pch_mac W=1U
+  L=0.035U NF=1
m_assist.i200.mxna1 _assist.net031 dbl_nbl_wa_turn vss vpw nch_mac W=1U
+  L=0.035U NF=1
m_assist.i200.mxpa1 _assist.net031 dbl_nbl_wa_turn vddpe vnwp pch_mac W=1U
+  L=0.035U NF=1
m_assist.i201.mxna1 _assist.net021 _assist.net031 vss vpw nch_mac W=1U
+  L=0.035U NF=1
m_assist.i201.mxpa1 _assist.net021 _assist.net031 vddpe vnwp pch_mac W=1U
+  L=0.035U NF=1
m_assist.i74.mxna1 _assist.nwabl_lat wabl vss vpw nch_mac W=0.22U L=0.035U
+  NF=1
m_assist.i74.mxpa1 _assist.nwabl_lat wabl vddpe vnwp pch_mac W=0.3U L=0.035U
+  NF=1
m_assist.mxn10 _assist.net039 _assist.wa_en_local vss vpw nch_mac W=0.5U
+  L=0.035U NF=1
m_assist.mxn12 dbl_nbl_wa gtp _assist.net039 vpw nch_mac W=0.5U L=0.035U NF=1
m_assist.mxn5 _assist.net045 _assist.wa_en_local vss vpw nch_mac W=0.5U
+  L=0.035U NF=1
m_assist.mxn6 dbl_nbl_wa_el gtp _assist.net045 vpw nch_mac W=0.2U L=0.035U
+  NF=1
m_assist.mxp5 dbl_nbl_wa gtp vddpe vnwp pch_mac W=5U L=0.035U NF=1
m_assist.mxp6 dbl_nbl_wa _assist.wa_en_local vddpe vnwp pch_mac W=1U L=0.035U
+  NF=1
.ends sram128x46wa_cntl
****
.subckt sram128x46wa_cntl_s nretnvt nactc actp fca2_6 fca2_5 fca2_4 fca2_3
+  fca2_2 fca2_1 cre2 fca1_0 vpw vnwp vnwc vddce vddpe dft_p2 gwen_p2 gtp
+  dbl_nbl_wa_turn dbl_nbl_wa ten dftrambyp_dum emas ema[0] ema[1] ema[2]
+  emaw[0] emaw[1] pgen_dum ceny vsse fca2_0 fca1_6 fca1_5 fca1_4 fca1_3
+  fca1_2 fca1_1 cre1 vss dft_p2_term gwen_p2_term gtp_term
+  dbl_nbl_wa_turn_term dbl_nbl_wa_term penso pensi tpen pen pso1 pso0 se so1
+  so0 log1 log0 wablm1 wablm0 wabl rawlm1 rawlm0 rawl nret ret2n_dum rdt gwen
+  cen clk a0 a1 a2 a3 a4 a5 a6 a7 a8 a9 a10 tgwen tcen ta0 ta1 ta2 ta3 ta4
+  ta5 ta6 ta7 ta8 ta9 ta10 gweny ay0 ay1 ay2 ay3 ay4 ay5 ay6 ay7 ay8 ay9 ay10
+  wablm0_right wa_en_right wablm1_right wablm0_left wa_en_left wablm1_left
** sram128x46wa_cntl_s: 54 flat devices **
xwa_cntl wa_en_left wa_en_right wablm0_left wablm0_right wablm1_left
+  wablm1_right a0 a1 a2 a3 a4 a5 a6 a7 a8 a9 a10 actp ay0 ay1 ay2 ay3 ay4 ay5
+  ay6 ay7 ay8 ay9 ay10 cen ceny clk cre1 cre2 dbl_nbl_wa dbl_nbl_wa_el
+  dbl_nbl_wa_term dbl_nbl_wa_turn dbl_nbl_wa_turn_term dft_p2 dft_p2_term
+  dftrambyp_dum ema[0] ema[1] ema[2] emas emaw[0] emaw[1] fca1_0 fca1_1
+  fca1_2 fca1_3 fca1_4 fca1_5 fca1_6 fca2_0 fca2_1 fca2_2 fca2_3 fca2_4
+  fca2_5 fca2_6 gtp gtp_term gwen gwen_p2 gwen_p2_term gweny log0 log1 nactc
+  nret nretnvt pen pensi penso pgen_dum pso0 pso1 rawl rawlm0 rawlm1 rdt
+  ret2n_dum se so0 so1 ta0 ta1 ta2 ta3 ta4 ta5 ta6 ta7 ta8 ta9 ta10 tcen ten
+  tgwen tpen vddce vddpe vnwc vnwp vpw vss vsse wabl wablm0 wablm1
+  sram128x46wa_cntl
.ends sram128x46wa_cntl_s
****
.subckt sram128x46wa_nbl_cm2 cap_ctrl00 cap_ctrl00_term cap_ctrl01
+  cap_ctrl01_term cap_ctrl02 cap_ctrl02_term cap_ctrl10 cap_ctrl10_term
+  cap_ctrl11 cap_ctrl11_term cap_ctrl12 cap_ctrl12_term d0 d1 q0 q1 td0 td1
+  twen0 twen1 vddce vddp vddpe vnwp vpw vss vss_ast0 vss_ast1 vsse wa_en
+  wablm0 wablm1 wen0 wen1 wen_lat0 wen_lat0_term wen_lat1 wen_lat1_term weny0
+  weny1
** sram128x46wa_nbl_cm2: 32 flat devices **
m_nbl_ast0.i0.mxna1 cap_ctrl00 _nbl_ast0.wa vss vpw nch_mac W=0.74U L=0.035U
+  NF=1
m_nbl_ast0.i0.mxpa1 cap_ctrl00 _nbl_ast0.wa vddp vnwp pch_mac W=0.185U
+  L=0.035U NF=1
m_nbl_ast0.i35.mxna1 _nbl_ast0.nwa wa_en vss vpw nch_mac W=0.185U L=0.035U
+  NF=1
m_nbl_ast0.i35.mxpa1 _nbl_ast0.nwa wa_en vddp vnwp pch_mac W=0.185U L=0.035U
+  NF=1
m_nbl_ast0.i36.mxna1 _nbl_ast0.wa wen_lat0 vss vpw nch_mac W=0.185U L=0.035U
+  NF=1
m_nbl_ast0.i36.mxna2 _nbl_ast0.wa _nbl_ast0.nwa vss vpw nch_mac W=0.185U
+  L=0.035U NF=1
m_nbl_ast0.i36.mxpa1 _nbl_ast0.wa wen_lat0 _nbl_ast0.i36.p1 vnwp pch_mac
+  W=0.185U L=0.035U NF=1
m_nbl_ast0.i36.mxpa2 _nbl_ast0.i36.p1 _nbl_ast0.nwa vddp vnwp pch_mac W=0.185U
+  L=0.035U NF=1
m_nbl_ast0.mxm11 cap_ctrl01 vss_ast0 cap_ctrl01 vnwp pch_mac W=4U L=0.035U
+  NF=6
m_nbl_ast0.mxm14 vss_ast0 _nbl_ast0.nwa vss vpw nch_mac W=2.48U L=0.035U NF=1
m_nbl_ast0.mxm7 cap_ctrl00 vss_ast0 cap_ctrl00 vnwp pch_mac W=10U L=0.035U
+  NF=17
m_nbl_ast0.mxn4 cap_ctrl00 wablm1 cap_ctrl02 vpw nch_mac W=0.3U L=0.035U NF=1
m_nbl_ast0.mxn5 cap_ctrl00 wablm0 cap_ctrl01 vpw nch_mac W=0.3U L=0.035U NF=1
m_nbl_ast0.mxp2 cap_ctrl02 vss_ast0 cap_ctrl02 vnwp pch_mac W=2U L=0.035U NF=6
m_nbl_ast0.mxp4 cap_ctrl02 _nbl_ast0.wa vddp vnwp pch_mac W=0.185U L=0.035U
+  NF=17
m_nbl_ast0.mxp5 cap_ctrl01 _nbl_ast0.wa vddp vnwp pch_mac W=0.185U L=0.035U
+  NF=17
m_nbl_ast1.i0.mxna1 cap_ctrl10 _nbl_ast1.wa vss vpw nch_mac W=0.74U L=0.035U
+  NF=1
m_nbl_ast1.i0.mxpa1 cap_ctrl10 _nbl_ast1.wa vddp vnwp pch_mac W=0.185U
+  L=0.035U NF=1
m_nbl_ast1.i35.mxna1 _nbl_ast1.nwa wa_en vss vpw nch_mac W=0.185U L=0.035U
+  NF=1
m_nbl_ast1.i35.mxpa1 _nbl_ast1.nwa wa_en vddp vnwp pch_mac W=0.185U L=0.035U
+  NF=1
m_nbl_ast1.i36.mxna1 _nbl_ast1.wa wen_lat1 vss vpw nch_mac W=0.185U L=0.035U
+  NF=1
m_nbl_ast1.i36.mxna2 _nbl_ast1.wa _nbl_ast1.nwa vss vpw nch_mac W=0.185U
+  L=0.035U NF=1
m_nbl_ast1.i36.mxpa1 _nbl_ast1.wa wen_lat1 _nbl_ast1.i36.p1 vnwp pch_mac
+  W=0.185U L=0.035U NF=1
m_nbl_ast1.i36.mxpa2 _nbl_ast1.i36.p1 _nbl_ast1.nwa vddp vnwp pch_mac W=0.185U
+  L=0.035U NF=1
m_nbl_ast1.mxm11 cap_ctrl11 vss_ast1 cap_ctrl11 vnwp pch_mac W=4U L=0.035U
+  NF=6
m_nbl_ast1.mxm14 vss_ast1 _nbl_ast1.nwa vss vpw nch_mac W=2.48U L=0.035U NF=1
m_nbl_ast1.mxm7 cap_ctrl10 vss_ast1 cap_ctrl10 vnwp pch_mac W=10U L=0.035U
+  NF=17
m_nbl_ast1.mxn4 cap_ctrl10 wablm1 cap_ctrl12 vpw nch_mac W=0.3U L=0.035U NF=1
m_nbl_ast1.mxn5 cap_ctrl10 wablm0 cap_ctrl11 vpw nch_mac W=0.3U L=0.035U NF=1
m_nbl_ast1.mxp2 cap_ctrl12 vss_ast1 cap_ctrl12 vnwp pch_mac W=2U L=0.035U NF=6
m_nbl_ast1.mxp4 cap_ctrl12 _nbl_ast1.wa vddp vnwp pch_mac W=0.185U L=0.035U
+  NF=17
m_nbl_ast1.mxp5 cap_ctrl11 _nbl_ast1.wa vddp vnwp pch_mac W=0.185U L=0.035U
+  NF=17
.ends sram128x46wa_nbl_cm2
****
.subckt sram128x46nbl_r wen_lat1_11 wen_lat0_11 cap_ctrl10_term_11
+  cap_ctrl11_term_11 cap_ctrl12_term_11 twen1_10 weny1_10 wen_lat1_10
+  vss_ast1_10 wen_lat0_10 vss_ast0_10 twen0_10 vddp_10 vsse_10 vss_10 vpw_10
+  cap_ctrl10_term_10 cap_ctrl11_term_10 cap_ctrl12_term_10 d1_9 wen1_9
+  twen1_9 weny1_9 wen_lat1_9 vss_ast1_9 wen_lat0_9 vss_ast0_9 weny0_9 twen0_9
+  vddpe_9 vddp_9 vsse_9 vss_9 vpw_9 cap_ctrl10_term_9 cap_ctrl11_term_9
+  cap_ctrl12_term_9 d1_8 td1_8 wen1_8 twen1_8 weny1_8 wen_lat1_8 vss_ast1_8
+  wen_lat0_8 vss_ast0_8 weny0_8 twen0_8 wen0_8 td0_8 vddce_8 vddp_8
+  cap_ctrl10_term_8 cap_ctrl11_term_8 cap_ctrl12_term_8 q1_7 d1_7 td1_7
+  wen1_7 twen1_7 weny1_7 wen_lat1_7 vss_ast1_7 wen_lat0_7 vss_ast0_7 weny0_7
+  twen0_7 wen0_7 td0_7 d0_7 vddpe_7 vddce_7 vddp_7 vsse_7 vss_7 vpw_7 vnwp_7
+  cap_ctrl10_term_7 cap_ctrl11_term_7 cap_ctrl12_term_7 q1_6 vpw_6 d1_6 td1_6
+  wen1_6 twen1_6 weny1_6 wen_lat1_6 vss_ast1_6 wen_lat0_6 vss_ast0_6 weny0_6
+  twen0_6 wen0_6 td0_6 d0_6 vddpe_6 vddce_6 vddp_6 vsse_6 vss_6 vnwp_6 q0_6
+  cap_ctrl10_term_6 cap_ctrl11_term_6 cap_ctrl12_term_6 q1_5 vpw_5 vss_5
+  td1_5 wen1_5 twen1_5 weny1_5 wen_lat1_5 vss_ast1_5 wen_lat0_5 vss_ast0_5
+  weny0_5 twen0_5 wen0_5 td0_5 d0_5 vddpe_5 vddce_5 vddp_5 vsse_5 vnwp_5
+  cap_ctrl10_term_5 cap_ctrl11_term_5 cap_ctrl12_term_5 q1_4 d1_4 td1_4
+  wen1_4 twen1_4 weny1_4 wen_lat1_4 vss_ast1_4 wen_lat0_4 vss_ast0_4 weny0_4
+  twen0_4 wen0_4 td0_4 d0_4 vddpe_4 vddce_4 vddp_4 vsse_4 vss_4 vnwp_4 q0_4
+  cap_ctrl10_term_4 cap_ctrl11_term_4 cap_ctrl12_term_4 q1_3 vss_3 d1_3 td1_3
+  wen1_3 weny1_3 wen_lat1_3 wen_lat0_3 vss_ast0_3 weny0_3 twen0_3 wen0_3
+  td0_3 d0_3 vddpe_3 vddce_3 vddp_3 vsse_3 vpw_3 vnwp_3 q0_3
+  cap_ctrl10_term_3 cap_ctrl11_term_3 cap_ctrl12_term_3 q1_2 vpw_2 vss_2
+  vsse_2 twen1_2 wen_lat1_2 vss_ast1_2 wen_lat0_2 vss_ast0_2 weny0_2 twen0_2
+  wen0_2 td0_2 d0_2 vddpe_2 vddce_2 vddp_2 vnwp_2 cap_ctrl10_term_2
+  cap_ctrl11_term_2 cap_ctrl12_term_2 q1_1 vpw_1 d1_1 td1_1 wen1_1 weny1_1
+  wen_lat1_1 wen_lat0_1 vss_ast0_1 weny0_1 twen0_1 wen0_1 td0_1 d0_1 vddpe_1
+  vddce_1 vddp_1 vsse_1 vss_1 vnwp_1 q0_1 cap_ctrl10_term_1 cap_ctrl11_term_1
+  cap_ctrl12_term_1 q1_0 vss_0 d1_0 td1_0 wen1_0 weny1_0 wen_lat1_0
+  wen_lat0_0 vss_ast0_0 weny0_0 twen0_0 wen0_0 td0_0 d0_0 vddpe_0 vddce_0
+  vddp_0 vpw_0 vnwp_0 cap_ctrl10_term_0 cap_ctrl11_term_0 cap_ctrl12_term_0
+  q1_11 cap_ctrl00_11 cap_ctrl01_11 cap_ctrl02_11 d1_11 td1_11 wen1_11
+  twen1_11 weny1_11 wen_lat1_term_11 vss_ast1_11 wen_lat0_term_11 vss_ast0_11
+  weny0_11 twen0_11 wen0_11 td0_11 d0_11 vddpe_11 vddce_11 vddp_11 vsse_11
+  vss_11 vpw_11 vnwp_11 q0_11 cap_ctrl10_11 cap_ctrl11_11 cap_ctrl12_11 q1_10
+  cap_ctrl00_10 cap_ctrl01_10 cap_ctrl02_10 d1_10 td1_10 wen1_10
+  wen_lat1_term_10 wen_lat0_term_10 weny0_10 wen0_10 td0_10 d0_10 vddpe_10
+  vddce_10 vnwp_10 q0_10 cap_ctrl10_10 cap_ctrl11_10 cap_ctrl12_10 q1_9
+  cap_ctrl00_9 cap_ctrl01_9 cap_ctrl02_9 td1_9 wen_lat1_term_9
+  wen_lat0_term_9 wen0_9 td0_9 d0_9 vddce_9 vnwp_9 q0_9 cap_ctrl10_9
+  cap_ctrl11_9 cap_ctrl12_9 q1_8 vpw_8 cap_ctrl00_8 cap_ctrl01_8 cap_ctrl02_8
+  wen_lat1_term_8 wen_lat0_term_8 d0_8 vddpe_8 vsse_8 vss_8 vnwp_8 q0_8
+  cap_ctrl10_8 cap_ctrl11_8 cap_ctrl12_8 cap_ctrl00_7 cap_ctrl01_7
+  cap_ctrl02_7 wen_lat1_term_7 wen_lat0_term_7 q0_7 cap_ctrl10_7 cap_ctrl11_7
+  cap_ctrl12_7 cap_ctrl00_6 cap_ctrl01_6 cap_ctrl02_6 wen_lat1_term_6
+  wen_lat0_term_6 cap_ctrl10_6 cap_ctrl11_6 cap_ctrl12_6 cap_ctrl00_5
+  cap_ctrl01_5 cap_ctrl02_5 d1_5 wen_lat1_term_5 wen_lat0_term_5 q0_5
+  cap_ctrl10_5 cap_ctrl11_5 cap_ctrl12_5 vpw_4 cap_ctrl00_4 cap_ctrl01_4
+  cap_ctrl02_4 wen_lat1_term_4 wen_lat0_term_4 cap_ctrl10_4 cap_ctrl11_4
+  cap_ctrl12_4 cap_ctrl00_3 cap_ctrl01_3 cap_ctrl02_3 twen1_3 wen_lat1_term_3
+  vss_ast1_3 wen_lat0_term_3 cap_ctrl10_3 cap_ctrl11_3 cap_ctrl12_3
+  cap_ctrl00_2 cap_ctrl01_2 cap_ctrl02_2 d1_2 td1_2 wen1_2 weny1_2
+  wen_lat1_term_2 wen_lat0_term_2 q0_2 cap_ctrl10_2 cap_ctrl11_2 cap_ctrl12_2
+  cap_ctrl00_1 cap_ctrl01_1 cap_ctrl02_1 twen1_1 wen_lat1_term_1 vss_ast1_1
+  wen_lat0_term_1 cap_ctrl10_1 cap_ctrl11_1 cap_ctrl12_1 vsse_0 cap_ctrl00_0
+  cap_ctrl01_0 cap_ctrl02_0 twen1_0 wen_lat1_term_0 vss_ast1_0
+  wen_lat0_term_0 q0_0 cap_ctrl10_0 cap_ctrl11_0 cap_ctrl12_0 wablm0 wa_en
+  wablm1
** sram128x46nbl_r: 384 flat devices **
xr_ast_1 cap_ctrl00_1 cap_ctrl00_term_3 cap_ctrl01_1 cap_ctrl01_term_5
+  cap_ctrl02_1 cap_ctrl02_term_7 cap_ctrl10_1 cap_ctrl10_term_1 cap_ctrl11_1
+  cap_ctrl11_term_1 cap_ctrl12_1 cap_ctrl12_term_1 d0_1 d1_1 q0_1 q1_1 td0_1
+  td1_1 twen0_1 twen1_1 vddce_1 vddp_1 vddpe_1 vnwp_1 vpw_1 vss_1 vss_ast0_1
+  vss_ast1_1 vsse_1 wa_en wablm0 wablm1 wen0_1 wen1_1 wen_lat0_1
+  wen_lat0_term_1 wen_lat1_1 wen_lat1_term_1 weny0_1 weny1_1
+  sram128x46wa_nbl_cm2
xr_ast_10 cap_ctrl00_10 cap_ctrl00_term_63 cap_ctrl01_10 cap_ctrl01_term_65
+  cap_ctrl02_10 cap_ctrl02_term_67 cap_ctrl10_10 cap_ctrl10_term_10
+  cap_ctrl11_10 cap_ctrl11_term_10 cap_ctrl12_10 cap_ctrl12_term_10 d0_10
+  d1_10 q0_10 q1_10 td0_10 td1_10 twen0_10 twen1_10 vddce_10 vddp_10 vddpe_10
+  vnwp_10 vpw_10 vss_10 vss_ast0_10 vss_ast1_10 vsse_10 wa_en wablm0 wablm1
+  wen0_10 wen1_10 wen_lat0_10 wen_lat0_term_10 wen_lat1_10 wen_lat1_term_10
+  weny0_10 weny1_10 sram128x46wa_nbl_cm2
xr_ast_2 cap_ctrl00_2 cap_ctrl00_term_15 cap_ctrl01_2 cap_ctrl01_term_17
+  cap_ctrl02_2 cap_ctrl02_term_19 cap_ctrl10_2 cap_ctrl10_term_2 cap_ctrl11_2
+  cap_ctrl11_term_2 cap_ctrl12_2 cap_ctrl12_term_2 d0_2 d1_2 q0_2 q1_2 td0_2
+  td1_2 twen0_2 twen1_2 vddce_2 vddp_2 vddpe_2 vnwp_2 vpw_2 vss_2 vss_ast0_2
+  vss_ast1_2 vsse_2 wa_en wablm0 wablm1 wen0_2 wen1_2 wen_lat0_2
+  wen_lat0_term_2 wen_lat1_2 wen_lat1_term_2 weny0_2 weny1_2
+  sram128x46wa_nbl_cm2
xr_ast_3 cap_ctrl00_3 cap_ctrl00_term_21 cap_ctrl01_3 cap_ctrl01_term_23
+  cap_ctrl02_3 cap_ctrl02_term_25 cap_ctrl10_3 cap_ctrl10_term_3 cap_ctrl11_3
+  cap_ctrl11_term_3 cap_ctrl12_3 cap_ctrl12_term_3 d0_3 d1_3 q0_3 q1_3 td0_3
+  td1_3 twen0_3 twen1_3 vddce_3 vddp_3 vddpe_3 vnwp_3 vpw_3 vss_3 vss_ast0_3
+  vss_ast1_3 vsse_3 wa_en wablm0 wablm1 wen0_3 wen1_3 wen_lat0_3
+  wen_lat0_term_3 wen_lat1_3 wen_lat1_term_3 weny0_3 weny1_3
+  sram128x46wa_nbl_cm2
xr_ast_4 cap_ctrl00_4 cap_ctrl00_term_27 cap_ctrl01_4 cap_ctrl01_term_29
+  cap_ctrl02_4 cap_ctrl02_term_31 cap_ctrl10_4 cap_ctrl10_term_4 cap_ctrl11_4
+  cap_ctrl11_term_4 cap_ctrl12_4 cap_ctrl12_term_4 d0_4 d1_4 q0_4 q1_4 td0_4
+  td1_4 twen0_4 twen1_4 vddce_4 vddp_4 vddpe_4 vnwp_4 vpw_4 vss_4 vss_ast0_4
+  vss_ast1_4 vsse_4 wa_en wablm0 wablm1 wen0_4 wen1_4 wen_lat0_4
+  wen_lat0_term_4 wen_lat1_4 wen_lat1_term_4 weny0_4 weny1_4
+  sram128x46wa_nbl_cm2
xr_ast_5 cap_ctrl00_5 cap_ctrl00_term_33 cap_ctrl01_5 cap_ctrl01_term_35
+  cap_ctrl02_5 cap_ctrl02_term_37 cap_ctrl10_5 cap_ctrl10_term_5 cap_ctrl11_5
+  cap_ctrl11_term_5 cap_ctrl12_5 cap_ctrl12_term_5 d0_5 d1_5 q0_5 q1_5 td0_5
+  td1_5 twen0_5 twen1_5 vddce_5 vddp_5 vddpe_5 vnwp_5 vpw_5 vss_5 vss_ast0_5
+  vss_ast1_5 vsse_5 wa_en wablm0 wablm1 wen0_5 wen1_5 wen_lat0_5
+  wen_lat0_term_5 wen_lat1_5 wen_lat1_term_5 weny0_5 weny1_5
+  sram128x46wa_nbl_cm2
xr_ast_6 cap_ctrl00_6 cap_ctrl00_term_39 cap_ctrl01_6 cap_ctrl01_term_41
+  cap_ctrl02_6 cap_ctrl02_term_43 cap_ctrl10_6 cap_ctrl10_term_6 cap_ctrl11_6
+  cap_ctrl11_term_6 cap_ctrl12_6 cap_ctrl12_term_6 d0_6 d1_6 q0_6 q1_6 td0_6
+  td1_6 twen0_6 twen1_6 vddce_6 vddp_6 vddpe_6 vnwp_6 vpw_6 vss_6 vss_ast0_6
+  vss_ast1_6 vsse_6 wa_en wablm0 wablm1 wen0_6 wen1_6 wen_lat0_6
+  wen_lat0_term_6 wen_lat1_6 wen_lat1_term_6 weny0_6 weny1_6
+  sram128x46wa_nbl_cm2
xr_ast_7 cap_ctrl00_7 cap_ctrl00_term_45 cap_ctrl01_7 cap_ctrl01_term_47
+  cap_ctrl02_7 cap_ctrl02_term_49 cap_ctrl10_7 cap_ctrl10_term_7 cap_ctrl11_7
+  cap_ctrl11_term_7 cap_ctrl12_7 cap_ctrl12_term_7 d0_7 d1_7 q0_7 q1_7 td0_7
+  td1_7 twen0_7 twen1_7 vddce_7 vddp_7 vddpe_7 vnwp_7 vpw_7 vss_7 vss_ast0_7
+  vss_ast1_7 vsse_7 wa_en wablm0 wablm1 wen0_7 wen1_7 wen_lat0_7
+  wen_lat0_term_7 wen_lat1_7 wen_lat1_term_7 weny0_7 weny1_7
+  sram128x46wa_nbl_cm2
xr_ast_8 cap_ctrl00_8 cap_ctrl00_term_51 cap_ctrl01_8 cap_ctrl01_term_53
+  cap_ctrl02_8 cap_ctrl02_term_55 cap_ctrl10_8 cap_ctrl10_term_8 cap_ctrl11_8
+  cap_ctrl11_term_8 cap_ctrl12_8 cap_ctrl12_term_8 d0_8 d1_8 q0_8 q1_8 td0_8
+  td1_8 twen0_8 twen1_8 vddce_8 vddp_8 vddpe_8 vnwp_8 vpw_8 vss_8 vss_ast0_8
+  vss_ast1_8 vsse_8 wa_en wablm0 wablm1 wen0_8 wen1_8 wen_lat0_8
+  wen_lat0_term_8 wen_lat1_8 wen_lat1_term_8 weny0_8 weny1_8
+  sram128x46wa_nbl_cm2
xr_ast_9 cap_ctrl00_9 cap_ctrl00_term_57 cap_ctrl01_9 cap_ctrl01_term_59
+  cap_ctrl02_9 cap_ctrl02_term_61 cap_ctrl10_9 cap_ctrl10_term_9 cap_ctrl11_9
+  cap_ctrl11_term_9 cap_ctrl12_9 cap_ctrl12_term_9 d0_9 d1_9 q0_9 q1_9 td0_9
+  td1_9 twen0_9 twen1_9 vddce_9 vddp_9 vddpe_9 vnwp_9 vpw_9 vss_9 vss_ast0_9
+  vss_ast1_9 vsse_9 wa_en wablm0 wablm1 wen0_9 wen1_9 wen_lat0_9
+  wen_lat0_term_9 wen_lat1_9 wen_lat1_term_9 weny0_9 weny1_9
+  sram128x46wa_nbl_cm2
xr_ast_l cap_ctrl00_0 cap_ctrl00_term cap_ctrl01_0 cap_ctrl01_term
+  cap_ctrl02_0 cap_ctrl02_term cap_ctrl10_0 cap_ctrl10_term_0 cap_ctrl11_0
+  cap_ctrl11_term_0 cap_ctrl12_0 cap_ctrl12_term_0 d0_0 d1_0 q0_0 q1_0 td0_0
+  td1_0 twen0_0 twen1_0 vddce_0 vddp_0 vddpe_0 vnwp_0 vpw_0 vss_0 vss_ast0_0
+  vss_ast1_0 vsse_0 wa_en wablm0 wablm1 wen0_0 wen1_0 wen_lat0_0
+  wen_lat0_term_0 wen_lat1_0 wen_lat1_term_0 weny0_0 weny1_0
+  sram128x46wa_nbl_cm2
xr_ast_r cap_ctrl00_11 cap_ctrl00_term_9 cap_ctrl01_11 cap_ctrl01_term_11
+  cap_ctrl02_11 cap_ctrl02_term_13 cap_ctrl10_11 cap_ctrl10_term_11
+  cap_ctrl11_11 cap_ctrl11_term_11 cap_ctrl12_11 cap_ctrl12_term_11 d0_11
+  d1_11 q0_11 q1_11 td0_11 td1_11 twen0_11 twen1_11 vddce_11 vddp_11 vddpe_11
+  vnwp_11 vpw_11 vss_11 vss_ast0_11 vss_ast1_11 vsse_11 wa_en wablm0 wablm1
+  wen0_11 wen1_11 wen_lat0_11 wen_lat0_term_11 wen_lat1_11 wen_lat1_term_11
+  weny0_11 weny1_11 sram128x46wa_nbl_cm2
.ends sram128x46nbl_r
****
.subckt sram128x46ast_row_r vnwp_12 si psi wen_lat1_11 wen_lat0_11
+  cap_ctrl10_term_11 cap_ctrl11_term_11 cap_ctrl12_term_11 vddpe_10 d1_10
+  twen1_10 weny1_10 wen_lat1_10 vss_ast1_10 wen_lat0_10 vss_ast0_10 twen0_10
+  vddp_10 vsse_10 vss_10 vpw_10 cap_ctrl10_term_10 cap_ctrl11_term_10
+  cap_ctrl12_term_10 d1_9 wen1_9 twen1_9 weny1_9 wen_lat1_9 vss_ast1_9
+  wen_lat0_9 vss_ast0_9 weny0_9 twen0_9 d0_9 vddpe_9 vddp_9 vsse_9 vss_9
+  vpw_9 cap_ctrl10_term_9 cap_ctrl11_term_9 cap_ctrl12_term_9 q1_8 d1_8 td1_8
+  wen1_8 twen1_8 weny1_8 wen_lat1_8 vss_ast1_8 wen_lat0_8 vss_ast0_8 weny0_8
+  twen0_8 wen0_8 td0_8 d0_8 vddpe_8 vddce_8 vddp_8 vsse_8 vss_8 vpw_8 vnwp_8
+  cap_ctrl10_term_8 cap_ctrl11_term_8 cap_ctrl12_term_8 q1_7 d1_7 td1_7
+  wen1_7 twen1_7 weny1_7 wen_lat1_7 vss_ast1_7 wen_lat0_7 vss_ast0_7 weny0_7
+  twen0_7 wen0_7 td0_7 d0_7 vddpe_7 vddce_7 vddp_7 vsse_7 vss_7 vpw_7 vnwp_7
+  q0_7 cap_ctrl10_term_7 cap_ctrl11_term_7 cap_ctrl12_term_7 q1_6 d1_6 td1_6
+  wen1_6 weny1_6 wen_lat1_6 wen_lat0_6 vss_ast0_6 weny0_6 twen0_6 wen0_6
+  td0_6 d0_6 vddpe_6 vddce_6 vddp_6 vsse_6 vss_6 vpw_6 cap_ctrl10_term_6
+  cap_ctrl11_term_6 cap_ctrl12_term_6 d1_5 td1_5 wen1_5 twen1_5 weny1_5
+  wen_lat1_5 vss_ast1_5 wen_lat0_5 vss_ast0_5 weny0_5 twen0_5 wen0_5 td0_5
+  d0_5 vddpe_5 vddce_5 vddp_5 vsse_5 vss_5 vpw_5 vnwp_5 cap_ctrl10_term_5
+  cap_ctrl11_term_5 cap_ctrl12_term_5 q1_4 vpw_4 d1_4 td1_4 wen1_4 twen1_4
+  weny1_4 wen_lat1_4 vss_ast1_4 wen_lat0_4 vss_ast0_4 weny0_4 twen0_4 wen0_4
+  td0_4 d0_4 vddpe_4 vddce_4 vddp_4 vsse_4 vss_4 vnwp_4 q0_4
+  cap_ctrl10_term_4 cap_ctrl11_term_4 cap_ctrl12_term_4 q1_3 vss_3 d1_3 td1_3
+  wen1_3 weny1_3 wen_lat1_3 wen_lat0_3 vss_ast0_3 weny0_3 twen0_3 wen0_3
+  td0_3 d0_3 vpw_3 cap_ctrl10_term_3 cap_ctrl11_term_3 cap_ctrl12_term_3
+  vss_2 vsse_2 d1_2 td1_2 wen1_2 twen1_2 weny1_2 wen_lat1_2 vss_ast1_2
+  wen_lat0_2 vss_ast0_2 weny0_2 twen0_2 wen0_2 td0_2 d0_2 vddpe_2 vddce_2
+  vddp_2 vnwp_2 q0_2 cap_ctrl10_term_2 cap_ctrl11_term_2 cap_ctrl12_term_2
+  q1_1 d1_1 td1_1 wen1_1 weny1_1 wen_lat1_1 wen_lat0_1 vss_ast0_1 weny0_1
+  twen0_1 wen0_1 td0_1 d0_1 vddpe_1 vddce_1 vddp_1 vsse_1 vpw_1 vnwp_1 q0_1
+  cap_ctrl10_term_1 cap_ctrl11_term_1 cap_ctrl12_term_1 q1_0 d1_0 td1_0
+  wen1_0 weny1_0 wen_lat1_0 wen_lat0_0 vss_ast0_0 vss_0 vpw_0
+  cap_ctrl10_term_0 cap_ctrl11_term_0 cap_ctrl12_term_0 vsse_12 vnwc vpw_12
+  q1_11 vpw_11 cap_ctrl00_11 cap_ctrl01_11 cap_ctrl02_11 d1_11 td1_11 wen1_11
+  twen1_11 weny1_11 wen_lat1_term_11 vss_ast1_11 wen_lat0_term_11 vss_ast0_11
+  weny0_11 twen0_11 wen0_11 td0_11 d0_11 vddpe_11 vddce_11 vddp_11 vsse_11
+  vss_11 vnwp_11 q0_11 cap_ctrl10_11 cap_ctrl11_11 cap_ctrl12_11 q1_10
+  cap_ctrl00_10 cap_ctrl01_10 cap_ctrl02_10 td1_10 wen1_10 wen_lat1_term_10
+  wen_lat0_term_10 weny0_10 wen0_10 td0_10 d0_10 vddce_10 vnwp_10 q0_10
+  cap_ctrl10_10 cap_ctrl11_10 cap_ctrl12_10 q1_9 cap_ctrl00_9 cap_ctrl01_9
+  cap_ctrl02_9 td1_9 wen_lat1_term_9 wen_lat0_term_9 wen0_9 td0_9 vddce_9
+  vnwp_9 q0_9 cap_ctrl10_9 cap_ctrl11_9 cap_ctrl12_9 cap_ctrl00_8
+  cap_ctrl01_8 cap_ctrl02_8 wen_lat1_term_8 wen_lat0_term_8 q0_8 cap_ctrl10_8
+  cap_ctrl11_8 cap_ctrl12_8 cap_ctrl00_7 cap_ctrl01_7 cap_ctrl02_7
+  wen_lat1_term_7 wen_lat0_term_7 cap_ctrl10_7 cap_ctrl11_7 cap_ctrl12_7
+  cap_ctrl00_6 cap_ctrl01_6 cap_ctrl02_6 twen1_6 wen_lat1_term_6 vss_ast1_6
+  wen_lat0_term_6 vnwp_6 q0_6 cap_ctrl10_6 cap_ctrl11_6 cap_ctrl12_6 q1_5
+  cap_ctrl00_5 cap_ctrl01_5 cap_ctrl02_5 wen_lat1_term_5 wen_lat0_term_5 q0_5
+  cap_ctrl10_5 cap_ctrl11_5 cap_ctrl12_5 cap_ctrl00_4 cap_ctrl01_4
+  cap_ctrl02_4 wen_lat1_term_4 wen_lat0_term_4 cap_ctrl10_4 cap_ctrl11_4
+  cap_ctrl12_4 cap_ctrl00_3 cap_ctrl01_3 cap_ctrl02_3 twen1_3 wen_lat1_term_3
+  vss_ast1_3 wen_lat0_term_3 vddpe_3 vddce_3 vddp_3 vsse_3 vnwp_3 q0_3
+  cap_ctrl10_3 cap_ctrl11_3 cap_ctrl12_3 q1_2 vpw_2 cap_ctrl00_2 cap_ctrl01_2
+  cap_ctrl02_2 wen_lat1_term_2 wen_lat0_term_2 cap_ctrl10_2 cap_ctrl11_2
+  cap_ctrl12_2 vss_1 cap_ctrl00_1 cap_ctrl01_1 cap_ctrl02_1 twen1_1
+  wen_lat1_term_1 vss_ast1_1 wen_lat0_term_1 cap_ctrl10_1 cap_ctrl11_1
+  cap_ctrl12_1 vsse_0 cap_ctrl00_0 cap_ctrl01_0 cap_ctrl02_0 twen1_0
+  wen_lat1_term_0 vss_ast1_0 wen_lat0_term_0 weny0_0 twen0_0 wen0_0 td0_0
+  d0_0 vddpe_0 vddce_0 vddp_0 vnwp_0 q0_0 cap_ctrl10_0 cap_ctrl11_0
+  cap_ctrl12_0 wablm0 wa_en wablm1
** sram128x46ast_row_r: 384 flat devices **
xast_cdm_row_r wen_lat1_11 wen_lat0_11 cap_ctrl10_term_11 cap_ctrl11_term_11
+  cap_ctrl12_term_11 twen1_10 weny1_10 wen_lat1_10 vss_ast1_10 wen_lat0_10
+  vss_ast0_10 twen0_10 vddp_10 vsse_10 vss_10 vpw_10 cap_ctrl10_term_10
+  cap_ctrl11_term_10 cap_ctrl12_term_10 d1_9 wen1_9 twen1_9 weny1_9
+  wen_lat1_9 vss_ast1_9 wen_lat0_9 vss_ast0_9 weny0_9 twen0_9 vddpe_9 vddp_9
+  vsse_9 vss_9 vpw_9 cap_ctrl10_term_9 cap_ctrl11_term_9 cap_ctrl12_term_9
+  d1_8 td1_8 wen1_8 twen1_8 weny1_8 wen_lat1_8 vss_ast1_8 wen_lat0_8
+  vss_ast0_8 weny0_8 twen0_8 wen0_8 td0_8 vddce_8 vddp_8 cap_ctrl10_term_8
+  cap_ctrl11_term_8 cap_ctrl12_term_8 q1_7 d1_7 td1_7 wen1_7 twen1_7 weny1_7
+  wen_lat1_7 vss_ast1_7 wen_lat0_7 vss_ast0_7 weny0_7 twen0_7 wen0_7 td0_7
+  d0_7 vddpe_7 vddce_7 vddp_7 vsse_7 vss_7 vpw_7 vnwp_7 cap_ctrl10_term_7
+  cap_ctrl11_term_7 cap_ctrl12_term_7 q1_6 vpw_6 d1_6 td1_6 wen1_6 twen1_6
+  weny1_6 wen_lat1_6 vss_ast1_6 wen_lat0_6 vss_ast0_6 weny0_6 twen0_6 wen0_6
+  td0_6 d0_6 vddpe_6 vddce_6 vddp_6 vsse_6 vss_6 vnwp_6 q0_6
+  cap_ctrl10_term_6 cap_ctrl11_term_6 cap_ctrl12_term_6 q1_5 vpw_5 vss_5
+  td1_5 wen1_5 twen1_5 weny1_5 wen_lat1_5 vss_ast1_5 wen_lat0_5 vss_ast0_5
+  weny0_5 twen0_5 wen0_5 td0_5 d0_5 vddpe_5 vddce_5 vddp_5 vsse_5 vnwp_5
+  cap_ctrl10_term_5 cap_ctrl11_term_5 cap_ctrl12_term_5 q1_4 d1_4 td1_4
+  wen1_4 twen1_4 weny1_4 wen_lat1_4 vss_ast1_4 wen_lat0_4 vss_ast0_4 weny0_4
+  twen0_4 wen0_4 td0_4 d0_4 vddpe_4 vddce_4 vddp_4 vsse_4 vss_4 vnwp_4 q0_4
+  cap_ctrl10_term_4 cap_ctrl11_term_4 cap_ctrl12_term_4 q1_3 vss_3 d1_3 td1_3
+  wen1_3 weny1_3 wen_lat1_3 wen_lat0_3 vss_ast0_3 weny0_3 twen0_3 wen0_3
+  td0_3 d0_3 vddpe_3 vddce_3 vddp_3 vsse_3 vpw_3 vnwp_3 q0_3
+  cap_ctrl10_term_3 cap_ctrl11_term_3 cap_ctrl12_term_3 q1_2 vpw_2 vss_2
+  vsse_2 twen1_2 wen_lat1_2 vss_ast1_2 wen_lat0_2 vss_ast0_2 weny0_2 twen0_2
+  wen0_2 td0_2 d0_2 vddpe_2 vddce_2 vddp_2 vnwp_2 cap_ctrl10_term_2
+  cap_ctrl11_term_2 cap_ctrl12_term_2 q1_1 vpw_1 d1_1 td1_1 wen1_1 weny1_1
+  wen_lat1_1 wen_lat0_1 vss_ast0_1 weny0_1 twen0_1 wen0_1 td0_1 d0_1 vddpe_1
+  vddce_1 vddp_1 vsse_1 vss_1 vnwp_1 q0_1 cap_ctrl10_term_1 cap_ctrl11_term_1
+  cap_ctrl12_term_1 q1_0 vss_0 d1_0 td1_0 wen1_0 weny1_0 wen_lat1_0
+  wen_lat0_0 vss_ast0_0 weny0_0 twen0_0 wen0_0 td0_0 d0_0 vddpe_0 vddce_0
+  vddp_0 vpw_0 vnwp_0 cap_ctrl10_term_0 cap_ctrl11_term_0 cap_ctrl12_term_0
+  q1_11 cap_ctrl00_11 cap_ctrl01_11 cap_ctrl02_11 d1_11 td1_11 wen1_11
+  twen1_11 weny1_11 wen_lat1_term_11 vss_ast1_11 wen_lat0_term_11 vss_ast0_11
+  weny0_11 twen0_11 wen0_11 td0_11 d0_11 vddpe_11 vddce_11 vddp_11 vsse_11
+  vss_11 vpw_11 vnwp_11 q0_11 cap_ctrl10_11 cap_ctrl11_11 cap_ctrl12_11 q1_10
+  cap_ctrl00_10 cap_ctrl01_10 cap_ctrl02_10 d1_10 td1_10 wen1_10
+  wen_lat1_term_10 wen_lat0_term_10 weny0_10 wen0_10 td0_10 d0_10 vddpe_10
+  vddce_10 vnwp_10 q0_10 cap_ctrl10_10 cap_ctrl11_10 cap_ctrl12_10 q1_9
+  cap_ctrl00_9 cap_ctrl01_9 cap_ctrl02_9 td1_9 wen_lat1_term_9
+  wen_lat0_term_9 wen0_9 td0_9 d0_9 vddce_9 vnwp_9 q0_9 cap_ctrl10_9
+  cap_ctrl11_9 cap_ctrl12_9 q1_8 vpw_8 cap_ctrl00_8 cap_ctrl01_8 cap_ctrl02_8
+  wen_lat1_term_8 wen_lat0_term_8 d0_8 vddpe_8 vsse_8 vss_8 vnwp_8 q0_8
+  cap_ctrl10_8 cap_ctrl11_8 cap_ctrl12_8 cap_ctrl00_7 cap_ctrl01_7
+  cap_ctrl02_7 wen_lat1_term_7 wen_lat0_term_7 q0_7 cap_ctrl10_7 cap_ctrl11_7
+  cap_ctrl12_7 cap_ctrl00_6 cap_ctrl01_6 cap_ctrl02_6 wen_lat1_term_6
+  wen_lat0_term_6 cap_ctrl10_6 cap_ctrl11_6 cap_ctrl12_6 cap_ctrl00_5
+  cap_ctrl01_5 cap_ctrl02_5 d1_5 wen_lat1_term_5 wen_lat0_term_5 q0_5
+  cap_ctrl10_5 cap_ctrl11_5 cap_ctrl12_5 vpw_4 cap_ctrl00_4 cap_ctrl01_4
+  cap_ctrl02_4 wen_lat1_term_4 wen_lat0_term_4 cap_ctrl10_4 cap_ctrl11_4
+  cap_ctrl12_4 cap_ctrl00_3 cap_ctrl01_3 cap_ctrl02_3 twen1_3 wen_lat1_term_3
+  vss_ast1_3 wen_lat0_term_3 cap_ctrl10_3 cap_ctrl11_3 cap_ctrl12_3
+  cap_ctrl00_2 cap_ctrl01_2 cap_ctrl02_2 d1_2 td1_2 wen1_2 weny1_2
+  wen_lat1_term_2 wen_lat0_term_2 q0_2 cap_ctrl10_2 cap_ctrl11_2 cap_ctrl12_2
+  cap_ctrl00_1 cap_ctrl01_1 cap_ctrl02_1 twen1_1 wen_lat1_term_1 vss_ast1_1
+  wen_lat0_term_1 cap_ctrl10_1 cap_ctrl11_1 cap_ctrl12_1 vsse_0 cap_ctrl00_0
+  cap_ctrl01_0 cap_ctrl02_0 twen1_0 wen_lat1_term_0 vss_ast1_0
+  wen_lat0_term_0 q0_0 cap_ctrl10_0 cap_ctrl11_0 cap_ctrl12_0 wablm0 wa_en
+  wablm1 sram128x46nbl_r
.ends sram128x46ast_row_r
****
.subckt sram128x46nbl_l cap_ctrl12_term_10 cap_ctrl11_term_10
+  cap_ctrl10_term_10 wen_lat0_10 wen_lat1_10 cap_ctrl12_term_9
+  cap_ctrl11_term_9 cap_ctrl10_term_9 vpw_9 vss_9 vddp_9 td0_9 vss_ast0_9
+  wen_lat0_9 vss_ast1_9 wen_lat1_9 weny1_9 d1_9 vddpe_9 vsse_9
+  cap_ctrl12_term_8 cap_ctrl11_term_8 cap_ctrl10_term_8 q0_8 vpw_8 vss_8
+  vsse_8 vddpe_8 weny0_8 vss_ast0_8 wen_lat0_8 vss_ast1_8 wen_lat1_8 weny1_8
+  twen1_8 wen1_8 d1_8 cap_ctrl12_term_7 cap_ctrl11_term_7 cap_ctrl10_term_7
+  vnwp_7 vss_7 vsse_7 vddp_7 vddce_7 vddpe_7 td0_7 wen0_7 twen0_7 weny0_7
+  vss_ast0_7 wen_lat0_7 vss_ast1_7 wen_lat1_7 weny1_7 twen1_7 wen1_7 td1_7
+  d1_7 q1_7 cap_ctrl12_term_6 cap_ctrl11_term_6 cap_ctrl10_term_6 vnwp_6
+  vss_6 vsse_6 vddp_6 vddce_6 d0_6 td0_6 wen0_6 twen0_6 weny0_6 vss_ast0_6
+  wen_lat0_6 vss_ast1_6 wen_lat1_6 weny1_6 twen1_6 wen1_6 td1_6 d1_6 vpw_6
+  q1_6 cap_ctrl12_term_5 cap_ctrl11_term_5 cap_ctrl10_term_5 q0_5 vddp_5
+  vddce_5 d0_5 td0_5 wen0_5 twen0_5 weny0_5 vss_ast0_5 wen_lat0_5 vss_ast1_5
+  wen_lat1_5 weny1_5 twen1_5 wen1_5 td1_5 d1_5 vss_5 q1_5 cap_ctrl12_term_4
+  cap_ctrl11_term_4 cap_ctrl10_term_4 q0_4 vpw_4 vddp_4 vddce_4 vddpe_4 d0_4
+  td0_4 wen0_4 twen0_4 weny0_4 vss_ast0_4 wen_lat0_4 wen_lat1_4 weny1_4
+  wen1_4 td1_4 d1_4 q1_4 cap_ctrl12_term_3 cap_ctrl11_term_3
+  cap_ctrl10_term_3 vddp_3 vddce_3 d0_3 td0_3 wen0_3 twen0_3 weny0_3
+  vss_ast0_3 wen_lat0_3 vss_ast1_3 wen_lat1_3 weny1_3 twen1_3 wen1_3 td1_3
+  d1_3 vpw_3 q1_3 cap_ctrl12_term_2 cap_ctrl11_term_2 cap_ctrl10_term_2 q0_2
+  vddp_2 vddce_2 d0_2 td0_2 wen0_2 twen0_2 weny0_2 vss_ast0_2 wen_lat0_2
+  vss_ast1_2 wen_lat1_2 weny1_2 twen1_2 wen1_2 td1_2 d1_2 q1_2
+  cap_ctrl12_term_1 cap_ctrl11_term_1 cap_ctrl10_term_1 q0_1 vddp_1 d0_1
+  td0_1 wen0_1 twen0_1 weny0_1 vss_ast0_1 wen_lat0_1 wen_lat1_1 weny1_1
+  wen1_1 td1_1 d1_1 vddpe_1 vpw_1 vddce_1 q1_1 cap_ctrl12_term_0
+  cap_ctrl11_term_0 cap_ctrl10_term_0 q0_0 vddp_0 vddce_0 d0_0 td0_0 wen0_0
+  twen0_0 weny0_0 vss_ast0_0 wen_lat0_0 vss_ast1_0 wen_lat1_0 weny1_0 twen1_0
+  wen1_0 td1_0 d1_0 vss_0 q1_0 cap_ctrl12_10 cap_ctrl11_10 cap_ctrl10_10
+  q0_10 vnwp_10 vpw_10 vss_10 vsse_10 vddp_10 vddce_10 vddpe_10 d0_10 td0_10
+  wen0_10 twen0_10 weny0_10 vss_ast0_10 wen_lat0_term_10 vss_ast1_10
+  wen_lat1_term_10 weny1_10 twen1_10 wen1_10 td1_10 d1_10 cap_ctrl02_10
+  cap_ctrl01_10 cap_ctrl00_10 q1_10 cap_ctrl12_9 cap_ctrl11_9 cap_ctrl10_9
+  q0_9 vddce_9 d0_9 wen0_9 twen0_9 weny0_9 wen_lat0_term_9 wen_lat1_term_9
+  twen1_9 wen1_9 td1_9 cap_ctrl02_9 cap_ctrl01_9 cap_ctrl00_9 vnwp_9 q1_9
+  cap_ctrl12_8 cap_ctrl11_8 cap_ctrl10_8 vnwp_8 vddp_8 vddce_8 d0_8 td0_8
+  wen0_8 twen0_8 wen_lat0_term_8 wen_lat1_term_8 td1_8 cap_ctrl02_8
+  cap_ctrl01_8 cap_ctrl00_8 q1_8 cap_ctrl12_7 cap_ctrl11_7 cap_ctrl10_7 q0_7
+  d0_7 wen_lat0_term_7 wen_lat1_term_7 cap_ctrl02_7 cap_ctrl01_7 cap_ctrl00_7
+  vpw_7 cap_ctrl12_6 cap_ctrl11_6 cap_ctrl10_6 q0_6 vddpe_6 wen_lat0_term_6
+  wen_lat1_term_6 cap_ctrl02_6 cap_ctrl01_6 cap_ctrl00_6 cap_ctrl12_5
+  cap_ctrl11_5 cap_ctrl10_5 vnwp_5 vsse_5 vddpe_5 wen_lat0_term_5
+  wen_lat1_term_5 cap_ctrl02_5 cap_ctrl01_5 cap_ctrl00_5 vpw_5 cap_ctrl12_4
+  cap_ctrl11_4 cap_ctrl10_4 vnwp_4 vsse_4 wen_lat0_term_4 vss_ast1_4
+  wen_lat1_term_4 twen1_4 cap_ctrl02_4 cap_ctrl01_4 cap_ctrl00_4 vss_4
+  cap_ctrl12_3 cap_ctrl11_3 cap_ctrl10_3 q0_3 vnwp_3 vss_3 vsse_3 vddpe_3
+  wen_lat0_term_3 wen_lat1_term_3 cap_ctrl02_3 cap_ctrl01_3 cap_ctrl00_3
+  cap_ctrl12_2 cap_ctrl11_2 cap_ctrl10_2 vnwp_2 vsse_2 vddpe_2
+  wen_lat0_term_2 wen_lat1_term_2 cap_ctrl02_2 cap_ctrl01_2 cap_ctrl00_2
+  vss_2 vpw_2 cap_ctrl12_1 cap_ctrl11_1 cap_ctrl10_1 vnwp_1 wen_lat0_term_1
+  vss_ast1_1 wen_lat1_term_1 twen1_1 cap_ctrl02_1 cap_ctrl01_1 cap_ctrl00_1
+  vsse_1 vss_1 cap_ctrl12_0 cap_ctrl11_0 cap_ctrl10_0 vnwp_0 vsse_0 vddpe_0
+  wen_lat0_term_0 wen_lat1_term_0 cap_ctrl02_0 cap_ctrl01_0 cap_ctrl00_0
+  vpw_0 wablm0 wa_en wablm1
** sram128x46nbl_l: 352 flat devices **
xl_ast_1 cap_ctrl00_1 cap_ctrl00_term cap_ctrl01_1 cap_ctrl01_term
+  cap_ctrl02_1 cap_ctrl02_term cap_ctrl10_1 cap_ctrl10_term_1 cap_ctrl11_1
+  cap_ctrl11_term_1 cap_ctrl12_1 cap_ctrl12_term_1 d0_1 d1_1 q0_1 q1_1 td0_1
+  td1_1 twen0_1 twen1_1 vddce_1 vddp_1 vddpe_1 vnwp_1 vpw_1 vss_1 vss_ast0_1
+  vss_ast1_1 vsse_1 wa_en wablm0 wablm1 wen0_1 wen1_1 wen_lat0_1
+  wen_lat0_term_1 wen_lat1_1 wen_lat1_term_1 weny0_1 weny1_1
+  sram128x46wa_nbl_cm2
xl_ast_2 cap_ctrl00_2 cap_ctrl00_term_3 cap_ctrl01_2 cap_ctrl01_term_5
+  cap_ctrl02_2 cap_ctrl02_term_7 cap_ctrl10_2 cap_ctrl10_term_2 cap_ctrl11_2
+  cap_ctrl11_term_2 cap_ctrl12_2 cap_ctrl12_term_2 d0_2 d1_2 q0_2 q1_2 td0_2
+  td1_2 twen0_2 twen1_2 vddce_2 vddp_2 vddpe_2 vnwp_2 vpw_2 vss_2 vss_ast0_2
+  vss_ast1_2 vsse_2 wa_en wablm0 wablm1 wen0_2 wen1_2 wen_lat0_2
+  wen_lat0_term_2 wen_lat1_2 wen_lat1_term_2 weny0_2 weny1_2
+  sram128x46wa_nbl_cm2
xl_ast_3 cap_ctrl00_3 cap_ctrl00_term_15 cap_ctrl01_3 cap_ctrl01_term_17
+  cap_ctrl02_3 cap_ctrl02_term_19 cap_ctrl10_3 cap_ctrl10_term_3 cap_ctrl11_3
+  cap_ctrl11_term_3 cap_ctrl12_3 cap_ctrl12_term_3 d0_3 d1_3 q0_3 q1_3 td0_3
+  td1_3 twen0_3 twen1_3 vddce_3 vddp_3 vddpe_3 vnwp_3 vpw_3 vss_3 vss_ast0_3
+  vss_ast1_3 vsse_3 wa_en wablm0 wablm1 wen0_3 wen1_3 wen_lat0_3
+  wen_lat0_term_3 wen_lat1_3 wen_lat1_term_3 weny0_3 weny1_3
+  sram128x46wa_nbl_cm2
xl_ast_4 cap_ctrl00_4 cap_ctrl00_term_21 cap_ctrl01_4 cap_ctrl01_term_23
+  cap_ctrl02_4 cap_ctrl02_term_25 cap_ctrl10_4 cap_ctrl10_term_4 cap_ctrl11_4
+  cap_ctrl11_term_4 cap_ctrl12_4 cap_ctrl12_term_4 d0_4 d1_4 q0_4 q1_4 td0_4
+  td1_4 twen0_4 twen1_4 vddce_4 vddp_4 vddpe_4 vnwp_4 vpw_4 vss_4 vss_ast0_4
+  vss_ast1_4 vsse_4 wa_en wablm0 wablm1 wen0_4 wen1_4 wen_lat0_4
+  wen_lat0_term_4 wen_lat1_4 wen_lat1_term_4 weny0_4 weny1_4
+  sram128x46wa_nbl_cm2
xl_ast_5 cap_ctrl00_5 cap_ctrl00_term_27 cap_ctrl01_5 cap_ctrl01_term_29
+  cap_ctrl02_5 cap_ctrl02_term_31 cap_ctrl10_5 cap_ctrl10_term_5 cap_ctrl11_5
+  cap_ctrl11_term_5 cap_ctrl12_5 cap_ctrl12_term_5 d0_5 d1_5 q0_5 q1_5 td0_5
+  td1_5 twen0_5 twen1_5 vddce_5 vddp_5 vddpe_5 vnwp_5 vpw_5 vss_5 vss_ast0_5
+  vss_ast1_5 vsse_5 wa_en wablm0 wablm1 wen0_5 wen1_5 wen_lat0_5
+  wen_lat0_term_5 wen_lat1_5 wen_lat1_term_5 weny0_5 weny1_5
+  sram128x46wa_nbl_cm2
xl_ast_6 cap_ctrl00_6 cap_ctrl00_term_33 cap_ctrl01_6 cap_ctrl01_term_35
+  cap_ctrl02_6 cap_ctrl02_term_37 cap_ctrl10_6 cap_ctrl10_term_6 cap_ctrl11_6
+  cap_ctrl11_term_6 cap_ctrl12_6 cap_ctrl12_term_6 d0_6 d1_6 q0_6 q1_6 td0_6
+  td1_6 twen0_6 twen1_6 vddce_6 vddp_6 vddpe_6 vnwp_6 vpw_6 vss_6 vss_ast0_6
+  vss_ast1_6 vsse_6 wa_en wablm0 wablm1 wen0_6 wen1_6 wen_lat0_6
+  wen_lat0_term_6 wen_lat1_6 wen_lat1_term_6 weny0_6 weny1_6
+  sram128x46wa_nbl_cm2
xl_ast_7 cap_ctrl00_7 cap_ctrl00_term_39 cap_ctrl01_7 cap_ctrl01_term_41
+  cap_ctrl02_7 cap_ctrl02_term_43 cap_ctrl10_7 cap_ctrl10_term_7 cap_ctrl11_7
+  cap_ctrl11_term_7 cap_ctrl12_7 cap_ctrl12_term_7 d0_7 d1_7 q0_7 q1_7 td0_7
+  td1_7 twen0_7 twen1_7 vddce_7 vddp_7 vddpe_7 vnwp_7 vpw_7 vss_7 vss_ast0_7
+  vss_ast1_7 vsse_7 wa_en wablm0 wablm1 wen0_7 wen1_7 wen_lat0_7
+  wen_lat0_term_7 wen_lat1_7 wen_lat1_term_7 weny0_7 weny1_7
+  sram128x46wa_nbl_cm2
xl_ast_8 cap_ctrl00_8 cap_ctrl00_term_45 cap_ctrl01_8 cap_ctrl01_term_47
+  cap_ctrl02_8 cap_ctrl02_term_49 cap_ctrl10_8 cap_ctrl10_term_8 cap_ctrl11_8
+  cap_ctrl11_term_8 cap_ctrl12_8 cap_ctrl12_term_8 d0_8 d1_8 q0_8 q1_8 td0_8
+  td1_8 twen0_8 twen1_8 vddce_8 vddp_8 vddpe_8 vnwp_8 vpw_8 vss_8 vss_ast0_8
+  vss_ast1_8 vsse_8 wa_en wablm0 wablm1 wen0_8 wen1_8 wen_lat0_8
+  wen_lat0_term_8 wen_lat1_8 wen_lat1_term_8 weny0_8 weny1_8
+  sram128x46wa_nbl_cm2
xl_ast_9 cap_ctrl00_9 cap_ctrl00_term_51 cap_ctrl01_9 cap_ctrl01_term_53
+  cap_ctrl02_9 cap_ctrl02_term_55 cap_ctrl10_9 cap_ctrl10_term_9 cap_ctrl11_9
+  cap_ctrl11_term_9 cap_ctrl12_9 cap_ctrl12_term_9 d0_9 d1_9 q0_9 q1_9 td0_9
+  td1_9 twen0_9 twen1_9 vddce_9 vddp_9 vddpe_9 vnwp_9 vpw_9 vss_9 vss_ast0_9
+  vss_ast1_9 vsse_9 wa_en wablm0 wablm1 wen0_9 wen1_9 wen_lat0_9
+  wen_lat0_term_9 wen_lat1_9 wen_lat1_term_9 weny0_9 weny1_9
+  sram128x46wa_nbl_cm2
xl_ast_l cap_ctrl00_0 cap_ctrl00_term_57 cap_ctrl01_0 cap_ctrl01_term_59
+  cap_ctrl02_0 cap_ctrl02_term_61 cap_ctrl10_0 cap_ctrl10_term_0 cap_ctrl11_0
+  cap_ctrl11_term_0 cap_ctrl12_0 cap_ctrl12_term_0 d0_0 d1_0 q0_0 q1_0 td0_0
+  td1_0 twen0_0 twen1_0 vddce_0 vddp_0 vddpe_0 vnwp_0 vpw_0 vss_0 vss_ast0_0
+  vss_ast1_0 vsse_0 wa_en wablm0 wablm1 wen0_0 wen1_0 wen_lat0_0
+  wen_lat0_term_0 wen_lat1_0 wen_lat1_term_0 weny0_0 weny1_0
+  sram128x46wa_nbl_cm2
xl_ast_r cap_ctrl00_10 cap_ctrl00_term_9 cap_ctrl01_10 cap_ctrl01_term_11
+  cap_ctrl02_10 cap_ctrl02_term_13 cap_ctrl10_10 cap_ctrl10_term_10
+  cap_ctrl11_10 cap_ctrl11_term_10 cap_ctrl12_10 cap_ctrl12_term_10 d0_10
+  d1_10 q0_10 q1_10 td0_10 td1_10 twen0_10 twen1_10 vddce_10 vddp_10 vddpe_10
+  vnwp_10 vpw_10 vss_10 vss_ast0_10 vss_ast1_10 vsse_10 wa_en wablm0 wablm1
+  wen0_10 wen1_10 wen_lat0_10 wen_lat0_term_10 wen_lat1_10 wen_lat1_term_10
+  weny0_10 weny1_10 sram128x46wa_nbl_cm2
.ends sram128x46nbl_l
****
.subckt sram128x46ast_row_l cap_ctrl12_term_10 cap_ctrl11_term_10
+  cap_ctrl10_term_10 wen_lat0_10 wen_lat1_10 cap_ctrl12_term_9
+  cap_ctrl11_term_9 cap_ctrl10_term_9 vnwp_10 vpw_10 vss_9 vss_ast0_9
+  wen_lat0_9 vss_ast1_9 wen_lat1_9 weny1_9 twen1_9 d1_9 vddpe_9 vsse_10
+  cap_ctrl12_term_8 cap_ctrl11_term_8 cap_ctrl10_term_8 q0_8 vpw_9 vss_8
+  vsse_9 vddpe_8 twen0_8 weny0_8 vss_ast0_8 wen_lat0_8 vss_ast1_8 wen_lat1_8
+  weny1_8 twen1_8 wen1_8 d1_8 cap_ctrl12_term_7 cap_ctrl11_term_7
+  cap_ctrl10_term_7 vnwp_8 vss_7 vsse_8 vddp_7 vddce_7 vddpe_7 td0_7 wen0_7
+  twen0_7 weny0_7 vss_ast0_7 wen_lat0_7 vss_ast1_7 wen_lat1_7 weny1_7 twen1_7
+  wen1_7 td1_7 d1_7 q1_7 cap_ctrl12_term_6 cap_ctrl11_term_6
+  cap_ctrl10_term_6 q0_6 vddp_6 vddce_6 d0_6 td0_6 wen0_6 twen0_6 weny0_6
+  vss_ast0_6 wen_lat0_6 vss_ast1_6 wen_lat1_6 weny1_6 twen1_6 wen1_6 td1_6
+  d1_6 vpw_7 q1_6 cap_ctrl12_term_5 cap_ctrl11_term_5 cap_ctrl10_term_5 q0_5
+  vddp_5 vddce_5 d0_5 td0_5 wen0_5 twen0_5 weny0_5 vss_ast0_5 wen_lat0_5
+  vss_ast1_5 wen_lat1_5 weny1_5 twen1_5 wen1_5 td1_5 d1_5 vss_5 q1_5
+  cap_ctrl12_term_4 cap_ctrl11_term_4 cap_ctrl10_term_4 q0_4 vpw_5 vddp_4
+  vddce_4 vddpe_4 d0_4 td0_4 wen0_4 twen0_4 weny0_4 vss_ast0_4 wen_lat0_4
+  wen_lat1_4 weny1_4 wen1_4 td1_4 d1_4 vsse_5 q1_4 cap_ctrl12_term_3
+  cap_ctrl11_term_3 cap_ctrl10_term_3 vddp_3 vddce_3 d0_3 td0_3 wen0_3
+  twen0_3 weny0_3 vss_ast0_3 wen_lat0_3 vss_ast1_3 wen_lat1_3 weny1_3 twen1_3
+  wen1_3 td1_3 d1_3 q1_3 cap_ctrl12_term_2 cap_ctrl11_term_2
+  cap_ctrl10_term_2 q0_2 vddp_2 vddce_2 d0_2 td0_2 wen0_2 twen0_2 weny0_2
+  vss_ast0_2 wen_lat0_2 vss_ast1_2 wen_lat1_2 weny1_2 wen1_2 td1_2 d1_2 q1_2
+  cap_ctrl12_term_1 cap_ctrl11_term_1 cap_ctrl10_term_1 q0_1 vddp_1 d0_1
+  td0_1 wen0_1 twen0_1 weny0_1 vss_ast0_1 wen_lat0_1 wen_lat1_1 weny1_1
+  wen1_1 td1_1 d1_1 vddpe_1 vpw_2 vddce_1 q1_1 cap_ctrl12_term_0
+  cap_ctrl11_term_0 cap_ctrl10_term_0 q0_0 vddp_0 vddce_0 d0_0 td0_0 wen0_0
+  twen0_0 weny0_0 vss_ast0_0 wen_lat0_0 vss_ast1_0 wen_lat1_0 weny1_0 twen1_0
+  wen1_0 td1_0 d1_0 vss_0 q1_0 psi si vpw_0 cap_ctrl12_10 cap_ctrl11_10
+  cap_ctrl10_10 q0_10 vnwp_11 vpw_11 vss_10 vsse_11 vddp_10 vddce_10 vddpe_10
+  d0_10 td0_10 wen0_10 twen0_10 weny0_10 vss_ast0_10 wen_lat0_term_10
+  vss_ast1_10 wen_lat1_term_10 weny1_10 twen1_10 wen1_10 td1_10 d1_10
+  cap_ctrl02_10 cap_ctrl01_10 cap_ctrl00_10 q1_10 cap_ctrl12_9 cap_ctrl11_9
+  cap_ctrl10_9 q0_9 vddp_9 vddce_9 d0_9 td0_9 wen0_9 twen0_9 weny0_9
+  wen_lat0_term_9 wen_lat1_term_9 wen1_9 td1_9 cap_ctrl02_9 cap_ctrl01_9
+  cap_ctrl00_9 q1_9 cap_ctrl12_8 cap_ctrl11_8 cap_ctrl10_8 vnwp_9 vddp_8
+  vddce_8 d0_8 td0_8 wen0_8 wen_lat0_term_8 wen_lat1_term_8 td1_8
+  cap_ctrl02_8 cap_ctrl01_8 cap_ctrl00_8 q1_8 cap_ctrl12_7 cap_ctrl11_7
+  cap_ctrl10_7 q0_7 d0_7 wen_lat0_term_7 wen_lat1_term_7 cap_ctrl02_7
+  cap_ctrl01_7 cap_ctrl00_7 vpw_8 cap_ctrl12_6 cap_ctrl11_6 cap_ctrl10_6
+  vnwp_7 vss_6 vsse_7 vddpe_6 wen_lat0_term_6 wen_lat1_term_6 cap_ctrl02_6
+  cap_ctrl01_6 cap_ctrl00_6 cap_ctrl12_5 cap_ctrl11_5 cap_ctrl10_5 vnwp_6
+  vsse_6 vddpe_5 wen_lat0_term_5 wen_lat1_term_5 cap_ctrl02_5 cap_ctrl01_5
+  cap_ctrl00_5 vpw_6 cap_ctrl12_4 cap_ctrl11_4 cap_ctrl10_4 wen_lat0_term_4
+  vss_ast1_4 wen_lat1_term_4 twen1_4 cap_ctrl02_4 cap_ctrl01_4 cap_ctrl00_4
+  vss_4 vnwp_5 cap_ctrl12_3 cap_ctrl11_3 cap_ctrl10_3 q0_3 vnwp_4 vss_3
+  vsse_4 vddpe_3 wen_lat0_term_3 wen_lat1_term_3 cap_ctrl02_3 cap_ctrl01_3
+  cap_ctrl00_3 vpw_4 cap_ctrl12_2 cap_ctrl11_2 cap_ctrl10_2 vnwp_3 vsse_3
+  vddpe_2 wen_lat0_term_2 wen_lat1_term_2 twen1_2 cap_ctrl02_2 cap_ctrl01_2
+  cap_ctrl00_2 vss_2 vpw_3 cap_ctrl12_1 cap_ctrl11_1 cap_ctrl10_1
+  wen_lat0_term_1 vss_ast1_1 wen_lat1_term_1 twen1_1 cap_ctrl02_1
+  cap_ctrl01_1 cap_ctrl00_1 vsse_2 vss_1 vnwp_2 cap_ctrl12_0 cap_ctrl11_0
+  cap_ctrl10_0 vnwp_1 vsse_1 vddpe_0 wen_lat0_term_0 wen_lat1_term_0
+  cap_ctrl02_0 cap_ctrl01_0 cap_ctrl00_0 vpw_1 vnwc vnwp_0 vsse_0 wablm0
+  wa_en wablm1
** sram128x46ast_row_l: 352 flat devices **
xast_cdm_row_l cap_ctrl12_term_10 cap_ctrl11_term_10 cap_ctrl10_term_10
+  wen_lat0_10 wen_lat1_10 cap_ctrl12_term_9 cap_ctrl11_term_9
+  cap_ctrl10_term_9 vpw_10 vss_9 vddp_9 td0_9 vss_ast0_9 wen_lat0_9
+  vss_ast1_9 wen_lat1_9 weny1_9 d1_9 vddpe_9 vsse_10 cap_ctrl12_term_8
+  cap_ctrl11_term_8 cap_ctrl10_term_8 q0_8 vpw_9 vss_8 vsse_9 vddpe_8 weny0_8
+  vss_ast0_8 wen_lat0_8 vss_ast1_8 wen_lat1_8 weny1_8 twen1_8 wen1_8 d1_8
+  cap_ctrl12_term_7 cap_ctrl11_term_7 cap_ctrl10_term_7 vnwp_8 vss_7 vsse_8
+  vddp_7 vddce_7 vddpe_7 td0_7 wen0_7 twen0_7 weny0_7 vss_ast0_7 wen_lat0_7
+  vss_ast1_7 wen_lat1_7 weny1_7 twen1_7 wen1_7 td1_7 d1_7 q1_7
+  cap_ctrl12_term_6 cap_ctrl11_term_6 cap_ctrl10_term_6 vnwp_7 vss_6 vsse_7
+  vddp_6 vddce_6 d0_6 td0_6 wen0_6 twen0_6 weny0_6 vss_ast0_6 wen_lat0_6
+  vss_ast1_6 wen_lat1_6 weny1_6 twen1_6 wen1_6 td1_6 d1_6 vpw_7 q1_6
+  cap_ctrl12_term_5 cap_ctrl11_term_5 cap_ctrl10_term_5 q0_5 vddp_5 vddce_5
+  d0_5 td0_5 wen0_5 twen0_5 weny0_5 vss_ast0_5 wen_lat0_5 vss_ast1_5
+  wen_lat1_5 weny1_5 twen1_5 wen1_5 td1_5 d1_5 vss_5 q1_5 cap_ctrl12_term_4
+  cap_ctrl11_term_4 cap_ctrl10_term_4 q0_4 vpw_5 vddp_4 vddce_4 vddpe_4 d0_4
+  td0_4 wen0_4 twen0_4 weny0_4 vss_ast0_4 wen_lat0_4 wen_lat1_4 weny1_4
+  wen1_4 td1_4 d1_4 q1_4 cap_ctrl12_term_3 cap_ctrl11_term_3
+  cap_ctrl10_term_3 vddp_3 vddce_3 d0_3 td0_3 wen0_3 twen0_3 weny0_3
+  vss_ast0_3 wen_lat0_3 vss_ast1_3 wen_lat1_3 weny1_3 twen1_3 wen1_3 td1_3
+  d1_3 vpw_4 q1_3 cap_ctrl12_term_2 cap_ctrl11_term_2 cap_ctrl10_term_2 q0_2
+  vddp_2 vddce_2 d0_2 td0_2 wen0_2 twen0_2 weny0_2 vss_ast0_2 wen_lat0_2
+  vss_ast1_2 wen_lat1_2 weny1_2 twen1_2 wen1_2 td1_2 d1_2 q1_2
+  cap_ctrl12_term_1 cap_ctrl11_term_1 cap_ctrl10_term_1 q0_1 vddp_1 d0_1
+  td0_1 wen0_1 twen0_1 weny0_1 vss_ast0_1 wen_lat0_1 wen_lat1_1 weny1_1
+  wen1_1 td1_1 d1_1 vddpe_1 vpw_2 vddce_1 q1_1 cap_ctrl12_term_0
+  cap_ctrl11_term_0 cap_ctrl10_term_0 q0_0 vddp_0 vddce_0 d0_0 td0_0 wen0_0
+  twen0_0 weny0_0 vss_ast0_0 wen_lat0_0 vss_ast1_0 wen_lat1_0 weny1_0 twen1_0
+  wen1_0 td1_0 d1_0 vss_0 q1_0 cap_ctrl12_10 cap_ctrl11_10 cap_ctrl10_10
+  q0_10 vnwp_11 vpw_11 vss_10 vsse_11 vddp_10 vddce_10 vddpe_10 d0_10 td0_10
+  wen0_10 twen0_10 weny0_10 vss_ast0_10 wen_lat0_term_10 vss_ast1_10
+  wen_lat1_term_10 weny1_10 twen1_10 wen1_10 td1_10 d1_10 cap_ctrl02_10
+  cap_ctrl01_10 cap_ctrl00_10 q1_10 cap_ctrl12_9 cap_ctrl11_9 cap_ctrl10_9
+  q0_9 vddce_9 d0_9 wen0_9 twen0_9 weny0_9 wen_lat0_term_9 wen_lat1_term_9
+  twen1_9 wen1_9 td1_9 cap_ctrl02_9 cap_ctrl01_9 cap_ctrl00_9 vnwp_10 q1_9
+  cap_ctrl12_8 cap_ctrl11_8 cap_ctrl10_8 vnwp_9 vddp_8 vddce_8 d0_8 td0_8
+  wen0_8 twen0_8 wen_lat0_term_8 wen_lat1_term_8 td1_8 cap_ctrl02_8
+  cap_ctrl01_8 cap_ctrl00_8 q1_8 cap_ctrl12_7 cap_ctrl11_7 cap_ctrl10_7 q0_7
+  d0_7 wen_lat0_term_7 wen_lat1_term_7 cap_ctrl02_7 cap_ctrl01_7 cap_ctrl00_7
+  vpw_8 cap_ctrl12_6 cap_ctrl11_6 cap_ctrl10_6 q0_6 vddpe_6 wen_lat0_term_6
+  wen_lat1_term_6 cap_ctrl02_6 cap_ctrl01_6 cap_ctrl00_6 cap_ctrl12_5
+  cap_ctrl11_5 cap_ctrl10_5 vnwp_6 vsse_6 vddpe_5 wen_lat0_term_5
+  wen_lat1_term_5 cap_ctrl02_5 cap_ctrl01_5 cap_ctrl00_5 vpw_6 cap_ctrl12_4
+  cap_ctrl11_4 cap_ctrl10_4 vnwp_5 vsse_5 wen_lat0_term_4 vss_ast1_4
+  wen_lat1_term_4 twen1_4 cap_ctrl02_4 cap_ctrl01_4 cap_ctrl00_4 vss_4
+  cap_ctrl12_3 cap_ctrl11_3 cap_ctrl10_3 q0_3 vnwp_4 vss_3 vsse_4 vddpe_3
+  wen_lat0_term_3 wen_lat1_term_3 cap_ctrl02_3 cap_ctrl01_3 cap_ctrl00_3
+  cap_ctrl12_2 cap_ctrl11_2 cap_ctrl10_2 vnwp_3 vsse_3 vddpe_2
+  wen_lat0_term_2 wen_lat1_term_2 cap_ctrl02_2 cap_ctrl01_2 cap_ctrl00_2
+  vss_2 vpw_3 cap_ctrl12_1 cap_ctrl11_1 cap_ctrl10_1 vnwp_2 wen_lat0_term_1
+  vss_ast1_1 wen_lat1_term_1 twen1_1 cap_ctrl02_1 cap_ctrl01_1 cap_ctrl00_1
+  vsse_2 vss_1 cap_ctrl12_0 cap_ctrl11_0 cap_ctrl10_0 vnwp_1 vsse_1 vddpe_0
+  wen_lat0_term_0 wen_lat1_term_0 cap_ctrl02_0 cap_ctrl01_0 cap_ctrl00_0
+  vpw_1 wablm0 wa_en wablm1 sram128x46nbl_l
.ends sram128x46ast_row_l
****
.subckt sram128x46ast_slice vnwp_25 si_1 psi_1 wen_lat1_22 wen_lat0_22 vpw_24
+  cap_ctrl10_term_22 cap_ctrl11_term_22 cap_ctrl12_term_22 q1_21 vddpe_22
+  d1_21 td1_21 weny1_21 wen_lat1_21 wen_lat0_21 vss_ast0_21 twen0_21 td0_21
+  vddp_21 vsse_23 vnwp_23 cap_ctrl10_term_21 cap_ctrl11_term_21
+  cap_ctrl12_term_21 d1_20 td1_20 wen1_20 weny1_20 wen_lat1_20 wen_lat0_20
+  vss_ast0_20 weny0_20 twen0_20 td0_20 d0_20 vddpe_21 vddce_21 vddp_20
+  vnwp_22 cap_ctrl10_term_20 cap_ctrl11_term_20 cap_ctrl12_term_20 q1_19
+  d1_19 td1_19 wen1_19 weny1_19 wen_lat1_19 wen_lat0_19 weny0_19 wen0_19
+  td0_19 d0_19 vddpe_20 vddce_20 vnwp_21 cap_ctrl10_term_19
+  cap_ctrl11_term_19 cap_ctrl12_term_19 q1_18 d1_18 td1_18 weny1_18
+  wen_lat1_18 wen_lat0_18 vss_ast0_18 weny0_18 twen0_18 wen0_18 td0_18 d0_18
+  vddpe_19 vddp_18 vnwp_20 q0_18 cap_ctrl10_term_18 cap_ctrl11_term_18
+  cap_ctrl12_term_18 d1_17 td1_17 weny1_17 wen_lat1_17 wen_lat0_17 weny0_17
+  twen0_17 wen0_17 td0_17 d0_17 vddpe_18 vddce_18 vddp_17 vpw_19 vnwp_19
+  q0_17 cap_ctrl10_term_17 cap_ctrl11_term_17 cap_ctrl12_term_17 d1_16 td1_16
+  weny1_16 wen_lat1_16 wen_lat0_16 weny0_16 td0_16 d0_16 vddpe_17 vddce_17
+  vnwp_18 cap_ctrl10_term_16 cap_ctrl11_term_16 cap_ctrl12_term_16 vpw_17
+  d1_15 td1_15 weny1_15 wen_lat1_15 wen_lat0_15 weny0_15 twen0_15 wen0_15
+  td0_15 d0_15 vddpe_16 vddce_16 vddp_15 vnwp_17 q0_15 cap_ctrl10_term_15
+  cap_ctrl11_term_15 cap_ctrl12_term_15 vss_15 d1_14 td1_14 weny1_14
+  wen_lat1_14 wen_lat0_14 weny0_14 td0_14 d0_14 vddpe_15 vddce_15 vpw_16
+  vnwp_16 cap_ctrl10_term_14 cap_ctrl11_term_14 cap_ctrl12_term_14 vpw_15
+  vss_14 vsse_15 td1_13 wen_lat1_13 wen_lat0_13 weny0_13 td0_13 d0_13
+  vddpe_14 vddce_14 vnwp_15 q0_13 cap_ctrl10_term_13 cap_ctrl11_term_13
+  cap_ctrl12_term_13 d1_12 td1_12 weny1_12 wen_lat1_12 wen_lat0_12 weny0_12
+  td0_12 d0_12 vddpe_13 vddce_13 vpw_14 vnwp_14 q0_12 cap_ctrl10_term_12
+  cap_ctrl11_term_12 cap_ctrl12_term_12 td1_11 wen_lat1_11 wen_lat0_11
+  weny0_11 td0_11 d0_11 vddpe_12 vddce_12 vss_12 vpw_13 vnwp_13
+  cap_ctrl10_term_11 cap_ctrl11_term_11 cap_ctrl12_term_11 vsse_12 nretnvt
+  nactc actp fca2_6 fca2_5 fca2_4 fca2_3 fca2_2 fca2_1 cre2 fca1_0 vnwc_1
+  vddpe_11 dft_p2 gwen_p2 gtp dbl_nbl_wa_turn dbl_nbl_wa ten dftrambyp_dum
+  emas ema[0] ema[1] ema[2] emaw[0] emaw[1] pgen_dum cap_ctrl12_term_10
+  cap_ctrl11_term_10 cap_ctrl10_term_10 vsse_11 vddce_10 vddpe_10 d0_10
+  td0_10 weny0_10 wen_lat0_10 wen_lat1_10 td1_10 d1_10 vss_10 vpw_11 vnwp_11
+  cap_ctrl12_term_9 cap_ctrl11_term_9 cap_ctrl10_term_9 vnwp_10 vpw_10
+  vddpe_9 d0_9 td0_9 weny0_9 wen_lat0_9 wen_lat1_9 twen1_9 td1_9 vsse_10
+  vss_9 cap_ctrl12_term_8 cap_ctrl11_term_8 cap_ctrl10_term_8 vss_8 d0_8
+  td0_8 weny0_8 wen_lat0_8 vss_ast1_8 wen_lat1_8 twen1_8 td1_8
+  cap_ctrl12_term_7 cap_ctrl11_term_7 cap_ctrl10_term_7 td0_7 wen_lat0_7
+  wen_lat1_7 td1_7 vddpe_7 vsse_8 vss_7 vpw_8 vnwp_8 vddce_7
+  cap_ctrl12_term_6 cap_ctrl11_term_6 cap_ctrl10_term_6 vnwp_7 vss_6 d0_6
+  td0_6 weny0_6 wen_lat0_6 vss_ast1_6 wen_lat1_6 twen1_6 td1_6 vsse_7
+  cap_ctrl12_term_5 cap_ctrl11_term_5 cap_ctrl10_term_5 vsse_6 td0_5
+  wen_lat0_5 vss_ast1_5 wen_lat1_5 twen1_5 cap_ctrl12_term_4
+  cap_ctrl11_term_4 cap_ctrl10_term_4 vddp_4 td0_4 twen0_4 weny0_4 vss_ast0_4
+  wen_lat0_4 wen_lat1_4 twen1_4 td1_4 vsse_5 vss_4 vnwp_5 q1_4
+  cap_ctrl12_term_3 cap_ctrl11_term_3 cap_ctrl10_term_3 vss_3 d0_3 td0_3
+  weny0_3 wen_lat0_3 vss_ast1_3 wen_lat1_3 twen1_3 td1_3 q1_3
+  cap_ctrl12_term_2 cap_ctrl11_term_2 cap_ctrl10_term_2 vsse_3 td0_2 twen0_2
+  vss_ast0_2 wen_lat0_2 vss_ast1_2 wen_lat1_2 twen1_2 q1_2 cap_ctrl12_term_1
+  cap_ctrl11_term_1 cap_ctrl10_term_1 vddp_1 d0_1 twen0_1 weny0_1 vss_ast0_1
+  wen_lat0_1 vss_ast1_1 wen_lat1_1 twen1_1 td1_1 vss_1 q1_1 cap_ctrl12_term_0
+  cap_ctrl11_term_0 cap_ctrl10_term_0 vsse_1 td0_0 wen_lat0_0 vss_ast1_0
+  wen_lat1_0 twen1_0 q1_0 si_0 vsse_0 vsse_25 vnwc_2 vpw_25 q1_22
+  cap_ctrl00_22 cap_ctrl01_22 cap_ctrl02_22 d1_22 td1_22 wen1_22 twen1_22
+  weny1_22 wen_lat1_term_22 vss_ast1_22 wen_lat0_term_22 vss_ast0_22 weny0_22
+  twen0_22 wen0_22 td0_22 d0_22 vddpe_23 vddce_23 vddp_22 vsse_24 vss_23
+  vnwp_24 q0_22 cap_ctrl10_22 cap_ctrl11_22 cap_ctrl12_22 vddce_22 vss_22
+  cap_ctrl00_21 cap_ctrl01_21 cap_ctrl02_21 wen1_21 twen1_21 wen_lat1_term_21
+  vss_ast1_21 wen_lat0_term_21 weny0_21 wen0_21 d0_21 vpw_23 q0_21
+  cap_ctrl10_21 cap_ctrl11_21 cap_ctrl12_21 q1_20 vsse_22 cap_ctrl00_20
+  cap_ctrl01_20 cap_ctrl02_20 twen1_20 wen_lat1_term_20 vss_ast1_20
+  wen_lat0_term_20 wen0_20 vss_21 vpw_22 q0_20 cap_ctrl10_20 cap_ctrl11_20
+  cap_ctrl12_20 cap_ctrl00_19 cap_ctrl01_19 cap_ctrl02_19 twen1_19
+  wen_lat1_term_19 vss_ast1_19 wen_lat0_term_19 vss_ast0_19 twen0_19 vddp_19
+  vsse_21 vss_20 vpw_21 q0_19 cap_ctrl10_19 cap_ctrl11_19 cap_ctrl12_19
+  vddce_19 vpw_20 vss_19 cap_ctrl00_18 cap_ctrl01_18 cap_ctrl02_18 wen1_18
+  twen1_18 wen_lat1_term_18 vss_ast1_18 wen_lat0_term_18 vsse_20
+  cap_ctrl10_18 cap_ctrl11_18 cap_ctrl12_18 q1_17 cap_ctrl00_17 cap_ctrl01_17
+  cap_ctrl02_17 wen1_17 twen1_17 wen_lat1_term_17 vss_ast1_17
+  wen_lat0_term_17 vss_ast0_17 vsse_19 vss_18 cap_ctrl10_17 cap_ctrl11_17
+  cap_ctrl12_17 q1_16 cap_ctrl00_16 cap_ctrl01_16 cap_ctrl02_16 wen1_16
+  twen1_16 wen_lat1_term_16 vss_ast1_16 wen_lat0_term_16 vss_ast0_16 twen0_16
+  wen0_16 vddp_16 vsse_18 vss_17 vpw_18 q0_16 cap_ctrl10_16 cap_ctrl11_16
+  cap_ctrl12_16 q1_15 cap_ctrl00_15 cap_ctrl01_15 cap_ctrl02_15 wen1_15
+  twen1_15 wen_lat1_term_15 vss_ast1_15 wen_lat0_term_15 vss_ast0_15 vsse_17
+  vss_16 cap_ctrl10_15 cap_ctrl11_15 cap_ctrl12_15 q1_14 cap_ctrl00_14
+  cap_ctrl01_14 cap_ctrl02_14 wen1_14 twen1_14 wen_lat1_term_14 vss_ast1_14
+  wen_lat0_term_14 vss_ast0_14 twen0_14 wen0_14 vddp_14 vsse_16 q0_14
+  cap_ctrl10_14 cap_ctrl11_14 cap_ctrl12_14 q1_13 cap_ctrl00_13 cap_ctrl01_13
+  cap_ctrl02_13 d1_13 wen1_13 twen1_13 weny1_13 wen_lat1_term_13 vss_ast1_13
+  wen_lat0_term_13 vss_ast0_13 twen0_13 wen0_13 vddp_13 cap_ctrl10_13
+  cap_ctrl11_13 cap_ctrl12_13 q1_12 cap_ctrl00_12 cap_ctrl01_12 cap_ctrl02_12
+  wen1_12 twen1_12 wen_lat1_term_12 vss_ast1_12 wen_lat0_term_12 vss_ast0_12
+  twen0_12 wen0_12 vddp_12 vsse_14 vss_13 cap_ctrl10_12 cap_ctrl11_12
+  cap_ctrl12_12 q1_11 cap_ctrl00_11 cap_ctrl01_11 cap_ctrl02_11 d1_11 wen1_11
+  twen1_11 weny1_11 wen_lat1_term_11 vss_ast1_11 wen_lat0_term_11 vss_ast0_11
+  twen0_11 wen0_11 vddp_11 vsse_13 q0_11 cap_ctrl10_11 cap_ctrl11_11
+  cap_ctrl12_11 fca2_0 fca1_6 fca1_5 fca1_4 fca1_3 fca1_2 fca1_1 cre1 vpw_12
+  vnwp_12 vddce_11 vss_11 dft_p2_term gwen_p2_term gtp_term
+  dbl_nbl_wa_turn_term dbl_nbl_wa_term penso pensi tpen pen pso1 pso0 se so1
+  so0 log1 log0 wablm1 wablm0 wabl rawlm1 rawlm0 rawl nret ret2n_dum rdt gwen
+  cen clk a0 a1 a2 a3 a4 a5 a6 a7 a8 a9 a10 tgwen tcen ta0 ta1 ta2 ta3 ta4
+  ta5 ta6 ta7 ta8 ta9 ta10 gweny ceny ay0 ay1 ay2 ay3 ay4 ay5 ay6 ay7 ay8 ay9
+  ay10 cap_ctrl12_10 cap_ctrl11_10 cap_ctrl10_10 q0_10 vddp_10 wen0_10
+  twen0_10 vss_ast0_10 wen_lat0_term_10 vss_ast1_10 wen_lat1_term_10 weny1_10
+  twen1_10 wen1_10 cap_ctrl02_10 cap_ctrl01_10 cap_ctrl00_10 q1_10
+  cap_ctrl12_9 cap_ctrl11_9 cap_ctrl10_9 q0_9 vddp_9 wen0_9 twen0_9
+  vss_ast0_9 wen_lat0_term_9 vss_ast1_9 wen_lat1_term_9 weny1_9 wen1_9 d1_9
+  cap_ctrl02_9 cap_ctrl01_9 cap_ctrl00_9 vddce_9 q1_9 cap_ctrl12_8
+  cap_ctrl11_8 cap_ctrl10_8 q0_8 vddp_8 wen0_8 twen0_8 vss_ast0_8
+  wen_lat0_term_8 wen_lat1_term_8 weny1_8 wen1_8 d1_8 vddpe_8 cap_ctrl02_8
+  cap_ctrl01_8 cap_ctrl00_8 vsse_9 vpw_9 vnwp_9 vddce_8 q1_8 cap_ctrl12_7
+  cap_ctrl11_7 cap_ctrl10_7 q0_7 vddp_7 d0_7 wen0_7 twen0_7 weny0_7
+  vss_ast0_7 wen_lat0_term_7 vss_ast1_7 wen_lat1_term_7 weny1_7 twen1_7
+  wen1_7 d1_7 cap_ctrl02_7 cap_ctrl01_7 cap_ctrl00_7 q1_7 cap_ctrl12_6
+  cap_ctrl11_6 cap_ctrl10_6 q0_6 vddp_6 wen0_6 twen0_6 vss_ast0_6
+  wen_lat0_term_6 wen_lat1_term_6 weny1_6 wen1_6 d1_6 vddpe_6 cap_ctrl02_6
+  cap_ctrl01_6 cap_ctrl00_6 vpw_7 vddce_6 q1_6 cap_ctrl12_5 cap_ctrl11_5
+  cap_ctrl10_5 q0_5 vddp_5 d0_5 wen0_5 twen0_5 weny0_5 vss_ast0_5
+  wen_lat0_term_5 wen_lat1_term_5 weny1_5 wen1_5 td1_5 d1_5 vddpe_5
+  cap_ctrl02_5 cap_ctrl01_5 cap_ctrl00_5 vss_5 vpw_6 vnwp_6 vddce_5 q1_5
+  cap_ctrl12_4 cap_ctrl11_4 cap_ctrl10_4 q0_4 vpw_5 vddpe_4 d0_4 wen0_4
+  wen_lat0_term_4 vss_ast1_4 wen_lat1_term_4 weny1_4 wen1_4 d1_4 cap_ctrl02_4
+  cap_ctrl01_4 cap_ctrl00_4 vddce_4 cap_ctrl12_3 cap_ctrl11_3 cap_ctrl10_3
+  q0_3 vddp_3 wen0_3 twen0_3 vss_ast0_3 wen_lat0_term_3 wen_lat1_term_3
+  weny1_3 wen1_3 d1_3 vddpe_3 cap_ctrl02_3 cap_ctrl01_3 cap_ctrl00_3 vsse_4
+  vpw_4 vnwp_4 vddce_3 cap_ctrl12_2 cap_ctrl11_2 cap_ctrl10_2 q0_2 vddp_2
+  d0_2 wen0_2 weny0_2 wen_lat0_term_2 wen_lat1_term_2 weny1_2 wen1_2 td1_2
+  d1_2 vddpe_2 cap_ctrl02_2 cap_ctrl01_2 cap_ctrl00_2 vss_2 vpw_3 vnwp_3
+  vddce_2 cap_ctrl12_1 cap_ctrl11_1 cap_ctrl10_1 q0_1 td0_1 wen0_1
+  wen_lat0_term_1 wen_lat1_term_1 weny1_1 wen1_1 d1_1 vddpe_1 cap_ctrl02_1
+  cap_ctrl01_1 cap_ctrl00_1 vsse_2 vpw_2 vnwp_2 vddce_1 cap_ctrl12_0
+  cap_ctrl11_0 cap_ctrl10_0 q0_0 vddp_0 d0_0 wen0_0 twen0_0 weny0_0
+  vss_ast0_0 wen_lat0_term_0 wen_lat1_term_0 weny1_0 wen1_0 td1_0 d1_0
+  vddpe_0 cap_ctrl02_0 cap_ctrl01_0 cap_ctrl00_0 vss_0 vpw_1 vnwp_1 vddce_0
+  psi_0 vpw_0 vnwc_0 vnwp_0
** sram128x46ast_slice: 790 flat devices **
xast_cntl_s nretnvt nactc actp fca2_6 fca2_5 fca2_4 fca2_3 fca2_2 fca2_1 cre2
+  fca1_0 vpw_12 vnwp_12 vnwc_1 vddce_11 vddpe_11 dft_p2 gwen_p2 gtp
+  dbl_nbl_wa_turn dbl_nbl_wa ten dftrambyp_dum emas ema[0] ema[1] ema[2]
+  emaw[0] emaw[1] pgen_dum ceny vsse_12 fca2_0 fca1_6 fca1_5 fca1_4 fca1_3
+  fca1_2 fca1_1 cre1 vss_11 dft_p2_term gwen_p2_term gtp_term
+  dbl_nbl_wa_turn_term dbl_nbl_wa_term penso pensi tpen pen pso1 pso0 se so1
+  so0 log1 log0 wablm1 wablm0 wabl rawlm1 rawlm0 rawl nret ret2n_dum rdt gwen
+  cen clk a0 a1 a2 a3 a4 a5 a6 a7 a8 a9 a10 tgwen tcen ta0 ta1 ta2 ta3 ta4
+  ta5 ta6 ta7 ta8 ta9 ta10 gweny ay0 ay1 ay2 ay3 ay4 ay5 ay6 ay7 ay8 ay9 ay10
+  wablm0_right wa_en_right wablm1_right wablm0_left wa_en_left wablm1_left
+  sram128x46wa_cntl_s
xast_left cap_ctrl12_term_10 cap_ctrl11_term_10 cap_ctrl10_term_10 wen_lat0_10
+  wen_lat1_10 cap_ctrl12_term_9 cap_ctrl11_term_9 cap_ctrl10_term_9 vnwp_10
+  vpw_10 vss_9 vss_ast0_9 wen_lat0_9 vss_ast1_9 wen_lat1_9 weny1_9 twen1_9
+  d1_9 vddpe_9 vsse_10 cap_ctrl12_term_8 cap_ctrl11_term_8 cap_ctrl10_term_8
+  q0_8 vpw_9 vss_8 vsse_9 vddpe_8 twen0_8 weny0_8 vss_ast0_8 wen_lat0_8
+  vss_ast1_8 wen_lat1_8 weny1_8 twen1_8 wen1_8 d1_8 cap_ctrl12_term_7
+  cap_ctrl11_term_7 cap_ctrl10_term_7 vnwp_8 vss_7 vsse_8 vddp_7 vddce_7
+  vddpe_7 td0_7 wen0_7 twen0_7 weny0_7 vss_ast0_7 wen_lat0_7 vss_ast1_7
+  wen_lat1_7 weny1_7 twen1_7 wen1_7 td1_7 d1_7 q1_7 cap_ctrl12_term_6
+  cap_ctrl11_term_6 cap_ctrl10_term_6 q0_6 vddp_6 vddce_6 d0_6 td0_6 wen0_6
+  twen0_6 weny0_6 vss_ast0_6 wen_lat0_6 vss_ast1_6 wen_lat1_6 weny1_6 twen1_6
+  wen1_6 td1_6 d1_6 vpw_7 q1_6 cap_ctrl12_term_5 cap_ctrl11_term_5
+  cap_ctrl10_term_5 q0_5 vddp_5 vddce_5 d0_5 td0_5 wen0_5 twen0_5 weny0_5
+  vss_ast0_5 wen_lat0_5 vss_ast1_5 wen_lat1_5 weny1_5 twen1_5 wen1_5 td1_5
+  d1_5 vss_5 q1_5 cap_ctrl12_term_4 cap_ctrl11_term_4 cap_ctrl10_term_4 q0_4
+  vpw_5 vddp_4 vddce_4 vddpe_4 d0_4 td0_4 wen0_4 twen0_4 weny0_4 vss_ast0_4
+  wen_lat0_4 wen_lat1_4 weny1_4 wen1_4 td1_4 d1_4 vsse_5 q1_4
+  cap_ctrl12_term_3 cap_ctrl11_term_3 cap_ctrl10_term_3 vddp_3 vddce_3 d0_3
+  td0_3 wen0_3 twen0_3 weny0_3 vss_ast0_3 wen_lat0_3 vss_ast1_3 wen_lat1_3
+  weny1_3 twen1_3 wen1_3 td1_3 d1_3 q1_3 cap_ctrl12_term_2 cap_ctrl11_term_2
+  cap_ctrl10_term_2 q0_2 vddp_2 vddce_2 d0_2 td0_2 wen0_2 twen0_2 weny0_2
+  vss_ast0_2 wen_lat0_2 vss_ast1_2 wen_lat1_2 weny1_2 wen1_2 td1_2 d1_2 q1_2
+  cap_ctrl12_term_1 cap_ctrl11_term_1 cap_ctrl10_term_1 q0_1 vddp_1 d0_1
+  td0_1 wen0_1 twen0_1 weny0_1 vss_ast0_1 wen_lat0_1 wen_lat1_1 weny1_1
+  wen1_1 td1_1 d1_1 vddpe_1 vpw_2 vddce_1 q1_1 cap_ctrl12_term_0
+  cap_ctrl11_term_0 cap_ctrl10_term_0 q0_0 vddp_0 vddce_0 d0_0 td0_0 wen0_0
+  twen0_0 weny0_0 vss_ast0_0 wen_lat0_0 vss_ast1_0 wen_lat1_0 weny1_0 twen1_0
+  wen1_0 td1_0 d1_0 vss_0 q1_0 psi_0 si_0 vpw_0 cap_ctrl12_10 cap_ctrl11_10
+  cap_ctrl10_10 q0_10 vnwp_11 vpw_11 vss_10 vsse_11 vddp_10 vddce_10 vddpe_10
+  d0_10 td0_10 wen0_10 twen0_10 weny0_10 vss_ast0_10 wen_lat0_term_10
+  vss_ast1_10 wen_lat1_term_10 weny1_10 twen1_10 wen1_10 td1_10 d1_10
+  cap_ctrl02_10 cap_ctrl01_10 cap_ctrl00_10 q1_10 cap_ctrl12_9 cap_ctrl11_9
+  cap_ctrl10_9 q0_9 vddp_9 vddce_9 d0_9 td0_9 wen0_9 twen0_9 weny0_9
+  wen_lat0_term_9 wen_lat1_term_9 wen1_9 td1_9 cap_ctrl02_9 cap_ctrl01_9
+  cap_ctrl00_9 q1_9 cap_ctrl12_8 cap_ctrl11_8 cap_ctrl10_8 vnwp_9 vddp_8
+  vddce_8 d0_8 td0_8 wen0_8 wen_lat0_term_8 wen_lat1_term_8 td1_8
+  cap_ctrl02_8 cap_ctrl01_8 cap_ctrl00_8 q1_8 cap_ctrl12_7 cap_ctrl11_7
+  cap_ctrl10_7 q0_7 d0_7 wen_lat0_term_7 wen_lat1_term_7 cap_ctrl02_7
+  cap_ctrl01_7 cap_ctrl00_7 vpw_8 cap_ctrl12_6 cap_ctrl11_6 cap_ctrl10_6
+  vnwp_7 vss_6 vsse_7 vddpe_6 wen_lat0_term_6 wen_lat1_term_6 cap_ctrl02_6
+  cap_ctrl01_6 cap_ctrl00_6 cap_ctrl12_5 cap_ctrl11_5 cap_ctrl10_5 vnwp_6
+  vsse_6 vddpe_5 wen_lat0_term_5 wen_lat1_term_5 cap_ctrl02_5 cap_ctrl01_5
+  cap_ctrl00_5 vpw_6 cap_ctrl12_4 cap_ctrl11_4 cap_ctrl10_4 wen_lat0_term_4
+  vss_ast1_4 wen_lat1_term_4 twen1_4 cap_ctrl02_4 cap_ctrl01_4 cap_ctrl00_4
+  vss_4 vnwp_5 cap_ctrl12_3 cap_ctrl11_3 cap_ctrl10_3 q0_3 vnwp_4 vss_3
+  vsse_4 vddpe_3 wen_lat0_term_3 wen_lat1_term_3 cap_ctrl02_3 cap_ctrl01_3
+  cap_ctrl00_3 vpw_4 cap_ctrl12_2 cap_ctrl11_2 cap_ctrl10_2 vnwp_3 vsse_3
+  vddpe_2 wen_lat0_term_2 wen_lat1_term_2 twen1_2 cap_ctrl02_2 cap_ctrl01_2
+  cap_ctrl00_2 vss_2 vpw_3 cap_ctrl12_1 cap_ctrl11_1 cap_ctrl10_1
+  wen_lat0_term_1 vss_ast1_1 wen_lat1_term_1 twen1_1 cap_ctrl02_1
+  cap_ctrl01_1 cap_ctrl00_1 vsse_2 vss_1 vnwp_2 cap_ctrl12_0 cap_ctrl11_0
+  cap_ctrl10_0 vnwp_1 vsse_1 vddpe_0 wen_lat0_term_0 wen_lat1_term_0
+  cap_ctrl02_0 cap_ctrl01_0 cap_ctrl00_0 vpw_1 vnwc_0 vnwp_0 vsse_0
+  wablm0_left wa_en_left wablm1_left sram128x46ast_row_l
xast_right vnwp_25 si_1 psi_1 wen_lat1_22 wen_lat0_22 cap_ctrl10_term_22
+  cap_ctrl11_term_22 cap_ctrl12_term_22 vddpe_22 d1_21 twen1_21 weny1_21
+  wen_lat1_21 vss_ast1_21 wen_lat0_21 vss_ast0_21 twen0_21 vddp_21 vsse_23
+  vss_22 vpw_23 cap_ctrl10_term_21 cap_ctrl11_term_21 cap_ctrl12_term_21
+  d1_20 wen1_20 twen1_20 weny1_20 wen_lat1_20 vss_ast1_20 wen_lat0_20
+  vss_ast0_20 weny0_20 twen0_20 d0_20 vddpe_21 vddp_20 vsse_22 vss_21 vpw_22
+  cap_ctrl10_term_20 cap_ctrl11_term_20 cap_ctrl12_term_20 q1_19 d1_19 td1_19
+  wen1_19 twen1_19 weny1_19 wen_lat1_19 vss_ast1_19 wen_lat0_19 vss_ast0_19
+  weny0_19 twen0_19 wen0_19 td0_19 d0_19 vddpe_20 vddce_20 vddp_19 vsse_21
+  vss_20 vpw_21 vnwp_21 cap_ctrl10_term_19 cap_ctrl11_term_19
+  cap_ctrl12_term_19 q1_18 d1_18 td1_18 wen1_18 twen1_18 weny1_18 wen_lat1_18
+  vss_ast1_18 wen_lat0_18 vss_ast0_18 weny0_18 twen0_18 wen0_18 td0_18 d0_18
+  vddpe_19 vddce_19 vddp_18 vsse_20 vss_19 vpw_20 vnwp_20 q0_18
+  cap_ctrl10_term_18 cap_ctrl11_term_18 cap_ctrl12_term_18 q1_17 d1_17 td1_17
+  wen1_17 weny1_17 wen_lat1_17 wen_lat0_17 vss_ast0_17 weny0_17 twen0_17
+  wen0_17 td0_17 d0_17 vddpe_18 vddce_18 vddp_17 vsse_19 vss_18 vpw_19
+  cap_ctrl10_term_17 cap_ctrl11_term_17 cap_ctrl12_term_17 d1_16 td1_16
+  wen1_16 twen1_16 weny1_16 wen_lat1_16 vss_ast1_16 wen_lat0_16 vss_ast0_16
+  weny0_16 twen0_16 wen0_16 td0_16 d0_16 vddpe_17 vddce_17 vddp_16 vsse_18
+  vss_17 vpw_18 vnwp_18 cap_ctrl10_term_16 cap_ctrl11_term_16
+  cap_ctrl12_term_16 q1_15 vpw_17 d1_15 td1_15 wen1_15 twen1_15 weny1_15
+  wen_lat1_15 vss_ast1_15 wen_lat0_15 vss_ast0_15 weny0_15 twen0_15 wen0_15
+  td0_15 d0_15 vddpe_16 vddce_16 vddp_15 vsse_17 vss_16 vnwp_17 q0_15
+  cap_ctrl10_term_15 cap_ctrl11_term_15 cap_ctrl12_term_15 q1_14 vss_15 d1_14
+  td1_14 wen1_14 weny1_14 wen_lat1_14 wen_lat0_14 vss_ast0_14 weny0_14
+  twen0_14 wen0_14 td0_14 d0_14 vpw_16 cap_ctrl10_term_14 cap_ctrl11_term_14
+  cap_ctrl12_term_14 vss_14 vsse_15 d1_13 td1_13 wen1_13 twen1_13 weny1_13
+  wen_lat1_13 vss_ast1_13 wen_lat0_13 vss_ast0_13 weny0_13 twen0_13 wen0_13
+  td0_13 d0_13 vddpe_14 vddce_14 vddp_13 vnwp_15 q0_13 cap_ctrl10_term_13
+  cap_ctrl11_term_13 cap_ctrl12_term_13 q1_12 d1_12 td1_12 wen1_12 weny1_12
+  wen_lat1_12 wen_lat0_12 vss_ast0_12 weny0_12 twen0_12 wen0_12 td0_12 d0_12
+  vddpe_13 vddce_13 vddp_12 vsse_14 vpw_14 vnwp_14 q0_12 cap_ctrl10_term_12
+  cap_ctrl11_term_12 cap_ctrl12_term_12 q1_11 d1_11 td1_11 wen1_11 weny1_11
+  wen_lat1_11 wen_lat0_11 vss_ast0_11 vss_12 vpw_13 cap_ctrl10_term_11
+  cap_ctrl11_term_11 cap_ctrl12_term_11 vsse_25 vnwc_2 vpw_25 q1_22 vpw_24
+  cap_ctrl00_22 cap_ctrl01_22 cap_ctrl02_22 d1_22 td1_22 wen1_22 twen1_22
+  weny1_22 wen_lat1_term_22 vss_ast1_22 wen_lat0_term_22 vss_ast0_22 weny0_22
+  twen0_22 wen0_22 td0_22 d0_22 vddpe_23 vddce_23 vddp_22 vsse_24 vss_23
+  vnwp_24 q0_22 cap_ctrl10_22 cap_ctrl11_22 cap_ctrl12_22 q1_21 cap_ctrl00_21
+  cap_ctrl01_21 cap_ctrl02_21 td1_21 wen1_21 wen_lat1_term_21
+  wen_lat0_term_21 weny0_21 wen0_21 td0_21 d0_21 vddce_22 vnwp_23 q0_21
+  cap_ctrl10_21 cap_ctrl11_21 cap_ctrl12_21 q1_20 cap_ctrl00_20 cap_ctrl01_20
+  cap_ctrl02_20 td1_20 wen_lat1_term_20 wen_lat0_term_20 wen0_20 td0_20
+  vddce_21 vnwp_22 q0_20 cap_ctrl10_20 cap_ctrl11_20 cap_ctrl12_20
+  cap_ctrl00_19 cap_ctrl01_19 cap_ctrl02_19 wen_lat1_term_19 wen_lat0_term_19
+  q0_19 cap_ctrl10_19 cap_ctrl11_19 cap_ctrl12_19 cap_ctrl00_18 cap_ctrl01_18
+  cap_ctrl02_18 wen_lat1_term_18 wen_lat0_term_18 cap_ctrl10_18 cap_ctrl11_18
+  cap_ctrl12_18 cap_ctrl00_17 cap_ctrl01_17 cap_ctrl02_17 twen1_17
+  wen_lat1_term_17 vss_ast1_17 wen_lat0_term_17 vnwp_19 q0_17 cap_ctrl10_17
+  cap_ctrl11_17 cap_ctrl12_17 q1_16 cap_ctrl00_16 cap_ctrl01_16 cap_ctrl02_16
+  wen_lat1_term_16 wen_lat0_term_16 q0_16 cap_ctrl10_16 cap_ctrl11_16
+  cap_ctrl12_16 cap_ctrl00_15 cap_ctrl01_15 cap_ctrl02_15 wen_lat1_term_15
+  wen_lat0_term_15 cap_ctrl10_15 cap_ctrl11_15 cap_ctrl12_15 cap_ctrl00_14
+  cap_ctrl01_14 cap_ctrl02_14 twen1_14 wen_lat1_term_14 vss_ast1_14
+  wen_lat0_term_14 vddpe_15 vddce_15 vddp_14 vsse_16 vnwp_16 q0_14
+  cap_ctrl10_14 cap_ctrl11_14 cap_ctrl12_14 q1_13 vpw_15 cap_ctrl00_13
+  cap_ctrl01_13 cap_ctrl02_13 wen_lat1_term_13 wen_lat0_term_13 cap_ctrl10_13
+  cap_ctrl11_13 cap_ctrl12_13 vss_13 cap_ctrl00_12 cap_ctrl01_12
+  cap_ctrl02_12 twen1_12 wen_lat1_term_12 vss_ast1_12 wen_lat0_term_12
+  cap_ctrl10_12 cap_ctrl11_12 cap_ctrl12_12 vsse_13 cap_ctrl00_11
+  cap_ctrl01_11 cap_ctrl02_11 twen1_11 wen_lat1_term_11 vss_ast1_11
+  wen_lat0_term_11 weny0_11 twen0_11 wen0_11 td0_11 d0_11 vddpe_12 vddce_12
+  vddp_11 vnwp_13 q0_11 cap_ctrl10_11 cap_ctrl11_11 cap_ctrl12_11
+  wablm0_right wa_en_right wablm1_right sram128x46ast_row_r
.ends sram128x46ast_slice
****
.subckt sram128x46botcap2x2 q0 q1 weny0 weny1 wr_mask0_term wr_mask1_term
+  cap_ctrl00_term cap_ctrl01_term cap_ctrl02_term cap_ctrl10_term
+  cap_ctrl11_term cap_ctrl12_term vddce vddpe vnwp vpw vss vss_ast0 vss_ast1
+  vsse d0 d1 td0 td1 twen0 twen1 wen0 wen1
** sram128x46botcap2x2: 8 flat devices **
di0.d_diode_x_dio vpw wen0 ndio_ll AREA=0.018P PJ=0.54U
di4.d_diode_x_dio vpw twen0 ndio_ll AREA=0.018P PJ=0.54U
di5.d_diode_x_dio vpw td0 ndio_ll AREA=0.018P PJ=0.54U
di6.d_diode_x_dio vpw d1 ndio_ll AREA=0.018P PJ=0.54U
di7.d_diode_x_dio vpw wen1 ndio_ll AREA=0.018P PJ=0.54U
di8.d_diode_x_dio vpw td1 ndio_ll AREA=0.018P PJ=0.54U
di82.d_diode_x_dio vpw d0 ndio_ll AREA=0.018P PJ=0.54U
di9.d_diode_x_dio vpw twen1 ndio_ll AREA=0.018P PJ=0.54U
.ends sram128x46botcap2x2
****
.subckt sram128x46botcap2x2_rpt cap_ctrl12_term cap_ctrl11_term
+  cap_ctrl10_term vnwp vpw vss_ast0 wr_mask0_term vss_ast1 wr_mask1_term
+  weny1 twen1 vddpe cap_ctrl02_term cap_ctrl01_term cap_ctrl00_term vss q1 q0
+  d0 td0 wen0 twen0 weny0 wen1 td1 d1 vddce
** sram128x46botcap2x2_rpt: 8 flat devices **
xbcap q0 q1 weny0 weny1 wr_mask0_term wr_mask1_term cap_ctrl00_term
+  cap_ctrl01_term cap_ctrl02_term cap_ctrl10_term cap_ctrl11_term
+  cap_ctrl12_term vddce vddpe vnwp vpw vss vss_ast0 vss_ast1 vss d0 d1 td0
+  td1 twen0 twen1 wen0 wen1 sram128x46botcap2x2
.ends sram128x46botcap2x2_rpt
****
.subckt sram128x46midbot ay0 ay1 ay2 ay3 ay4 ay5 ay6 ay7 ay8 ay9 ay10 ceny
+  gweny log0 log1 penso prdyn pso0 pso1 so0 so1 dbl_nbl_wa_term
+  dbl_nbl_wa_turn_term dft_p2_term gtp_term gwen_p2_term vddce vddpe vnwc
+  vnwp vpw vss vsse a0 a1 a2 a3 a4 a5 a6 a7 a8 a9 a10 cen clk cre1 cre2
+  dftrambyp ema0 ema1 ema2 emas emaw0 emaw1 fca1_0 fca1_1 fca1_2 fca1_3
+  fca1_4 fca1_5 fca1_6 fca2_0 fca2_1 fca2_2 fca2_3 fca2_4 fca2_5 fca2_6 gwen
+  pen pensi pgen rawl rawlm0 rawlm1 rdt ret1n ret2n se ta0 ta1 ta2 ta3 ta4
+  ta5 ta6 ta7 ta8 ta9 ta10 tcen ten tgwen tpen wabl wablm0 wablm1
** sram128x46midbot: 65 flat devices **
di113.d_diode_x_dio vpw dftrambyp ndio_ll AREA=0.018P PJ=0.54U
di114.d_diode_x_dio vpw emaw1 ndio_ll AREA=0.018P PJ=0.54U
di115.d_diode_x_dio vpw emaw0 ndio_ll AREA=0.018P PJ=0.54U
di116.d_diode_x_dio vpw rdt ndio_ll AREA=0.018P PJ=0.54U
di121.d_diode_x_dio vpw clk ndio_ll AREA=0.018P PJ=0.54U
di137.d_diode_x_dio vpw ta0 ndio_ll AREA=0.018P PJ=0.54U
di138.d_diode_x_dio vpw ta1 ndio_ll AREA=0.018P PJ=0.54U
di139.d_diode_x_dio vpw ta4 ndio_ll AREA=0.018P PJ=0.54U
di140.d_diode_x_dio vpw ta5 ndio_ll AREA=0.018P PJ=0.54U
di141.d_diode_x_dio vpw ta2 ndio_ll AREA=0.018P PJ=0.54U
di142.d_diode_x_dio vpw ta3 ndio_ll AREA=0.018P PJ=0.54U
di143.d_diode_x_dio vpw ta6 ndio_ll AREA=0.018P PJ=0.54U
di144.d_diode_x_dio vpw ta7 ndio_ll AREA=0.018P PJ=0.54U
di145.d_diode_x_dio vpw ta8 ndio_ll AREA=0.018P PJ=0.54U
di146.d_diode_x_dio vpw ta9 ndio_ll AREA=0.018P PJ=0.54U
di147.d_diode_x_dio vpw ta10 ndio_ll AREA=0.018P PJ=0.54U
di159.d_diode_x_dio vpw tcen ndio_ll AREA=0.018P PJ=0.54U
di160.d_diode_x_dio vpw tgwen ndio_ll AREA=0.018P PJ=0.54U
di163.d_diode_x_dio vpw ten ndio_ll AREA=0.018P PJ=0.54U
di176.d_diode_x_dio vpw cre1 ndio_ll AREA=0.018P PJ=0.54U
di177.d_diode_x_dio vpw fca1_0 ndio_ll AREA=0.018P PJ=0.54U
di178.d_diode_x_dio vpw fca1_1 ndio_ll AREA=0.018P PJ=0.54U
di179.d_diode_x_dio vpw fca1_2 ndio_ll AREA=0.018P PJ=0.54U
di180.d_diode_x_dio vpw fca1_3 ndio_ll AREA=0.018P PJ=0.54U
di181.d_diode_x_dio vpw fca1_4 ndio_ll AREA=0.018P PJ=0.54U
di182.d_diode_x_dio vpw fca1_5 ndio_ll AREA=0.018P PJ=0.54U
di183.d_diode_x_dio vpw fca1_6 ndio_ll AREA=0.018P PJ=0.54U
di184.d_diode_x_dio vpw cre2 ndio_ll AREA=0.018P PJ=0.54U
di185.d_diode_x_dio vpw fca2_0 ndio_ll AREA=0.018P PJ=0.54U
di186.d_diode_x_dio vpw fca2_1 ndio_ll AREA=0.018P PJ=0.54U
di187.d_diode_x_dio vpw fca2_2 ndio_ll AREA=0.018P PJ=0.54U
di188.d_diode_x_dio vpw fca2_3 ndio_ll AREA=0.018P PJ=0.54U
di189.d_diode_x_dio vpw fca2_4 ndio_ll AREA=0.018P PJ=0.54U
di190.d_diode_x_dio vpw fca2_5 ndio_ll AREA=0.018P PJ=0.54U
di191.d_diode_x_dio vpw fca2_6 ndio_ll AREA=0.018P PJ=0.54U
di192.d_diode_x_dio vpw pen ndio_ll AREA=0.018P PJ=0.54U
di193.d_diode_x_dio vpw tpen ndio_ll AREA=0.018P PJ=0.54U
di194.d_diode_x_dio vpw pensi ndio_ll AREA=0.018P PJ=0.54U
di196.d_diode_x_dio vpw pgen ndio_ll AREA=0.018P PJ=0.54U
di197.d_diode_x_dio vpw ret2n ndio_ll AREA=0.018P PJ=0.54U
di198.d_diode_x_dio vpw wablm1 ndio_ll AREA=0.018P PJ=0.54U
di199.d_diode_x_dio vpw wablm0 ndio_ll AREA=0.018P PJ=0.54U
di200.d_diode_x_dio vpw wabl ndio_ll AREA=0.018P PJ=0.54U
di201.d_diode_x_dio vpw rawlm1 ndio_ll AREA=0.018P PJ=0.54U
di202.d_diode_x_dio vpw rawlm0 ndio_ll AREA=0.018P PJ=0.54U
di203.d_diode_x_dio vpw rawl ndio_ll AREA=0.018P PJ=0.54U
di59.d_diode_x_dio vpw cen ndio_ll AREA=0.018P PJ=0.54U
di60.d_diode_x_dio vpw gwen ndio_ll AREA=0.018P PJ=0.54U
di61.d_diode_x_dio vpw ret1n ndio_ll AREA=0.018P PJ=0.54U
di62.d_diode_x_dio vpw emas ndio_ll AREA=0.018P PJ=0.54U
di63.d_diode_x_dio vpw ema0 ndio_ll AREA=0.018P PJ=0.54U
di64.d_diode_x_dio vpw ema1 ndio_ll AREA=0.018P PJ=0.54U
di65.d_diode_x_dio vpw ema2 ndio_ll AREA=0.018P PJ=0.54U
di85.d_diode_x_dio vpw se ndio_ll AREA=0.018P PJ=0.54U
di86.d_diode_x_dio vpw a0 ndio_ll AREA=0.018P PJ=0.54U
di87.d_diode_x_dio vpw a1 ndio_ll AREA=0.018P PJ=0.54U
di88.d_diode_x_dio vpw a2 ndio_ll AREA=0.018P PJ=0.54U
di89.d_diode_x_dio vpw a3 ndio_ll AREA=0.018P PJ=0.54U
di90.d_diode_x_dio vpw a4 ndio_ll AREA=0.018P PJ=0.54U
di91.d_diode_x_dio vpw a5 ndio_ll AREA=0.018P PJ=0.54U
di92.d_diode_x_dio vpw a6 ndio_ll AREA=0.018P PJ=0.54U
di93.d_diode_x_dio vpw a7 ndio_ll AREA=0.018P PJ=0.54U
di94.d_diode_x_dio vpw a8 ndio_ll AREA=0.018P PJ=0.54U
di95.d_diode_x_dio vpw a9 ndio_ll AREA=0.018P PJ=0.54U
di96.d_diode_x_dio vpw a10 ndio_ll AREA=0.018P PJ=0.54U
.ends sram128x46midbot
****
.subckt sram128x46midbot_pgm prdyn fca2_6 fca2_5 fca2_4 fca2_3 fca2_2 fca2_1
+  cre2 fca1_0 vss dft_p2_term gwen_p2_term gtp_term dbl_nbl_wa_turn_term
+  dbl_nbl_wa_term pensi pso1 pso0 se so0 log1 dftrambyp ret1n gwen clk a6 a7
+  a8 tgwen tcen ta0 ta1 ta2 ta3 ta4 ta5 gweny ay0 ay1 ay2 ay3 ay4 ay5 fca2_0
+  fca1_6 fca1_5 fca1_4 fca1_3 fca1_2 fca1_1 cre1 vpw vnwp vnwc vsse vddce
+  vddpe penso tpen pen so1 wablm1 wablm0 wabl rawlm1 rawlm0 rawl ten emas
+  ema0 ema1 ema2 emaw0 emaw1 ret2n pgen cen a0 a3 a4 a5 a1 ta6 ta7 ta8 ta9
+  ta10 ceny ay6 ay7 ay8 ay9 ay10
** sram128x46midbot_pgm: 65 flat devices **
xmidbot_pgm ay0 ay1 ay2 ay3 ay4 ay5 ay6 ay7 ay8 ay9 ay10 ceny gweny a1 log1
+  penso prdyn pso0 pso1 so0 so1 dbl_nbl_wa_term dbl_nbl_wa_turn_term
+  dft_p2_term gtp_term gwen_p2_term vddce vddpe vnwc vnwp vpw vss vsse a0 a1
+  a1 a3 a4 a5 a6 a7 a8 a1 a1 cen clk cre1 cre2 dftrambyp ema0 ema1 ema2 emas
+  emaw0 emaw1 fca1_0 fca1_1 fca1_2 fca1_3 fca1_4 fca1_5 fca1_6 fca2_0 fca2_1
+  fca2_2 fca2_3 fca2_4 fca2_5 fca2_6 gwen pen pensi pgen rawl rawlm0 rawlm1
+  a1 ret1n ret2n se ta0 ta1 ta2 ta3 ta4 ta5 ta6 ta7 ta8 ta9 ta10 tcen ten
+  tgwen tpen wabl wablm0 wablm1 sram128x46midbot
.ends sram128x46midbot_pgm
****
.subckt sram128x46botcorner vnwc vnwp vpw vss vsse psi si
** sram128x46botcorner: 2 flat devices **
di0.d_diode_x_dio vpw psi ndio_ll AREA=0.018P PJ=0.54U
di62.d_diode_x_dio vpw si ndio_ll AREA=0.018P PJ=0.54U
.ends sram128x46botcorner
****
.subckt sram128x46botcaprow vsse_2 si_1 psi_1 q1_22 cap_ctrl00_term_22
+  cap_ctrl01_term_22 cap_ctrl02_term_22 vddpe_23 weny1_22 wr_mask1_term_22
+  vss_ast1_22 wr_mask0_term_22 vss_ast0_22 cap_ctrl10_term_22
+  cap_ctrl11_term_22 cap_ctrl12_term_22 q1_21 cap_ctrl00_term_21
+  cap_ctrl01_term_21 cap_ctrl02_term_21 d1_21 td1_21 weny1_21
+  wr_mask1_term_21 vss_ast1_21 wr_mask0_term_21 vss_ast0_21 twen0_21 td0_21
+  vddce_22 vddpe_22 cap_ctrl10_term_21 cap_ctrl11_term_21 cap_ctrl12_term_21
+  q1_20 cap_ctrl00_term_20 cap_ctrl01_term_20 cap_ctrl02_term_20 d1_20 td1_20
+  wen1_20 weny1_20 wr_mask1_term_20 vss_ast1_20 wr_mask0_term_20 vss_ast0_20
+  weny0_20 td0_20 d0_20 vddpe_21 cap_ctrl10_term_20 cap_ctrl11_term_20
+  cap_ctrl12_term_20 cap_ctrl00_term_19 cap_ctrl01_term_19 cap_ctrl02_term_19
+  d1_19 td1_19 wen1_19 weny1_19 wr_mask1_term_19 vss_ast1_19 wr_mask0_term_19
+  vss_ast0_19 weny0_19 wen0_19 td0_19 d0_19 vddpe_20 cap_ctrl10_term_19
+  cap_ctrl11_term_19 cap_ctrl12_term_19 q1_18 cap_ctrl00_term_18
+  cap_ctrl01_term_18 cap_ctrl02_term_18 d1_18 td1_18 weny1_18
+  wr_mask1_term_18 vss_ast1_18 wr_mask0_term_18 vss_ast0_18 weny0_18 twen0_18
+  wen0_18 d0_18 vddpe_19 vddce_19 q0_18 cap_ctrl10_term_18 cap_ctrl11_term_18
+  cap_ctrl12_term_18 q1_17 cap_ctrl00_term_17 cap_ctrl01_term_17
+  cap_ctrl02_term_17 vddpe_18 d1_17 weny1_17 wr_mask1_term_17 vss_ast1_17
+  wr_mask0_term_17 vss_ast0_17 weny0_17 twen0_17 wen0_17 td0_17 d0_17
+  vddce_18 vnwp cap_ctrl10_term_17 cap_ctrl11_term_17 cap_ctrl12_term_17
+  cap_ctrl00_term_16 cap_ctrl01_term_16 cap_ctrl02_term_16 d1_16 td1_16
+  wr_mask1_term_16 vss_ast1_16 wr_mask0_term_16 vss_ast0_16 weny0_16 twen0_16
+  wen0_16 td0_16 d0_16 vddce_17 q0_16 cap_ctrl10_term_16 cap_ctrl11_term_16
+  cap_ctrl12_term_16 q1_15 cap_ctrl00_term_15 cap_ctrl01_term_15
+  cap_ctrl02_term_15 vddpe_16 d1_15 td1_15 wr_mask1_term_15 vss_ast1_15
+  wr_mask0_term_15 vss_ast0_15 weny0_15 td0_15 d0_15 vddce_16 q0_15
+  cap_ctrl10_term_15 cap_ctrl11_term_15 cap_ctrl12_term_15 q1_14
+  cap_ctrl00_term_14 cap_ctrl01_term_14 cap_ctrl02_term_14 vddpe_15 d1_14
+  td1_14 twen1_14 wr_mask1_term_14 vss_ast1_14 wr_mask0_term_14 vss_ast0_14
+  weny0_14 td0_14 d0_14 vddce_15 cap_ctrl10_term_14 cap_ctrl11_term_14
+  cap_ctrl12_term_14 q1_13 cap_ctrl00_term_13 cap_ctrl01_term_13
+  cap_ctrl02_term_13 td1_13 wr_mask1_term_13 vss_ast1_13 wr_mask0_term_13
+  vss_ast0_13 weny0_13 td0_13 d0_13 vddpe_14 vddce_14 q0_13
+  cap_ctrl10_term_13 cap_ctrl11_term_13 cap_ctrl12_term_13 q1_12
+  cap_ctrl00_term_12 cap_ctrl01_term_12 cap_ctrl02_term_12 vddpe_13 d1_12
+  weny1_12 wr_mask1_term_12 vss_ast1_12 wr_mask0_term_12 vss_ast0_12 weny0_12
+  twen0_12 wen0_12 d0_12 q0_12 cap_ctrl10_term_12 cap_ctrl11_term_12
+  cap_ctrl12_term_12 cap_ctrl00_term_11 cap_ctrl01_term_11 cap_ctrl02_term_11
+  d1_11 td1_11 wr_mask1_term_11 vss_ast1_11 wr_mask0_term_11 vss_ast0_11
+  weny0_11 twen0_11 wen0_11 td0_11 d0_11 vddce_12 q0_11 cap_ctrl10_term_11
+  cap_ctrl11_term_11 cap_ctrl12_term_11 prdyn fca2_6 fca2_5 fca2_4 fca2_3
+  fca2_2 fca2_1 cre2 fca1_0 vnwc_1 vddpe_11 dft_p2_term gwen_p2_term gtp_term
+  dbl_nbl_wa_turn_term dbl_nbl_wa_term pensi pso1 pso0 se so0 log1 dftrambyp
+  ret1n gwen clk a6 a7 a8 tgwen tcen ta0 ta1 ta2 ta3 ta4 ta5 gweny ceny ay0
+  ay1 ay2 ay3 ay4 ay5 cap_ctrl12_term_10 cap_ctrl11_term_10
+  cap_ctrl10_term_10 q0_10 vddce_10 d0_10 td0_10 weny0_10 vss_ast0_10
+  wr_mask0_term_10 vss_ast1_10 wr_mask1_term_10 twen1_10 td1_10 d1_10
+  cap_ctrl02_term_10 cap_ctrl01_term_10 cap_ctrl00_term_10 q1_10
+  cap_ctrl12_term_9 cap_ctrl11_term_9 cap_ctrl10_term_9 d0_9 weny0_9
+  vss_ast0_9 wr_mask0_term_9 vss_ast1_9 wr_mask1_term_9 twen1_9 td1_9
+  cap_ctrl02_term_9 cap_ctrl01_term_9 cap_ctrl00_term_9 q1_9
+  cap_ctrl12_term_8 cap_ctrl11_term_8 cap_ctrl10_term_8 vddce_8 d0_8 td0_8
+  weny0_8 vss_ast0_8 wr_mask0_term_8 vss_ast1_8 wr_mask1_term_8 td1_8 vddpe_8
+  cap_ctrl02_term_8 cap_ctrl01_term_8 cap_ctrl00_term_8 q1_8
+  cap_ctrl12_term_7 cap_ctrl11_term_7 cap_ctrl10_term_7 d0_7 td0_7 weny0_7
+  vss_ast0_7 wr_mask0_term_7 vss_ast1_7 wr_mask1_term_7 twen1_7 td1_7 vddpe_7
+  cap_ctrl02_term_7 cap_ctrl01_term_7 cap_ctrl00_term_7 cap_ctrl12_term_6
+  cap_ctrl11_term_6 cap_ctrl10_term_6 q0_6 vpw d0_6 twen0_6 weny0_6
+  vss_ast0_6 wr_mask0_term_6 vss_ast1_6 wr_mask1_term_6 twen1_6 d1_6
+  cap_ctrl02_term_6 cap_ctrl01_term_6 cap_ctrl00_term_6 q1_6
+  cap_ctrl12_term_5 cap_ctrl11_term_5 cap_ctrl10_term_5 vddce_5 d0_5 td0_5
+  weny0_5 vss_ast0_5 wr_mask0_term_5 vss_ast1_5 wr_mask1_term_5 twen1_5 td1_5
+  cap_ctrl02_term_5 cap_ctrl01_term_5 cap_ctrl00_term_5 q1_5
+  cap_ctrl12_term_4 cap_ctrl11_term_4 cap_ctrl10_term_4 d0_4 weny0_4
+  vss_ast0_4 wr_mask0_term_4 vss_ast1_4 wr_mask1_term_4 twen1_4
+  cap_ctrl02_term_4 cap_ctrl01_term_4 cap_ctrl00_term_4 vddce_4 q1_4
+  cap_ctrl12_term_3 cap_ctrl11_term_3 cap_ctrl10_term_3 d0_3 twen0_3 weny0_3
+  vss_ast0_3 wr_mask0_term_3 vss_ast1_3 wr_mask1_term_3 twen1_3
+  cap_ctrl02_term_3 cap_ctrl01_term_3 cap_ctrl00_term_3 q1_3
+  cap_ctrl12_term_2 cap_ctrl11_term_2 cap_ctrl10_term_2 d0_2 td0_2 weny0_2
+  vss_ast0_2 wr_mask0_term_2 vss_ast1_2 wr_mask1_term_2 twen1_2 td1_2
+  cap_ctrl02_term_2 cap_ctrl01_term_2 cap_ctrl00_term_2 q1_2
+  cap_ctrl12_term_1 cap_ctrl11_term_1 cap_ctrl10_term_1 d0_1 td0_1 twen0_1
+  weny0_1 vss_ast0_1 wr_mask0_term_1 vss_ast1_1 wr_mask1_term_1 twen1_1 d1_1
+  cap_ctrl02_term_1 cap_ctrl01_term_1 cap_ctrl00_term_1 vddce_1
+  cap_ctrl12_term_0 cap_ctrl11_term_0 cap_ctrl10_term_0 d0_0 weny0_0
+  vss_ast0_0 wr_mask0_term_0 vss_ast1_0 wr_mask1_term_0 wen1_0 td1_0
+  cap_ctrl02_term_0 cap_ctrl01_term_0 cap_ctrl00_term_0 q1_0 psi_0 vnwc_0
+  vsse_0 vnwc_2 vddce_23 d1_22 td1_22 wen1_22 twen1_22 weny0_22 twen0_22
+  wen0_22 td0_22 d0_22 q0_22 wen1_21 twen1_21 weny0_21 wen0_21 d0_21 q0_21
+  twen1_20 twen0_20 wen0_20 vddce_21 q0_20 q1_19 twen1_19 twen0_19 vddce_20
+  q0_19 wen1_18 twen1_18 td0_18 td1_17 wen1_17 twen1_17 q0_17 q1_16 wen1_16
+  twen1_16 weny1_16 vddpe_17 wen1_15 twen1_15 weny1_15 twen0_15 wen0_15
+  wen1_14 weny1_14 twen0_14 wen0_14 q0_14 d1_13 wen1_13 twen1_13 weny1_13
+  twen0_13 wen0_13 vddce_13 td1_12 wen1_12 twen1_12 td0_12 q1_11 wen1_11
+  twen1_11 weny1_11 vddpe_12 fca2_0 fca1_6 fca1_5 fca1_4 fca1_3 fca1_2 fca1_1
+  cre1 vsse_1 vddce_11 penso tpen pen so1 wablm1 wablm0 wabl rawlm1 rawlm0
+  rawl ten emas ema0 ema1 ema2 emaw0 emaw1 ret2n pgen cen a0 a3 a4 a5 a1 ta6
+  ta7 ta8 ta9 ta10 ay6 ay7 ay8 ay9 ay10 vddpe_10 wen0_10 twen0_10 weny1_10
+  wen1_10 q0_9 vddpe_9 td0_9 wen0_9 twen0_9 weny1_9 wen1_9 d1_9 vddce_9 q0_8
+  wen0_8 twen0_8 weny1_8 twen1_8 wen1_8 d1_8 q0_7 vddce_7 wen0_7 twen0_7
+  weny1_7 wen1_7 d1_7 q1_7 vddpe_6 td0_6 wen0_6 weny1_6 wen1_6 td1_6 vddce_6
+  q0_5 vddpe_5 wen0_5 twen0_5 weny1_5 wen1_5 d1_5 q0_4 vddpe_4 td0_4 wen0_4
+  twen0_4 weny1_4 wen1_4 td1_4 d1_4 q0_3 vddpe_3 td0_3 wen0_3 weny1_3 wen1_3
+  td1_3 d1_3 vddce_3 q0_2 vddce_2 wen0_2 twen0_2 weny1_2 wen1_2 d1_2 vddpe_2
+  q0_1 vddpe_1 wen0_1 weny1_1 wen1_1 td1_1 q1_1 q0_0 vddpe_0 td0_0 wen0_0
+  twen0_0 weny1_0 twen1_0 d1_0 vddce_0 vss si_0
** sram128x46botcaprow: 253 flat devices **
xcentre prdyn fca2_6 fca2_5 fca2_4 fca2_3 fca2_2 fca2_1 cre2 fca1_0 vss
+  dft_p2_term gwen_p2_term gtp_term dbl_nbl_wa_turn_term dbl_nbl_wa_term
+  pensi pso1 pso0 se so0 log1 dftrambyp ret1n gwen clk a6 a7 a8 tgwen tcen
+  ta0 ta1 ta2 ta3 ta4 ta5 gweny ay0 ay1 ay2 ay3 ay4 ay5 fca2_0 fca1_6 fca1_5
+  fca1_4 fca1_3 fca1_2 fca1_1 cre1 vpw vnwp vnwc_1 vsse_1 vddce_11 vddpe_11
+  penso tpen pen so1 wablm1 wablm0 wabl rawlm1 rawlm0 rawl ten emas ema0 ema1
+  ema2 emaw0 emaw1 ret2n pgen cen a0 a3 a4 a5 a1 ta6 ta7 ta8 ta9 ta10 ceny
+  ay6 ay7 ay8 ay9 ay10 sram128x46midbot_pgm
xleft vnwc_0 vnwp vpw vss vsse_0 psi_0 si_0 sram128x46botcorner
xleft_col_0 cap_ctrl12_term_0 cap_ctrl11_term_0 cap_ctrl10_term_0 vnwp vpw
+  vss_ast0_0 wr_mask0_term_0 vss_ast1_0 wr_mask1_term_0 weny1_0 twen1_0
+  vddpe_0 cap_ctrl02_term_0 cap_ctrl01_term_0 cap_ctrl00_term_0 vss q1_0 q0_0
+  d0_0 td0_0 wen0_0 twen0_0 weny0_0 wen1_0 td1_0 d1_0 vddce_0
+  sram128x46botcap2x2_rpt
xleft_col_1 cap_ctrl12_term_1 cap_ctrl11_term_1 cap_ctrl10_term_1 vnwp vpw
+  vss_ast0_1 wr_mask0_term_1 vss_ast1_1 wr_mask1_term_1 weny1_1 twen1_1
+  vddpe_1 cap_ctrl02_term_1 cap_ctrl01_term_1 cap_ctrl00_term_1 vss q1_1 q0_1
+  d0_1 td0_1 wen0_1 twen0_1 weny0_1 wen1_1 td1_1 d1_1 vddce_1
+  sram128x46botcap2x2_rpt
xleft_col_10 cap_ctrl12_term_10 cap_ctrl11_term_10 cap_ctrl10_term_10 vnwp vpw
+  vss_ast0_10 wr_mask0_term_10 vss_ast1_10 wr_mask1_term_10 weny1_10 twen1_10
+  vddpe_10 cap_ctrl02_term_10 cap_ctrl01_term_10 cap_ctrl00_term_10 vss q1_10
+  q0_10 d0_10 td0_10 wen0_10 twen0_10 weny0_10 wen1_10 td1_10 d1_10 vddce_10
+  sram128x46botcap2x2_rpt
xleft_col_2 cap_ctrl12_term_2 cap_ctrl11_term_2 cap_ctrl10_term_2 vnwp vpw
+  vss_ast0_2 wr_mask0_term_2 vss_ast1_2 wr_mask1_term_2 weny1_2 twen1_2
+  vddpe_2 cap_ctrl02_term_2 cap_ctrl01_term_2 cap_ctrl00_term_2 vss q1_2 q0_2
+  d0_2 td0_2 wen0_2 twen0_2 weny0_2 wen1_2 td1_2 d1_2 vddce_2
+  sram128x46botcap2x2_rpt
xleft_col_3 cap_ctrl12_term_3 cap_ctrl11_term_3 cap_ctrl10_term_3 vnwp vpw
+  vss_ast0_3 wr_mask0_term_3 vss_ast1_3 wr_mask1_term_3 weny1_3 twen1_3
+  vddpe_3 cap_ctrl02_term_3 cap_ctrl01_term_3 cap_ctrl00_term_3 vss q1_3 q0_3
+  d0_3 td0_3 wen0_3 twen0_3 weny0_3 wen1_3 td1_3 d1_3 vddce_3
+  sram128x46botcap2x2_rpt
xleft_col_4 cap_ctrl12_term_4 cap_ctrl11_term_4 cap_ctrl10_term_4 vnwp vpw
+  vss_ast0_4 wr_mask0_term_4 vss_ast1_4 wr_mask1_term_4 weny1_4 twen1_4
+  vddpe_4 cap_ctrl02_term_4 cap_ctrl01_term_4 cap_ctrl00_term_4 vss q1_4 q0_4
+  d0_4 td0_4 wen0_4 twen0_4 weny0_4 wen1_4 td1_4 d1_4 vddce_4
+  sram128x46botcap2x2_rpt
xleft_col_5 cap_ctrl12_term_5 cap_ctrl11_term_5 cap_ctrl10_term_5 vnwp vpw
+  vss_ast0_5 wr_mask0_term_5 vss_ast1_5 wr_mask1_term_5 weny1_5 twen1_5
+  vddpe_5 cap_ctrl02_term_5 cap_ctrl01_term_5 cap_ctrl00_term_5 vss q1_5 q0_5
+  d0_5 td0_5 wen0_5 twen0_5 weny0_5 wen1_5 td1_5 d1_5 vddce_5
+  sram128x46botcap2x2_rpt
xleft_col_6 cap_ctrl12_term_6 cap_ctrl11_term_6 cap_ctrl10_term_6 vnwp vpw
+  vss_ast0_6 wr_mask0_term_6 vss_ast1_6 wr_mask1_term_6 weny1_6 twen1_6
+  vddpe_6 cap_ctrl02_term_6 cap_ctrl01_term_6 cap_ctrl00_term_6 vss q1_6 q0_6
+  d0_6 td0_6 wen0_6 twen0_6 weny0_6 wen1_6 td1_6 d1_6 vddce_6
+  sram128x46botcap2x2_rpt
xleft_col_7 cap_ctrl12_term_7 cap_ctrl11_term_7 cap_ctrl10_term_7 vnwp vpw
+  vss_ast0_7 wr_mask0_term_7 vss_ast1_7 wr_mask1_term_7 weny1_7 twen1_7
+  vddpe_7 cap_ctrl02_term_7 cap_ctrl01_term_7 cap_ctrl00_term_7 vss q1_7 q0_7
+  d0_7 td0_7 wen0_7 twen0_7 weny0_7 wen1_7 td1_7 d1_7 vddce_7
+  sram128x46botcap2x2_rpt
xleft_col_8 cap_ctrl12_term_8 cap_ctrl11_term_8 cap_ctrl10_term_8 vnwp vpw
+  vss_ast0_8 wr_mask0_term_8 vss_ast1_8 wr_mask1_term_8 weny1_8 twen1_8
+  vddpe_8 cap_ctrl02_term_8 cap_ctrl01_term_8 cap_ctrl00_term_8 vss q1_8 q0_8
+  d0_8 td0_8 wen0_8 twen0_8 weny0_8 wen1_8 td1_8 d1_8 vddce_8
+  sram128x46botcap2x2_rpt
xleft_col_9 cap_ctrl12_term_9 cap_ctrl11_term_9 cap_ctrl10_term_9 vnwp vpw
+  vss_ast0_9 wr_mask0_term_9 vss_ast1_9 wr_mask1_term_9 weny1_9 twen1_9
+  vddpe_9 cap_ctrl02_term_9 cap_ctrl01_term_9 cap_ctrl00_term_9 vss q1_9 q0_9
+  d0_9 td0_9 wen0_9 twen0_9 weny0_9 wen1_9 td1_9 d1_9 vddce_9
+  sram128x46botcap2x2_rpt
xright vnwc_2 vnwp vpw vss vsse_2 psi_1 si_1 sram128x46botcorner
xright_col_0 cap_ctrl12_term_11 cap_ctrl11_term_11 cap_ctrl10_term_11 vnwp vpw
+  vss_ast0_11 wr_mask0_term_11 vss_ast1_11 wr_mask1_term_11 weny1_11 twen1_11
+  vddpe_12 cap_ctrl02_term_11 cap_ctrl01_term_11 cap_ctrl00_term_11 vss q1_11
+  q0_11 d0_11 td0_11 wen0_11 twen0_11 weny0_11 wen1_11 td1_11 d1_11 vddce_12
+  sram128x46botcap2x2_rpt
xright_col_1 cap_ctrl12_term_12 cap_ctrl11_term_12 cap_ctrl10_term_12 vnwp vpw
+  vss_ast0_12 wr_mask0_term_12 vss_ast1_12 wr_mask1_term_12 weny1_12 twen1_12
+  vddpe_13 cap_ctrl02_term_12 cap_ctrl01_term_12 cap_ctrl00_term_12 vss q1_12
+  q0_12 d0_12 td0_12 wen0_12 twen0_12 weny0_12 wen1_12 td1_12 d1_12 vddce_13
+  sram128x46botcap2x2_rpt
xright_col_10 cap_ctrl12_term_21 cap_ctrl11_term_21 cap_ctrl10_term_21 vnwp
+  vpw vss_ast0_21 wr_mask0_term_21 vss_ast1_21 wr_mask1_term_21 weny1_21
+  twen1_21 vddpe_22 cap_ctrl02_term_21 cap_ctrl01_term_21 cap_ctrl00_term_21
+  vss q1_21 q0_21 d0_21 td0_21 wen0_21 twen0_21 weny0_21 wen1_21 td1_21 d1_21
+  vddce_22 sram128x46botcap2x2_rpt
xright_col_11 cap_ctrl12_term_22 cap_ctrl11_term_22 cap_ctrl10_term_22 vnwp
+  vpw vss_ast0_22 wr_mask0_term_22 vss_ast1_22 wr_mask1_term_22 weny1_22
+  twen1_22 vddpe_23 cap_ctrl02_term_22 cap_ctrl01_term_22 cap_ctrl00_term_22
+  vss q1_22 q0_22 d0_22 td0_22 wen0_22 twen0_22 weny0_22 wen1_22 td1_22 d1_22
+  vddce_23 sram128x46botcap2x2_rpt
xright_col_2 cap_ctrl12_term_13 cap_ctrl11_term_13 cap_ctrl10_term_13 vnwp vpw
+  vss_ast0_13 wr_mask0_term_13 vss_ast1_13 wr_mask1_term_13 weny1_13 twen1_13
+  vddpe_14 cap_ctrl02_term_13 cap_ctrl01_term_13 cap_ctrl00_term_13 vss q1_13
+  q0_13 d0_13 td0_13 wen0_13 twen0_13 weny0_13 wen1_13 td1_13 d1_13 vddce_14
+  sram128x46botcap2x2_rpt
xright_col_3 cap_ctrl12_term_14 cap_ctrl11_term_14 cap_ctrl10_term_14 vnwp vpw
+  vss_ast0_14 wr_mask0_term_14 vss_ast1_14 wr_mask1_term_14 weny1_14 twen1_14
+  vddpe_15 cap_ctrl02_term_14 cap_ctrl01_term_14 cap_ctrl00_term_14 vss q1_14
+  q0_14 d0_14 td0_14 wen0_14 twen0_14 weny0_14 wen1_14 td1_14 d1_14 vddce_15
+  sram128x46botcap2x2_rpt
xright_col_4 cap_ctrl12_term_15 cap_ctrl11_term_15 cap_ctrl10_term_15 vnwp vpw
+  vss_ast0_15 wr_mask0_term_15 vss_ast1_15 wr_mask1_term_15 weny1_15 twen1_15
+  vddpe_16 cap_ctrl02_term_15 cap_ctrl01_term_15 cap_ctrl00_term_15 vss q1_15
+  q0_15 d0_15 td0_15 wen0_15 twen0_15 weny0_15 wen1_15 td1_15 d1_15 vddce_16
+  sram128x46botcap2x2_rpt
xright_col_5 cap_ctrl12_term_16 cap_ctrl11_term_16 cap_ctrl10_term_16 vnwp vpw
+  vss_ast0_16 wr_mask0_term_16 vss_ast1_16 wr_mask1_term_16 weny1_16 twen1_16
+  vddpe_17 cap_ctrl02_term_16 cap_ctrl01_term_16 cap_ctrl00_term_16 vss q1_16
+  q0_16 d0_16 td0_16 wen0_16 twen0_16 weny0_16 wen1_16 td1_16 d1_16 vddce_17
+  sram128x46botcap2x2_rpt
xright_col_6 cap_ctrl12_term_17 cap_ctrl11_term_17 cap_ctrl10_term_17 vnwp vpw
+  vss_ast0_17 wr_mask0_term_17 vss_ast1_17 wr_mask1_term_17 weny1_17 twen1_17
+  vddpe_18 cap_ctrl02_term_17 cap_ctrl01_term_17 cap_ctrl00_term_17 vss q1_17
+  q0_17 d0_17 td0_17 wen0_17 twen0_17 weny0_17 wen1_17 td1_17 d1_17 vddce_18
+  sram128x46botcap2x2_rpt
xright_col_7 cap_ctrl12_term_18 cap_ctrl11_term_18 cap_ctrl10_term_18 vnwp vpw
+  vss_ast0_18 wr_mask0_term_18 vss_ast1_18 wr_mask1_term_18 weny1_18 twen1_18
+  vddpe_19 cap_ctrl02_term_18 cap_ctrl01_term_18 cap_ctrl00_term_18 vss q1_18
+  q0_18 d0_18 td0_18 wen0_18 twen0_18 weny0_18 wen1_18 td1_18 d1_18 vddce_19
+  sram128x46botcap2x2_rpt
xright_col_8 cap_ctrl12_term_19 cap_ctrl11_term_19 cap_ctrl10_term_19 vnwp vpw
+  vss_ast0_19 wr_mask0_term_19 vss_ast1_19 wr_mask1_term_19 weny1_19 twen1_19
+  vddpe_20 cap_ctrl02_term_19 cap_ctrl01_term_19 cap_ctrl00_term_19 vss q1_19
+  q0_19 d0_19 td0_19 wen0_19 twen0_19 weny0_19 wen1_19 td1_19 d1_19 vddce_20
+  sram128x46botcap2x2_rpt
xright_col_9 cap_ctrl12_term_20 cap_ctrl11_term_20 cap_ctrl10_term_20 vnwp vpw
+  vss_ast0_20 wr_mask0_term_20 vss_ast1_20 wr_mask1_term_20 weny1_20 twen1_20
+  vddpe_21 cap_ctrl02_term_20 cap_ctrl01_term_20 cap_ctrl00_term_20 vss q1_20
+  q0_20 d0_20 td0_20 wen0_20 twen0_20 weny0_20 wen1_20 td1_20 d1_20 vddce_21
+  sram128x46botcap2x2_rpt
.ends sram128x46botcaprow
****
.subckt sram128x46colm2x2_noopt q0 q1 bl0 bl1 bl2 bl3 blprech cap_ctrl00_term
+  cap_ctrl01_term cap_ctrl02_term cap_ctrl10_term cap_ctrl11_term
+  cap_ctrl12_term d0 d1 dwl_main dwl_mainbreak dwl_turn dwl_turnbreak iwclk0
+  iwclk1 log0 log0_sa nact_cc nbl0 nbl1 nbl2 nbl3 nsae nyr0 nyr1 nyr2 nyr3
+  rdmux saprech vddc vddce vddp vddpe vnwp vpw vss vss_ast0 vss_ast1 vsse
+  weny0_term weny1_term yw0 yw1 yw2 yw3
** sram128x46colm2x2_noopt: 136 flat devices **
mi20.mxna1 nd0 d0 vss vpw nch_mac W=0.15U L=0.03U NF=1
mi20.mxpa1 nd0 d0 vddp vnwp pch_mac W=0.3U L=0.03U NF=1
mi46.mxna1 q1 sao1 vss vpw nch_mac W=1.5U L=0.03U NF=4
mi46.mxpa1 q1 sao1 vddpe vnwp pch_mac W=2.4U L=0.03U NF=4
mi47.mxna1 nd1 d1 vss vpw nch_mac W=0.15U L=0.03U NF=1
mi47.mxpa1 nd1 d1 vddp vnwp pch_mac W=0.3U L=0.03U NF=1
mi52.mxn4_0 vss dwl_main vss vpw nch_mac W=0.27U L=0.03U NF=1
mi52.mxn4_1 vss dwl_main vss vpw nch_mac W=0.27U L=0.03U NF=1
mi55.mxna1 q0 sao0 vss vpw nch_mac W=1.5U L=0.03U NF=4
mi55.mxpa1 q0 sao0 vddpe vnwp pch_mac W=2.4U L=0.03U NF=4
micd.icdrw0._mx0.mxn0 nbl0 yw0 wrzero0 vpw nch_mac W=0.96U L=0.03U NF=2
micd.icdrw0._mx0.mxn1 bl0 yw0 wrone0 vpw nch_mac W=0.96U L=0.03U NF=2
micd.icdrw0._mx0.mxp1 nbl0 icd.nblprech vddp vnwp pch_mac W=0.5U L=0.03U NF=1
micd.icdrw0._mx0.mxp10 icd.icdrw0._mx0.vvdp nact_cc vddp vnwp pch_mac W=0.49U
+  L=0.03U NF=1
micd.icdrw0._mx0.mxp3 icd.nsd0 nyr0 nbl0 vnwp pch_mac W=0.45U L=0.035U NF=1
micd.icdrw0._mx0.mxp4 icd.sd0 nyr0 bl0 vnwp pch_mac W=0.45U L=0.035U NF=1
micd.icdrw0._mx0.mxp5 nbl0 bl0 icd.icdrw0._mx0.vvdp vnwp pch_mac W=0.28U
+  L=0.035U NF=1
micd.icdrw0._mx0.mxp7 bl0 icd.nblprech vddp vnwp pch_mac W=0.5U L=0.03U NF=1
micd.icdrw0._mx0.mxp8 nbl0 icd.nblprech bl0 vnwp pch_mac W=0.5U L=0.03U NF=1
micd.icdrw0._mx0.mxp9 bl0 nbl0 icd.icdrw0._mx0.vvdp vnwp pch_mac W=0.28U
+  L=0.035U NF=1
micd.icdrw0._mx1.mxn0 nbl1 yw1 wrzero0 vpw nch_mac W=0.96U L=0.03U NF=2
micd.icdrw0._mx1.mxn1 bl1 yw1 wrone0 vpw nch_mac W=0.96U L=0.03U NF=2
micd.icdrw0._mx1.mxp1 nbl1 icd.nblprech vddp vnwp pch_mac W=0.5U L=0.03U NF=1
micd.icdrw0._mx1.mxp10 icd.icdrw0._mx1.vvdp nact_cc vddp vnwp pch_mac W=0.49U
+  L=0.03U NF=1
micd.icdrw0._mx1.mxp3 icd.nsd0 nyr1 nbl1 vnwp pch_mac W=0.45U L=0.035U NF=1
micd.icdrw0._mx1.mxp4 icd.sd0 nyr1 bl1 vnwp pch_mac W=0.45U L=0.035U NF=1
micd.icdrw0._mx1.mxp5 nbl1 bl1 icd.icdrw0._mx1.vvdp vnwp pch_mac W=0.28U
+  L=0.035U NF=1
micd.icdrw0._mx1.mxp7 bl1 icd.nblprech vddp vnwp pch_mac W=0.5U L=0.03U NF=1
micd.icdrw0._mx1.mxp8 nbl1 icd.nblprech bl1 vnwp pch_mac W=0.5U L=0.03U NF=1
micd.icdrw0._mx1.mxp9 bl1 nbl1 icd.icdrw0._mx1.vvdp vnwp pch_mac W=0.28U
+  L=0.035U NF=1
micd.icdrw1._mx0.mxn0 nbl2 yw2 wrzero1 vpw nch_mac W=0.96U L=0.03U NF=2
micd.icdrw1._mx0.mxn1 bl2 yw2 wrone1 vpw nch_mac W=0.96U L=0.03U NF=2
micd.icdrw1._mx0.mxp1 nbl2 icd.nblprech vddp vnwp pch_mac W=0.5U L=0.03U NF=1
micd.icdrw1._mx0.mxp10 icd.icdrw1._mx0.vvdp nact_cc vddp vnwp pch_mac W=0.49U
+  L=0.03U NF=1
micd.icdrw1._mx0.mxp3 icd.nsd1 nyr2 nbl2 vnwp pch_mac W=0.45U L=0.035U NF=1
micd.icdrw1._mx0.mxp4 icd.sd1 nyr2 bl2 vnwp pch_mac W=0.45U L=0.035U NF=1
micd.icdrw1._mx0.mxp5 nbl2 bl2 icd.icdrw1._mx0.vvdp vnwp pch_mac W=0.28U
+  L=0.035U NF=1
micd.icdrw1._mx0.mxp7 bl2 icd.nblprech vddp vnwp pch_mac W=0.5U L=0.03U NF=1
micd.icdrw1._mx0.mxp8 nbl2 icd.nblprech bl2 vnwp pch_mac W=0.5U L=0.03U NF=1
micd.icdrw1._mx0.mxp9 bl2 nbl2 icd.icdrw1._mx0.vvdp vnwp pch_mac W=0.28U
+  L=0.035U NF=1
micd.icdrw1._mx1.mxn0 nbl3 yw3 wrzero1 vpw nch_mac W=0.96U L=0.03U NF=2
micd.icdrw1._mx1.mxn1 bl3 yw3 wrone1 vpw nch_mac W=0.96U L=0.03U NF=2
micd.icdrw1._mx1.mxp1 nbl3 icd.nblprech vddp vnwp pch_mac W=0.5U L=0.03U NF=1
micd.icdrw1._mx1.mxp10 icd.icdrw1._mx1.vvdp nact_cc vddp vnwp pch_mac W=0.49U
+  L=0.03U NF=1
micd.icdrw1._mx1.mxp3 icd.nsd1 nyr3 nbl3 vnwp pch_mac W=0.45U L=0.035U NF=1
micd.icdrw1._mx1.mxp4 icd.sd1 nyr3 bl3 vnwp pch_mac W=0.45U L=0.035U NF=1
micd.icdrw1._mx1.mxp5 nbl3 bl3 icd.icdrw1._mx1.vvdp vnwp pch_mac W=0.28U
+  L=0.035U NF=1
micd.icdrw1._mx1.mxp7 bl3 icd.nblprech vddp vnwp pch_mac W=0.5U L=0.03U NF=1
micd.icdrw1._mx1.mxp8 nbl3 icd.nblprech bl3 vnwp pch_mac W=0.5U L=0.03U NF=1
micd.icdrw1._mx1.mxp9 bl3 nbl3 icd.icdrw1._mx1.vvdp vnwp pch_mac W=0.28U
+  L=0.035U NF=1
micd.isa.isa0.mxn17 icd.nsd0 icd.sd0 icd.isa.saint0 vpw nch_mac W=1.68U
+  L=0.06U NF=2
micd.isa.isa0.mxn18 icd.isa.saint0 icd.sae vss vpw nch_mac W=0.84U L=0.035U
+  NF=1
micd.isa.isa0.mxn19 icd.sd0 icd.nsd0 icd.isa.saint0 vpw nch_mac W=1.68U
+  L=0.06U NF=2
micd.isa.isa0.mxp24 icd.nsd0 icd.isa.nsaprech vddp vnwp pch_mac W=0.28U
+  L=0.03U NF=1
micd.isa.isa0.mxp25 icd.nsd0 icd.isa.nsaprech icd.sd0 vnwp pch_mac W=0.28U
+  L=0.03U NF=2
micd.isa.isa0.mxp26 icd.sd0 icd.isa.nsaprech vddp vnwp pch_mac W=0.28U L=0.03U
+  NF=1
micd.isa.isa0.mxp27 icd.nsd0 icd.sd0 vddp vnwp pch_mac W=0.28U L=0.03U NF=1
micd.isa.isa0.mxp28 icd.sd0 icd.nsd0 vddp vnwp pch_mac W=0.28U L=0.03U NF=1
micd.isa.isa1.mxn17 icd.nsd1 icd.sd1 icd.isa.saint1 vpw nch_mac W=1.68U
+  L=0.06U NF=2
micd.isa.isa1.mxn18 icd.isa.saint1 icd.sae vss vpw nch_mac W=0.84U L=0.035U
+  NF=1
micd.isa.isa1.mxn19 icd.sd1 icd.nsd1 icd.isa.saint1 vpw nch_mac W=1.68U
+  L=0.06U NF=2
micd.isa.isa1.mxp24 icd.nsd1 icd.isa.nsaprech vddp vnwp pch_mac W=0.28U
+  L=0.03U NF=1
micd.isa.isa1.mxp25 icd.nsd1 icd.isa.nsaprech icd.sd1 vnwp pch_mac W=0.28U
+  L=0.03U NF=2
micd.isa.isa1.mxp26 icd.sd1 icd.isa.nsaprech vddp vnwp pch_mac W=0.28U L=0.03U
+  NF=1
micd.isa.isa1.mxp27 icd.nsd1 icd.sd1 vddp vnwp pch_mac W=0.28U L=0.03U NF=1
micd.isa.isa1.mxp28 icd.sd1 icd.nsd1 vddp vnwp pch_mac W=0.28U L=0.03U NF=1
micd.isa.mxn0 icd.isa.nsaprech saprech icd.isa.n1 vpw nch_mac W=0.27U L=0.03U
+  NF=1
micd.isa.mxn1 icd.isa.n1 nsae vss vpw nch_mac W=0.27U L=0.03U NF=1
micd.isa.mxn15 icd.sae nsae vss vpw nch_mac W=0.4U L=0.03U NF=2
micd.isa.mxp0 icd.isa.nsaprech saprech vddp vnwp pch_mac W=0.32U L=0.03U NF=1
micd.isa.mxp1 icd.isa.nsaprech nsae vddp vnwp pch_mac W=0.32U L=0.03U NF=1
micd.isa.mxp15 icd.sae nsae vddp vnwp pch_mac W=0.5U L=0.03U NF=2
micd.isasdl0.i64.mxna1 icd.isasdl0.sd_lat sao0 vss vpw nch_mac W=0.21U L=0.03U
+  NF=1
micd.isasdl0.i64.mxpa1 icd.isasdl0.sd_lat sao0 vddp vnwp pch_mac W=0.21U
+  L=0.03U NF=1
micd.isasdl0.mxn3 icd.isasdl0.n1 icd.sae vss vpw nch_mac W=0.8U L=0.03U NF=2
micd.isasdl0.mxn4 sao0 icd.nsd0 sao0 vpw nch_mac W=0.8U L=0.03U NF=2
micd.isasdl0.mxn9 icd.isasdl0.n1 icd.isasdl0.sd_lat vss vpw nch_mac W=0.4U
+  L=0.03U NF=1
micd.isasdl0.mxp4 sao0 icd.nsd0 sao0 vnwp pch_mac W=0.98U L=0.03U NF=2
micd.isasdl0.mxp5 sao0 icd.isasdl0.sd_lat icd.isasdl0.p1 vnwp pch_mac W=0.49U
+  L=0.03U NF=1
micd.isasdl0.mxp6 icd.isasdl0.p1 icd.sae vddp vnwp pch_mac W=0.49U L=0.03U
+  NF=1
micd.isasdl0.mx_sd_n sao0 icd.sd0 icd.isasdl0.n1 vpw nch_mac W=0.8U L=0.03U
+  NF=2
micd.isasdl0.mx_sd_p sao0 icd.sd0 vddp vnwp pch_mac W=0.98U L=0.03U NF=2
micd.isasdl1.i64.mxna1 icd.isasdl1.sd_lat sao1 vss vpw nch_mac W=0.21U L=0.03U
+  NF=1
micd.isasdl1.i64.mxpa1 icd.isasdl1.sd_lat sao1 vddp vnwp pch_mac W=0.21U
+  L=0.03U NF=1
micd.isasdl1.mxn3 icd.isasdl1.n1 icd.sae vss vpw nch_mac W=0.8U L=0.03U NF=2
micd.isasdl1.mxn4 sao1 icd.nsd1 sao1 vpw nch_mac W=0.8U L=0.03U NF=2
micd.isasdl1.mxn9 icd.isasdl1.n1 icd.isasdl1.sd_lat vss vpw nch_mac W=0.4U
+  L=0.03U NF=1
micd.isasdl1.mxp4 sao1 icd.nsd1 sao1 vnwp pch_mac W=0.98U L=0.03U NF=2
micd.isasdl1.mxp5 sao1 icd.isasdl1.sd_lat icd.isasdl1.p1 vnwp pch_mac W=0.49U
+  L=0.03U NF=1
micd.isasdl1.mxp6 icd.isasdl1.p1 icd.sae vddp vnwp pch_mac W=0.49U L=0.03U
+  NF=1
micd.isasdl1.mx_sd_n sao1 icd.sd1 icd.isasdl1.n1 vpw nch_mac W=0.8U L=0.03U
+  NF=2
micd.isasdl1.mx_sd_p sao1 icd.sd1 vddp vnwp pch_mac W=0.98U L=0.03U NF=2
micd.mxn15 icd.nblprech blprech vss vpw nch_mac W=0.34U L=0.035U NF=2
micd.mxp15 icd.nblprech blprech vddp vnwp pch_mac W=0.705U L=0.035U NF=3
miwr.i221.mxna1 iwr.nwclk iwclk0 vss vpw nch_mac W=0.4U L=0.035U NF=1
miwr.i221.mxpa1 iwr.nwclk iwclk0 vddp vnwp pch_mac W=0.5U L=0.035U NF=1
miwr.i224.mxna1 iwr.wclk iwr.nwclk vss vpw nch_mac W=0.4U L=0.035U NF=1
miwr.i224.mxpa1 iwr.wclk iwr.nwclk vddp vnwp pch_mac W=0.4U L=0.035U NF=1
miwr._dlat0.i48.mxnoe iwr.iwrzero0 iwr.nwclk nd0 vpw nch_mac W=0.14U L=0.035U
+  NF=1
miwr._dlat0.i48.mxpoen iwr.iwrzero0 iwr.wclk nd0 vnwp pch_mac W=0.14U L=0.035U
+  NF=1
miwr._dlat0.i50.mxna1 iwr.iwrone0 iwr.iwrzero0 vss vpw nch_mac W=0.5U L=0.035U
+  NF=2
miwr._dlat0.i50.mxpa1 iwr.iwrone0 iwr.iwrzero0 vddp vnwp pch_mac W=0.7U
+  L=0.035U NF=2
miwr._dlat0.i55.mxna1 iwr._dlat0.i55.n1 iwr.iwrone0 vss vpw nch_mac W=0.1U
+  L=0.035U NF=1
miwr._dlat0.i55.mxnoe iwr.iwrzero0 iwr.wclk iwr._dlat0.i55.n1 vpw nch_mac
+  W=0.1U L=0.035U NF=1
miwr._dlat0.i55.mxpa1 iwr._dlat0.i55.p1 iwr.iwrone0 vddp vnwp pch_mac W=0.1U
+  L=0.035U NF=1
miwr._dlat0.i55.mxpoen iwr.iwrzero0 iwr.nwclk iwr._dlat0.i55.p1 vnwp pch_mac
+  W=0.1U L=0.035U NF=1
miwr._dlat1.i48.mxnoe iwr.iwrzero1 iwr.nwclk nd1 vpw nch_mac W=0.14U L=0.035U
+  NF=1
miwr._dlat1.i48.mxpoen iwr.iwrzero1 iwr.wclk nd1 vnwp pch_mac W=0.14U L=0.035U
+  NF=1
miwr._dlat1.i50.mxna1 iwr.iwrone1 iwr.iwrzero1 vss vpw nch_mac W=0.5U L=0.035U
+  NF=2
miwr._dlat1.i50.mxpa1 iwr.iwrone1 iwr.iwrzero1 vddp vnwp pch_mac W=0.7U
+  L=0.035U NF=2
miwr._dlat1.i55.mxna1 iwr._dlat1.i55.n1 iwr.iwrone1 vss vpw nch_mac W=0.1U
+  L=0.035U NF=1
miwr._dlat1.i55.mxnoe iwr.iwrzero1 iwr.wclk iwr._dlat1.i55.n1 vpw nch_mac
+  W=0.1U L=0.035U NF=1
miwr._dlat1.i55.mxpa1 iwr._dlat1.i55.p1 iwr.iwrone1 vddp vnwp pch_mac W=0.1U
+  L=0.035U NF=1
miwr._dlat1.i55.mxpoen iwr.iwrzero1 iwr.nwclk iwr._dlat1.i55.p1 vnwp pch_mac
+  W=0.1U L=0.035U NF=1
miwr._tri0.mxn0 wrone0 iwr._tri0.net10 vss_ast0 vpw nch_mac W=2.3U L=0.035U
+  NF=4
miwr._tri0.mxn1 wrzero0 iwr._tri0.net9 vss_ast0 vpw nch_mac W=2.3U L=0.035U
+  NF=4
miwr._tri0.mxn3 iwr._tri0.net10 iwr.iwrone0 vss vpw nch_mac W=0.2U L=0.035U
+  NF=1
miwr._tri0.mxn4 iwr._tri0.net9 iwr.iwrzero0 vss vpw nch_mac W=0.2U L=0.035U
+  NF=1
miwr._tri0.mxn6 iwr._tri0.net9 iwr.nwclk vss vpw nch_mac W=0.2U L=0.035U NF=1
miwr._tri0.mxn7 iwr._tri0.net10 iwr.nwclk vss vpw nch_mac W=0.2U L=0.035U NF=1
miwr._tri0.mxp1 wrone0 iwr.wclk vddp vnwp pch_mac W=0.3U L=0.035U NF=1
miwr._tri0.mxp2 wrzero0 iwr.wclk vddp vnwp pch_mac W=0.3U L=0.035U NF=1
miwr._tri0.mxp4 iwr._tri0.p1 iwr.nwclk vddp vnwp pch_mac W=0.38U L=0.035U NF=1
miwr._tri0.mxp5 iwr._tri0.net9 iwr.iwrzero0 iwr._tri0.p1 vnwp pch_mac W=0.38U
+  L=0.035U NF=1
miwr._tri0.mxp6 iwr._tri0.net10 iwr.iwrone0 iwr._tri0.p1 vnwp pch_mac W=0.38U
+  L=0.035U NF=1
miwr._tri1.mxn0 wrone1 iwr._tri1.net10 vss_ast1 vpw nch_mac W=2.3U L=0.035U
+  NF=4
miwr._tri1.mxn1 wrzero1 iwr._tri1.net9 vss_ast1 vpw nch_mac W=2.3U L=0.035U
+  NF=4
miwr._tri1.mxn3 iwr._tri1.net10 iwr.iwrone1 vss vpw nch_mac W=0.2U L=0.035U
+  NF=1
miwr._tri1.mxn4 iwr._tri1.net9 iwr.iwrzero1 vss vpw nch_mac W=0.2U L=0.035U
+  NF=1
miwr._tri1.mxn6 iwr._tri1.net9 iwr.nwclk vss vpw nch_mac W=0.2U L=0.035U NF=1
miwr._tri1.mxn7 iwr._tri1.net10 iwr.nwclk vss vpw nch_mac W=0.2U L=0.035U NF=1
miwr._tri1.mxp1 wrone1 iwr.wclk vddp vnwp pch_mac W=0.3U L=0.035U NF=1
miwr._tri1.mxp2 wrzero1 iwr.wclk vddp vnwp pch_mac W=0.3U L=0.035U NF=1
miwr._tri1.mxp4 iwr._tri1.p1 iwr.nwclk vddp vnwp pch_mac W=0.38U L=0.035U NF=1
miwr._tri1.mxp5 iwr._tri1.net9 iwr.iwrzero1 iwr._tri1.p1 vnwp pch_mac W=0.38U
+  L=0.035U NF=1
miwr._tri1.mxp6 iwr._tri1.net10 iwr.iwrone1 iwr._tri1.p1 vnwp pch_mac W=0.38U
+  L=0.035U NF=1
.ends sram128x46colm2x2_noopt
****
.subckt sram128x46iocdm_l bl0_10 nbl0_10 nbl1_10 bl1_10 vddc_10 bl2_10 nbl2_10
+  nbl3_10 bl3_10 bl0_9 nbl0_9 nbl1_9 bl1_9 vddc_9 bl2_9 nbl2_9 nbl3_9 bl3_9
+  bl0_8 nbl0_8 nbl1_8 bl1_8 vddc_8 bl2_8 nbl2_8 nbl3_8 bl3_8 bl0_7 nbl0_7
+  nbl1_7 bl1_7 vddc_7 bl2_7 nbl2_7 nbl3_7 bl3_7 bl0_6 nbl0_6 nbl1_6 bl1_6
+  vddc_6 bl2_6 nbl2_6 nbl3_6 bl3_6 bl0_5 nbl0_5 nbl1_5 bl1_5 vddce vddc_5
+  bl2_5 nbl2_5 nbl3_5 bl3_5 bl0_4 nbl0_4 nbl1_4 bl1_4 vddp vddc_4 bl2_4
+  nbl2_4 nbl3_4 bl3_4 bl0_3 nbl0_3 nbl1_3 bl1_3 vddc_3 bl2_3 nbl2_3 nbl3_3
+  bl3_3 bl0_2 nbl0_2 nbl1_2 bl1_2 vddc_2 bl2_2 nbl2_2 nbl3_2 bl3_2 bl0_1
+  nbl0_1 nbl1_1 bl1_1 vddc_1 bl2_1 nbl2_1 nbl3_1 bl3_1 bl0_0 nbl0_0 nbl1_0
+  bl1_0 vddc_0 bl2_0 nbl2_0 nbl3_0 bl3_0 cap_ctrl12_term_10
+  cap_ctrl11_term_10 cap_ctrl10_term_10 q0_10 d0_10 weny0_term_10 vss_ast0_10
+  vss_ast1_10 weny1_term_10 d1_10 q1_10 cap_ctrl12_term_9 cap_ctrl11_term_9
+  cap_ctrl10_term_9 q0_9 d0_9 weny0_term_9 vss_ast0_9 vss_ast1_9 weny1_term_9
+  d1_9 q1_9 cap_ctrl12_term_8 cap_ctrl11_term_8 cap_ctrl10_term_8 q0_8 d0_8
+  weny0_term_8 vss_ast0_8 vss_ast1_8 weny1_term_8 d1_8 q1_8 cap_ctrl12_term_7
+  cap_ctrl11_term_7 cap_ctrl10_term_7 q0_7 d0_7 weny0_term_7 vss_ast0_7
+  vss_ast1_7 weny1_term_7 vpw d1_7 q1_7 cap_ctrl12_term_6 cap_ctrl11_term_6
+  cap_ctrl10_term_6 q0_6 d0_6 weny0_term_6 vss_ast0_6 vss_ast1_6 weny1_term_6
+  d1_6 q1_6 cap_ctrl12_term_5 cap_ctrl11_term_5 cap_ctrl10_term_5 q0_5 d0_5
+  weny0_term_5 vss_ast0_5 vss_ast1_5 weny1_term_5 d1_5 q1_5 cap_ctrl12_term_4
+  cap_ctrl11_term_4 cap_ctrl10_term_4 q0_4 d0_4 weny0_term_4 vss_ast0_4
+  vss_ast1_4 weny1_term_4 d1_4 q1_4 cap_ctrl12_term_3 cap_ctrl11_term_3
+  cap_ctrl10_term_3 q0_3 d0_3 weny0_term_3 vss_ast0_3 vss_ast1_3 weny1_term_3
+  d1_3 q1_3 cap_ctrl12_term_2 cap_ctrl11_term_2 cap_ctrl10_term_2 q0_2 d0_2
+  weny0_term_2 vss_ast0_2 vss_ast1_2 weny1_term_2 d1_2 q1_2 cap_ctrl12_term_1
+  cap_ctrl11_term_1 cap_ctrl10_term_1 q0_1 d0_1 weny0_term_1 vss_ast0_1
+  vss_ast1_1 weny1_term_1 d1_1 q1_1 cap_ctrl12_term_0 cap_ctrl11_term_0
+  cap_ctrl10_term_0 q0_0 d0_0 weny0_term_0 vss_ast0_0 log0 vss_ast1_0
+  weny1_term_0 d1_0 q1_0 yw3 yw2 nyr3 nyr2 dwl_mainbreak blprech nact_cc yw1
+  yw0 nyr1 nyr0 rdmux nsae saprech log0_sa iwclk0 iwclk1 dwl_main dwl_turn
** sram128x46iocdm_l: 1496 flat devices **
xl_io_1 q0_1 q1_1 bl0_1 bl1_1 bl2_1 bl3_1 blprech cap_ctrl00_term_3
+  cap_ctrl01_term_5 cap_ctrl02_term_7 cap_ctrl10_term_1 cap_ctrl11_term_1
+  cap_ctrl12_term_1 d0_1 d1_1 dwl_main dwl_main dwl_turn dwl_turn iwclk0
+  iwclk1 log0 log0_sa nact_cc nbl0_1 nbl1_1 nbl2_1 nbl3_1 nsae nyr0 nyr1 nyr2
+  nyr3 rdmux saprech vddc_1 vddce vddp vddp vddp vpw vpw vss_ast0_1
+  vss_ast1_1 vpw weny0_term_1 weny1_term_1 yw0 yw1 yw2 yw3
+  sram128x46colm2x2_noopt
xl_io_2 q0_2 q1_2 bl0_2 bl1_2 bl2_2 bl3_2 blprech cap_ctrl00_term_15
+  cap_ctrl01_term_17 cap_ctrl02_term_19 cap_ctrl10_term_2 cap_ctrl11_term_2
+  cap_ctrl12_term_2 d0_2 d1_2 dwl_main dwl_main dwl_turn dwl_turn iwclk0
+  iwclk1 log0 log0_sa nact_cc nbl0_2 nbl1_2 nbl2_2 nbl3_2 nsae nyr0 nyr1 nyr2
+  nyr3 rdmux saprech vddc_2 vddce vddp vddp vddp vpw vpw vss_ast0_2
+  vss_ast1_2 vpw weny0_term_2 weny1_term_2 yw0 yw1 yw2 yw3
+  sram128x46colm2x2_noopt
xl_io_3 q0_3 q1_3 bl0_3 bl1_3 bl2_3 bl3_3 blprech cap_ctrl00_term_21
+  cap_ctrl01_term_23 cap_ctrl02_term_25 cap_ctrl10_term_3 cap_ctrl11_term_3
+  cap_ctrl12_term_3 d0_3 d1_3 dwl_main dwl_main dwl_turn dwl_turn iwclk0
+  iwclk1 log0 log0_sa nact_cc nbl0_3 nbl1_3 nbl2_3 nbl3_3 nsae nyr0 nyr1 nyr2
+  nyr3 rdmux saprech vddc_3 vddce vddp vddp vddp vpw vpw vss_ast0_3
+  vss_ast1_3 vpw weny0_term_3 weny1_term_3 yw0 yw1 yw2 yw3
+  sram128x46colm2x2_noopt
xl_io_4 q0_4 q1_4 bl0_4 bl1_4 bl2_4 bl3_4 blprech cap_ctrl00_term_27
+  cap_ctrl01_term_29 cap_ctrl02_term_31 cap_ctrl10_term_4 cap_ctrl11_term_4
+  cap_ctrl12_term_4 d0_4 d1_4 dwl_main dwl_main dwl_turn dwl_turn iwclk0
+  iwclk1 log0 log0_sa nact_cc nbl0_4 nbl1_4 nbl2_4 nbl3_4 nsae nyr0 nyr1 nyr2
+  nyr3 rdmux saprech vddc_4 vddce vddp vddp vddp vpw vpw vss_ast0_4
+  vss_ast1_4 vpw weny0_term_4 weny1_term_4 yw0 yw1 yw2 yw3
+  sram128x46colm2x2_noopt
xl_io_5 q0_5 q1_5 bl0_5 bl1_5 bl2_5 bl3_5 blprech cap_ctrl00_term_33
+  cap_ctrl01_term_35 cap_ctrl02_term_37 cap_ctrl10_term_5 cap_ctrl11_term_5
+  cap_ctrl12_term_5 d0_5 d1_5 dwl_main dwl_mainbreak dwl_turn dwl_mainbreak
+  iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_5 nbl1_5 nbl2_5 nbl3_5 nsae nyr0
+  nyr1 nyr2 nyr3 rdmux saprech vddc_5 vddce vddp vddp vddp vpw vpw vss_ast0_5
+  vss_ast1_5 vpw weny0_term_5 weny1_term_5 yw0 yw1 yw2 yw3
+  sram128x46colm2x2_noopt
xl_io_6 q0_6 q1_6 bl0_6 bl1_6 bl2_6 bl3_6 blprech cap_ctrl00_term_39
+  cap_ctrl01_term_41 cap_ctrl02_term_43 cap_ctrl10_term_6 cap_ctrl11_term_6
+  cap_ctrl12_term_6 d0_6 d1_6 dwl_mainbreak dwl_mainbreak dwl_mainbreak
+  dwl_mainbreak iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_6 nbl1_6 nbl2_6
+  nbl3_6 nsae nyr0 nyr1 nyr2 nyr3 rdmux saprech vddc_6 vddce vddp vddp vddp
+  vpw vpw vss_ast0_6 vss_ast1_6 vpw weny0_term_6 weny1_term_6 yw0 yw1 yw2 yw3
+  sram128x46colm2x2_noopt
xl_io_7 q0_7 q1_7 bl0_7 bl1_7 bl2_7 bl3_7 blprech cap_ctrl00_term_45
+  cap_ctrl01_term_47 cap_ctrl02_term_49 cap_ctrl10_term_7 cap_ctrl11_term_7
+  cap_ctrl12_term_7 d0_7 d1_7 dwl_mainbreak dwl_mainbreak dwl_mainbreak
+  dwl_mainbreak iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_7 nbl1_7 nbl2_7
+  nbl3_7 nsae nyr0 nyr1 nyr2 nyr3 rdmux saprech vddc_7 vddce vddp vddp vddp
+  vpw vpw vss_ast0_7 vss_ast1_7 vpw weny0_term_7 weny1_term_7 yw0 yw1 yw2 yw3
+  sram128x46colm2x2_noopt
xl_io_8 q0_8 q1_8 bl0_8 bl1_8 bl2_8 bl3_8 blprech cap_ctrl00_term_51
+  cap_ctrl01_term_53 cap_ctrl02_term_55 cap_ctrl10_term_8 cap_ctrl11_term_8
+  cap_ctrl12_term_8 d0_8 d1_8 dwl_mainbreak dwl_mainbreak dwl_mainbreak
+  dwl_mainbreak iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_8 nbl1_8 nbl2_8
+  nbl3_8 nsae nyr0 nyr1 nyr2 nyr3 rdmux saprech vddc_8 vddce vddp vddp vddp
+  vpw vpw vss_ast0_8 vss_ast1_8 vpw weny0_term_8 weny1_term_8 yw0 yw1 yw2 yw3
+  sram128x46colm2x2_noopt
xl_io_9 q0_9 q1_9 bl0_9 bl1_9 bl2_9 bl3_9 blprech cap_ctrl00_term_57
+  cap_ctrl01_term_59 cap_ctrl02_term_61 cap_ctrl10_term_9 cap_ctrl11_term_9
+  cap_ctrl12_term_9 d0_9 d1_9 dwl_mainbreak dwl_mainbreak dwl_mainbreak
+  dwl_mainbreak iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_9 nbl1_9 nbl2_9
+  nbl3_9 nsae nyr0 nyr1 nyr2 nyr3 rdmux saprech vddc_9 vddce vddp vddp vddp
+  vpw vpw vss_ast0_9 vss_ast1_9 vpw weny0_term_9 weny1_term_9 yw0 yw1 yw2 yw3
+  sram128x46colm2x2_noopt
xl_io_l q0_0 q1_0 bl0_0 bl1_0 bl2_0 bl3_0 blprech cap_ctrl00_term
+  cap_ctrl01_term cap_ctrl02_term cap_ctrl10_term_0 cap_ctrl11_term_0
+  cap_ctrl12_term_0 d0_0 d1_0 dwl_main dwl_main dwl_turn dwl_turn iwclk0
+  iwclk1 log0 log0_sa nact_cc nbl0_0 nbl1_0 nbl2_0 nbl3_0 nsae nyr0 nyr1 nyr2
+  nyr3 rdmux saprech vddc_0 vddce vddp vddp vddp vpw vpw vss_ast0_0
+  vss_ast1_0 vpw weny0_term_0 weny1_term_0 yw0 yw1 yw2 yw3
+  sram128x46colm2x2_noopt
xl_io_r q0_10 q1_10 bl0_10 bl1_10 bl2_10 bl3_10 blprech cap_ctrl00_term_9
+  cap_ctrl01_term_11 cap_ctrl02_term_13 cap_ctrl10_term_10 cap_ctrl11_term_10
+  cap_ctrl12_term_10 d0_10 d1_10 dwl_mainbreak dwl_mainbreak dwl_mainbreak
+  dwl_mainbreak iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_10 nbl1_10 nbl2_10
+  nbl3_10 nsae nyr0 nyr1 nyr2 nyr3 rdmux saprech vddc_10 vddce vddp vddp vddp
+  vpw vpw vss_ast0_10 vss_ast1_10 vpw weny0_term_10 weny1_term_10 yw0 yw1 yw2
+  yw3 sram128x46colm2x2_noopt
.ends sram128x46iocdm_l
****
.subckt sram128x46io_row_l bl0_10 nbl0_10 nbl1_10 bl1_10 vddc_10 bl2_10
+  nbl2_10 nbl3_10 bl3_10 bl0_9 nbl0_9 nbl1_9 bl1_9 vddc_9 bl2_9 nbl2_9 nbl3_9
+  bl3_9 bl0_8 nbl0_8 nbl1_8 bl1_8 vddc_8 bl2_8 nbl2_8 nbl3_8 bl3_8 bl0_7
+  nbl0_7 nbl1_7 bl1_7 vddc_7 bl2_7 nbl2_7 nbl3_7 bl3_7 bl0_6 nbl0_6 nbl1_6
+  bl1_6 vddc_6 bl2_6 nbl2_6 nbl3_6 bl3_6 bl0_5 nbl0_5 nbl1_5 bl1_5 vddce
+  vddc_5 bl2_5 nbl2_5 nbl3_5 bl3_5 bl0_4 nbl0_4 nbl1_4 bl1_4 vddp vddc_4
+  bl2_4 nbl2_4 nbl3_4 bl3_4 bl0_3 nbl0_3 nbl1_3 bl1_3 vddc_3 bl2_3 nbl2_3
+  nbl3_3 bl3_3 bl0_2 nbl0_2 nbl1_2 bl1_2 vddc_2 bl2_2 nbl2_2 nbl3_2 bl3_2
+  bl0_1 nbl0_1 nbl1_1 bl1_1 vddc_1 bl2_1 nbl2_1 nbl3_1 bl3_1 bl0_0 nbl0_0
+  nbl1_0 bl1_0 vddc_0 bl2_0 nbl2_0 nbl3_0 bl3_0 cap_ctrl12_term_10
+  cap_ctrl11_term_10 cap_ctrl10_term_10 q0_10 d0_10 weny0_term_10 vss_ast0_10
+  vss_ast1_10 weny1_term_10 d1_10 q1_10 cap_ctrl12_term_9 cap_ctrl11_term_9
+  cap_ctrl10_term_9 q0_9 d0_9 weny0_term_9 vss_ast0_9 vss_ast1_9 weny1_term_9
+  d1_9 q1_9 cap_ctrl12_term_8 cap_ctrl11_term_8 cap_ctrl10_term_8 q0_8 d0_8
+  weny0_term_8 vss_ast0_8 vss_ast1_8 weny1_term_8 d1_8 q1_8 cap_ctrl12_term_7
+  cap_ctrl11_term_7 cap_ctrl10_term_7 q0_7 d0_7 weny0_term_7 vss_ast0_7
+  vss_ast1_7 weny1_term_7 d1_7 q1_7 cap_ctrl12_term_6 cap_ctrl11_term_6
+  cap_ctrl10_term_6 q0_6 d0_6 weny0_term_6 vss_ast0_6 vss_ast1_6 weny1_term_6
+  d1_6 q1_6 cap_ctrl12_term_5 cap_ctrl11_term_5 cap_ctrl10_term_5 q0_5 d0_5
+  weny0_term_5 vss_ast0_5 vss_ast1_5 weny1_term_5 d1_5 q1_5 cap_ctrl12_term_4
+  cap_ctrl11_term_4 cap_ctrl10_term_4 q0_4 d0_4 weny0_term_4 vss_ast0_4
+  vss_ast1_4 weny1_term_4 d1_4 q1_4 cap_ctrl12_term_3 cap_ctrl11_term_3
+  cap_ctrl10_term_3 q0_3 d0_3 weny0_term_3 vss_ast0_3 log0 vss_ast1_3
+  weny1_term_3 d1_3 q1_3 cap_ctrl12_term_2 cap_ctrl11_term_2
+  cap_ctrl10_term_2 q0_2 d0_2 vpw weny0_term_2 vss_ast0_2 vss_ast1_2
+  weny1_term_2 d1_2 q1_2 cap_ctrl12_term_1 cap_ctrl11_term_1
+  cap_ctrl10_term_1 q0_1 d0_1 weny0_term_1 vss_ast0_1 vss_ast1_1 weny1_term_1
+  d1_1 q1_1 cap_ctrl12_term_0 cap_ctrl11_term_0 cap_ctrl10_term_0 q0_0 d0_0
+  weny0_term_0 vss_ast0_0 vss_ast1_0 weny1_term_0 d1_0 q1_0 blprech nact_cc
+  yw3 yw2 yw1 yw0 nyr3 nyr2 nyr1 nyr0 rdmux nsae saprech log0_sa iwclk0
+  iwclk1 dwl_mainbreak
** sram128x46io_row_l: 1496 flat devices **
xio_cdm_row_l bl0_10 nbl0_10 nbl1_10 bl1_10 vddc_10 bl2_10 nbl2_10 nbl3_10
+  bl3_10 bl0_9 nbl0_9 nbl1_9 bl1_9 vddc_9 bl2_9 nbl2_9 nbl3_9 bl3_9 bl0_8
+  nbl0_8 nbl1_8 bl1_8 vddc_8 bl2_8 nbl2_8 nbl3_8 bl3_8 bl0_7 nbl0_7 nbl1_7
+  bl1_7 vddc_7 bl2_7 nbl2_7 nbl3_7 bl3_7 bl0_6 nbl0_6 nbl1_6 bl1_6 vddc_6
+  bl2_6 nbl2_6 nbl3_6 bl3_6 bl0_5 nbl0_5 nbl1_5 bl1_5 vddce vddc_5 bl2_5
+  nbl2_5 nbl3_5 bl3_5 bl0_4 nbl0_4 nbl1_4 bl1_4 vddp vddc_4 bl2_4 nbl2_4
+  nbl3_4 bl3_4 bl0_3 nbl0_3 nbl1_3 bl1_3 vddc_3 bl2_3 nbl2_3 nbl3_3 bl3_3
+  bl0_2 nbl0_2 nbl1_2 bl1_2 vddc_2 bl2_2 nbl2_2 nbl3_2 bl3_2 bl0_1 nbl0_1
+  nbl1_1 bl1_1 vddc_1 bl2_1 nbl2_1 nbl3_1 bl3_1 bl0_0 nbl0_0 nbl1_0 bl1_0
+  vddc_0 bl2_0 nbl2_0 nbl3_0 bl3_0 cap_ctrl12_term_10 cap_ctrl11_term_10
+  cap_ctrl10_term_10 q0_10 d0_10 weny0_term_10 vss_ast0_10 vss_ast1_10
+  weny1_term_10 d1_10 q1_10 cap_ctrl12_term_9 cap_ctrl11_term_9
+  cap_ctrl10_term_9 q0_9 d0_9 weny0_term_9 vss_ast0_9 vss_ast1_9 weny1_term_9
+  d1_9 q1_9 cap_ctrl12_term_8 cap_ctrl11_term_8 cap_ctrl10_term_8 q0_8 d0_8
+  weny0_term_8 vss_ast0_8 vss_ast1_8 weny1_term_8 d1_8 q1_8 cap_ctrl12_term_7
+  cap_ctrl11_term_7 cap_ctrl10_term_7 q0_7 d0_7 weny0_term_7 vss_ast0_7
+  vss_ast1_7 weny1_term_7 vpw d1_7 q1_7 cap_ctrl12_term_6 cap_ctrl11_term_6
+  cap_ctrl10_term_6 q0_6 d0_6 weny0_term_6 vss_ast0_6 vss_ast1_6 weny1_term_6
+  d1_6 q1_6 cap_ctrl12_term_5 cap_ctrl11_term_5 cap_ctrl10_term_5 q0_5 d0_5
+  weny0_term_5 vss_ast0_5 vss_ast1_5 weny1_term_5 d1_5 q1_5 cap_ctrl12_term_4
+  cap_ctrl11_term_4 cap_ctrl10_term_4 q0_4 d0_4 weny0_term_4 vss_ast0_4
+  vss_ast1_4 weny1_term_4 d1_4 q1_4 cap_ctrl12_term_3 cap_ctrl11_term_3
+  cap_ctrl10_term_3 q0_3 d0_3 weny0_term_3 vss_ast0_3 vss_ast1_3 weny1_term_3
+  d1_3 q1_3 cap_ctrl12_term_2 cap_ctrl11_term_2 cap_ctrl10_term_2 q0_2 d0_2
+  weny0_term_2 vss_ast0_2 vss_ast1_2 weny1_term_2 d1_2 q1_2 cap_ctrl12_term_1
+  cap_ctrl11_term_1 cap_ctrl10_term_1 q0_1 d0_1 weny0_term_1 vss_ast0_1
+  vss_ast1_1 weny1_term_1 d1_1 q1_1 cap_ctrl12_term_0 cap_ctrl11_term_0
+  cap_ctrl10_term_0 q0_0 d0_0 weny0_term_0 vss_ast0_0 log0 vss_ast1_0
+  weny1_term_0 d1_0 q1_0 yw3 yw2 nyr3 nyr2 dwl_mainbreak blprech nact_cc yw1
+  yw0 nyr1 nyr0 rdmux nsae saprech log0_sa iwclk0 iwclk1 dwl_main log0
+  sram128x46iocdm_l
.ends sram128x46io_row_l
****
.subckt sram128x46ckm2_noopt blprech_l blprech_r cen_p2 dft_p2 gtp gwen_p2
+  iwclk0 iwclk1 la_p2[0] la_p2[1] nla_p2[0] nla_p2[1] nra_p2[0] nra_p2[1]
+  nra_p2[2] nra_p2[3] nra_p2[4] nra_p2[5] nsae_l nsae_r nyr0 nyr1 nyr2 nyr3
+  ra_p2[0] ra_p2[1] ra_p2[2] ra_p2[3] ra_p2[4] ra_p2[5] rdmux saprech yw0_l
+  yw0_r yw1_l yw1_r yw2_l yw2_r yw3_l yw3_r actp ck_emas ck_emasin dbl
+  dbl_nbl_wa dbl_nbl_wa_turn dwl dwl_turn igtpdly log0 log0_sa log1 nact_cc
+  nactc nretnvt penso_term pso0_term pso1_term rawl rawlm0 rawlm1 ret1n vddc
+  vddce vddp vddp_nor vddpe vnwc vnwp vpw vss vsse wabl_term wablm0_term
+  wablm1_term a0 a1 a2 a3 a4 a5 a6 a7 a8 a9 a10 cen clk ema[0] ema[1] ema[2]
+  emas emaw[0] emaw[1] gwen nret rdt
** sram128x46ckm2_noopt: 655 flat devices **
mi255.mxna1 net89 a9 vss vpw nch_mac W=0.4U L=0.03U NF=1
mi255.mxpa1 net89 a9 vddpe vnwp pch_mac W=0.6U L=0.03U NF=1
mi256.mxna1 na8 a8 vss vpw nch_mac W=0.4U L=0.03U NF=1
mi256.mxpa1 na8 a8 vddpe vnwp pch_mac W=0.6U L=0.03U NF=1
mi257.mxna1 na7 a7 vss vpw nch_mac W=0.4U L=0.03U NF=1
mi257.mxpa1 na7 a7 vddpe vnwp pch_mac W=0.6U L=0.03U NF=1
mi258.mxna1 na5 a5 vss vpw nch_mac W=0.4U L=0.03U NF=1
mi258.mxpa1 na5 a5 vddpe vnwp pch_mac W=0.6U L=0.03U NF=1
mi259.mxna1 na3 a3 vss vpw nch_mac W=0.4U L=0.03U NF=1
mi259.mxpa1 na3 a3 vddpe vnwp pch_mac W=0.6U L=0.03U NF=1
mi260.mxna1 na1 a1 vss vpw nch_mac W=0.4U L=0.03U NF=1
mi260.mxpa1 na1 a1 vddpe vnwp pch_mac W=0.6U L=0.03U NF=1
mi261.mxna1 cedft cen vss vpw nch_mac W=0.4U L=0.03U NF=1
mi261.mxpa1 cedft cen vddpe vnwp pch_mac W=0.6U L=0.03U NF=1
mi262.mxna1 ngwen gwen vss vpw nch_mac W=0.4U L=0.03U NF=1
mi262.mxpa1 ngwen gwen vddpe vnwp pch_mac W=0.6U L=0.03U NF=1
mi263.mxna1 na0 a0 vss vpw nch_mac W=0.4U L=0.03U NF=1
mi263.mxpa1 na0 a0 vddpe vnwp pch_mac W=0.6U L=0.03U NF=1
mi264.mxna1 na2 a2 vss vpw nch_mac W=0.4U L=0.03U NF=1
mi264.mxpa1 na2 a2 vddpe vnwp pch_mac W=0.6U L=0.03U NF=1
mi265.mxna1 na4 a4 vss vpw nch_mac W=0.4U L=0.03U NF=1
mi265.mxpa1 na4 a4 vddpe vnwp pch_mac W=0.6U L=0.03U NF=1
mi266.mxna1 na6 a6 vss vpw nch_mac W=0.4U L=0.03U NF=1
mi266.mxpa1 na6 a6 vddpe vnwp pch_mac W=0.6U L=0.03U NF=1
mi58.mxna1 na10 a10 vss vpw nch_mac W=0.4U L=0.03U NF=1
mi58.mxpa1 na10 a10 vddpe vnwp pch_mac W=0.6U L=0.03U NF=1
mick.i0.mxna1 ick.nblpreclk gtp ick.i0.n1 vpw nch_mac W=2U L=0.03U NF=1
mick.i0.mxna2 ick.i0.n1 ick.nrdt_rd vss vpw nch_mac W=2U L=0.03U NF=1
mick.i0.mxpa1 ick.nblpreclk gtp vddpe vnwp pch_mac W=0.6U L=0.03U NF=1
mick.i0.mxpa2 ick.nblpreclk ick.nrdt_rd vddpe vnwp pch_mac W=0.6U L=0.03U NF=1
mick.i105_0.mxna1 ra_p2[0] ick.na_p2[4] vss vpw nch_mac W=0.4U L=0.035U NF=1
mick.i105_0.mxpa1 ra_p2[0] ick.na_p2[4] vddpe vnwp pch_mac W=0.45U L=0.035U
+  NF=1
mick.i105_1.mxna1 ra_p2[1] ick.na_p2[5] vss vpw nch_mac W=0.4U L=0.035U NF=1
mick.i105_1.mxpa1 ra_p2[1] ick.na_p2[5] vddpe vnwp pch_mac W=0.45U L=0.035U
+  NF=1
mick.i105_2.mxna1 ra_p2[2] ick.na_p2[6] vss vpw nch_mac W=0.4U L=0.035U NF=1
mick.i105_2.mxpa1 ra_p2[2] ick.na_p2[6] vddpe vnwp pch_mac W=0.45U L=0.035U
+  NF=1
mick.i105_3.mxna1 ra_p2[3] ick.na_p2[7] vss vpw nch_mac W=0.4U L=0.035U NF=1
mick.i105_3.mxpa1 ra_p2[3] ick.na_p2[7] vddpe vnwp pch_mac W=0.45U L=0.035U
+  NF=1
mick.i105_4.mxna1 ra_p2[4] ick.na_p2[8] vss vpw nch_mac W=0.4U L=0.035U NF=1
mick.i105_4.mxpa1 ra_p2[4] ick.na_p2[8] vddpe vnwp pch_mac W=0.45U L=0.035U
+  NF=1
mick.i105_5.mxna1 ra_p2[5] ick.na_p2[9] vss vpw nch_mac W=0.4U L=0.035U NF=1
mick.i105_5.mxpa1 ra_p2[5] ick.na_p2[9] vddpe vnwp pch_mac W=0.45U L=0.035U
+  NF=1
mick.i115_0.mxna1 nra_p2[0] ick.a_p2[4] vss vpw nch_mac W=0.4U L=0.035U NF=1
mick.i115_0.mxpa1 nra_p2[0] ick.a_p2[4] vddpe vnwp pch_mac W=0.45U L=0.035U
+  NF=1
mick.i115_1.mxna1 nra_p2[1] ick.a_p2[5] vss vpw nch_mac W=0.4U L=0.035U NF=1
mick.i115_1.mxpa1 nra_p2[1] ick.a_p2[5] vddpe vnwp pch_mac W=0.45U L=0.035U
+  NF=1
mick.i115_2.mxna1 nra_p2[2] ick.a_p2[6] vss vpw nch_mac W=0.4U L=0.035U NF=1
mick.i115_2.mxpa1 nra_p2[2] ick.a_p2[6] vddpe vnwp pch_mac W=0.45U L=0.035U
+  NF=1
mick.i115_3.mxna1 nra_p2[3] ick.a_p2[7] vss vpw nch_mac W=0.4U L=0.035U NF=1
mick.i115_3.mxpa1 nra_p2[3] ick.a_p2[7] vddpe vnwp pch_mac W=0.45U L=0.035U
+  NF=1
mick.i115_4.mxna1 nra_p2[4] ick.a_p2[8] vss vpw nch_mac W=0.4U L=0.035U NF=1
mick.i115_4.mxpa1 nra_p2[4] ick.a_p2[8] vddpe vnwp pch_mac W=0.45U L=0.035U
+  NF=1
mick.i115_5.mxna1 nra_p2[5] ick.a_p2[9] vss vpw nch_mac W=0.4U L=0.035U NF=1
mick.i115_5.mxpa1 nra_p2[5] ick.a_p2[9] vddpe vnwp pch_mac W=0.45U L=0.035U
+  NF=1
mick.i177.mxna1 ick.ndft_p2 dft_p2 vss vpw nch_mac W=0.3U L=0.03U NF=1
mick.i177.mxpa1 ick.ndft_p2 dft_p2 vddpe vnwp pch_mac W=0.4U L=0.03U NF=1
mick.i207.mxna1 rdmux ick.rda_p1 vss vpw nch_mac W=2.6U L=0.03U NF=4
mick.i207.mxpa1 rdmux ick.rda_p1 vddpe vnwp pch_mac W=4U L=0.03U NF=4
mick.i208.mxna1 saprech ick.insaprech vss vpw nch_mac W=4.575U L=0.035U NF=3
mick.i208.mxpa1 saprech ick.insaprech vddpe vnwp pch_mac W=3.6U L=0.035U NF=3
mick.i232.mxna1 ick.nrdt_rd dft_p2 vss vpw nch_mac W=0.3U L=0.03U NF=1
mick.i232.mxnb1 ick.nrdt_rd gwen_p2 ick.i232.n1 vpw nch_mac W=0.3U L=0.03U
+  NF=1
mick.i232.mxnb2 ick.i232.n1 ick.rdt_p2 vss vpw nch_mac W=0.3U L=0.03U NF=1
mick.i232.mxpa1 ick.nrdt_rd dft_p2 ick.i232.p1 vnwp pch_mac W=0.3U L=0.03U
+  NF=1
mick.i232.mxpb1 ick.i232.p1 gwen_p2 vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick.i232.mxpb2 ick.i232.p1 ick.rdt_p2 vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick.i234.mxna1 ick.iwen1 gwen_p2 vss vpw nch_mac W=0.2U L=0.03U NF=1
mick.i234.mxna2 ick.iwen1 ick.na_p2[2] vss vpw nch_mac W=0.2U L=0.03U NF=1
mick.i234.mxpa1 ick.iwen1 gwen_p2 ick.i234.p1 vnwp pch_mac W=0.4U L=0.03U NF=1
mick.i234.mxpa2 ick.i234.p1 ick.na_p2[2] vddpe vnwp pch_mac W=0.4U L=0.03U
+  NF=1
mick.i239.mxna1 ick.rda_p1 ick.nrda_p1 vss vpw nch_mac W=0.8U L=0.03U NF=2
mick.i239.mxpa1 ick.rda_p1 ick.nrda_p1 vddpe vnwp pch_mac W=1.2U L=0.03U NF=2
mick.i243.mxna1 la_p2[1] ick.na_p2[10] vss vpw nch_mac W=0.26U L=0.03U NF=1
mick.i243.mxna2 la_p2[1] dft_p2 vss vpw nch_mac W=0.26U L=0.03U NF=1
mick.i243.mxpa1 la_p2[1] ick.na_p2[10] ick.i243.p1 vnwp pch_mac W=0.51U
+  L=0.03U NF=1
mick.i243.mxpa2 ick.i243.p1 dft_p2 vddpe vnwp pch_mac W=0.51U L=0.03U NF=1
mick.i244.mxna1 la_p2[0] ick.na_p2[3] vss vpw nch_mac W=0.26U L=0.03U NF=1
mick.i244.mxna2 la_p2[0] dft_p2 vss vpw nch_mac W=0.26U L=0.03U NF=1
mick.i244.mxpa1 la_p2[0] ick.na_p2[3] ick.i244.p1 vnwp pch_mac W=0.51U L=0.03U
+  NF=1
mick.i244.mxpa2 ick.i244.p1 dft_p2 vddpe vnwp pch_mac W=0.51U L=0.03U NF=1
mick.i245.mxna1 nla_p2[0] ick.a_p2[3] vss vpw nch_mac W=0.26U L=0.03U NF=1
mick.i245.mxna2 nla_p2[0] dft_p2 vss vpw nch_mac W=0.26U L=0.03U NF=1
mick.i245.mxpa1 nla_p2[0] ick.a_p2[3] ick.i245.p1 vnwp pch_mac W=0.51U L=0.03U
+  NF=1
mick.i245.mxpa2 ick.i245.p1 dft_p2 vddpe vnwp pch_mac W=0.51U L=0.03U NF=1
mick.i248.i48.mxnoe ick.ncen_p2 ick.nclk cedft vpw nch_mac W=0.5U L=0.03U NF=1
mick.i248.i48.mxpoen ick.ncen_p2 ick.bclk cedft vnwp pch_mac W=0.5U L=0.03U
+  NF=1
mick.i248.i50.mxna1 cen_p2 ick.ncen_p2 vss vpw nch_mac W=0.6U L=0.03U NF=2
mick.i248.i50.mxpa1 cen_p2 ick.ncen_p2 vddpe vnwp pch_mac W=0.8U L=0.03U NF=2
mick.i248.i55.mxna1 ick.i248.i55.n1 cen_p2 vss vpw nch_mac W=0.1U L=0.03U NF=1
mick.i248.i55.mxnoe ick.ncen_p2 ick.bclk ick.i248.i55.n1 vpw nch_mac W=0.1U
+  L=0.03U NF=1
mick.i248.i55.mxpa1 ick.i248.i55.p1 cen_p2 vddpe vnwp pch_mac W=0.1U L=0.03U
+  NF=1
mick.i248.i55.mxpoen ick.ncen_p2 ick.nclk ick.i248.i55.p1 vnwp pch_mac W=0.1U
+  L=0.03U NF=1
mick.i4.mxna1 ick.niclk gtp vss vpw nch_mac W=0.3U L=0.03U NF=1
mick.i4.mxpa1 ick.niclk gtp vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick.i63.mxna1 ick.iwen0 ick.ndft_p2 ick.i63.n1 vpw nch_mac W=0.4U L=0.03U
+  NF=1
mick.i63.mxnb1 ick.i63.n1 gwen_p2 vss vpw nch_mac W=0.4U L=0.03U NF=1
mick.i63.mxnb2 ick.i63.n1 ick.a_p2[2] vss vpw nch_mac W=0.4U L=0.03U NF=1
mick.i63.mxpa1 ick.iwen0 ick.ndft_p2 vddpe vnwp pch_mac W=0.6U L=0.03U NF=1
mick.i63.mxpb1 ick.iwen0 gwen_p2 ick.i63.p1 vnwp pch_mac W=0.6U L=0.03U NF=1
mick.i63.mxpb2 ick.i63.p1 ick.a_p2[2] vddpe vnwp pch_mac W=0.6U L=0.03U NF=1
mick.i72.mxna1 ick.isaprech gtp ick.i72.n2 vpw nch_mac W=1.42U L=0.035U NF=1
mick.i72.mxna2 ick.i72.n2 gwen_p2 ick.i72.n1 vpw nch_mac W=1.42U L=0.035U NF=1
mick.i72.mxna3 ick.i72.n1 ick.ndft_p2 vss vpw nch_mac W=1.42U L=0.035U NF=1
mick.i72.mxpa1 ick.isaprech gtp vddpe vnwp pch_mac W=0.3U L=0.035U NF=1
mick.i72.mxpa2 ick.isaprech gwen_p2 vddpe vnwp pch_mac W=0.3U L=0.035U NF=1
mick.i72.mxpa3 ick.isaprech ick.ndft_p2 vddpe vnwp pch_mac W=0.3U L=0.035U
+  NF=1
mick.i95.mxna1 nla_p2[1] ick.a_p2[10] vss vpw nch_mac W=0.26U L=0.03U NF=1
mick.i95.mxna2 nla_p2[1] dft_p2 vss vpw nch_mac W=0.26U L=0.03U NF=1
mick.i95.mxpa1 nla_p2[1] ick.a_p2[10] ick.i95.p1 vnwp pch_mac W=0.51U L=0.03U
+  NF=1
mick.i95.mxpa2 ick.i95.p1 dft_p2 vddpe vnwp pch_mac W=0.51U L=0.03U NF=1
mick.mxn0 ick.insaprech ick.isaprech ick.n1 vpw nch_mac W=1U L=0.035U NF=1
mick.mxn1 ick.bclk ick.niclk vss vpw nch_mac W=0.6U L=0.03U NF=2
mick.mxn15 ick.nclk gtp vss vpw nch_mac W=0.8U L=0.03U NF=1
mick.mxn2 ick.n1 ick.nsetsa vss vpw nch_mac W=1U L=0.035U NF=1
mick.mxp0 ick.insaprech ick.isaprech vddpe vnwp pch_mac W=1.9U L=0.035U NF=1
mick.mxp1 ick.insaprech ick.nsetsa vddpe vnwp pch_mac W=0.4U L=0.035U NF=1
mick.mxp15 ick.nclk gtp vddpe vnwp pch_mac W=0.8U L=0.03U NF=1
mick.mxp2 ick.bclk ick.niclk vddpe vnwp pch_mac W=1.6U L=0.03U NF=2
mick._a2p2_lat.i50.mxna1 ick.nrda_p1 ick.irda_p1 vss vpw nch_mac W=0.2U
+  L=0.03U NF=1
mick._a2p2_lat.i50.mxpa1 ick.nrda_p1 ick.irda_p1 vddpe vnwp pch_mac W=0.3U
+  L=0.03U NF=1
mick._a2p2_lat.i55.mxna1 ick._a2p2_lat.i55.n1 ick.nrda_p1 vss vpw nch_mac
+  W=0.1U L=0.03U NF=1
mick._a2p2_lat.i55.mxnoe ick.irda_p1 ick.nclk ick._a2p2_lat.i55.n1 vpw nch_mac
+  W=0.1U L=0.03U NF=1
mick._a2p2_lat.i55.mxpa1 ick._a2p2_lat.i55.p1 ick.nrda_p1 vddpe vnwp pch_mac
+  W=0.1U L=0.03U NF=1
mick._a2p2_lat.i55.mxpoen ick.irda_p1 gtp ick._a2p2_lat.i55.p1 vnwp pch_mac
+  W=0.1U L=0.03U NF=1
mick._a2p2_lat.i57.mxna1 ick._a2p2_lat.nsel gwen_p2 vss vpw nch_mac W=0.1U
+  L=0.03U NF=1
mick._a2p2_lat.i57.mxpa1 ick._a2p2_lat.nsel gwen_p2 vddpe vnwp pch_mac W=0.15U
+  L=0.03U NF=1
mick._a2p2_lat.i65.mxnoe ick.irda_p1 gtp ick._a2p2_lat.nd vpw nch_mac W=0.2U
+  L=0.03U NF=1
mick._a2p2_lat.i65.mxpoen ick.irda_p1 ick.nclk ick._a2p2_lat.nd vnwp pch_mac
+  W=0.2U L=0.03U NF=1
mick._a2p2_lat.mxn1 ick._a2p2_lat.nd ick.a_p2[2] ick._a2p2_lat.n2 vpw nch_mac
+  W=0.2U L=0.03U NF=1
mick._a2p2_lat.mxn2 ick._a2p2_lat.nd ick.nrda_p1 ick._a2p2_lat.n1 vpw nch_mac
+  W=0.2U L=0.03U NF=1
mick._a2p2_lat.mxn5 ick._a2p2_lat.n1 ick._a2p2_lat.nsel vss vpw nch_mac W=0.2U
+  L=0.03U NF=1
mick._a2p2_lat.mxn6 ick._a2p2_lat.n2 gwen_p2 vss vpw nch_mac W=0.2U L=0.03U
+  NF=1
mick._a2p2_lat.mxp1 ick._a2p2_lat.nd ick.nrda_p1 ick._a2p2_lat.p1 vnwp pch_mac
+  W=0.3U L=0.03U NF=1
mick._a2p2_lat.mxp3 ick._a2p2_lat.nd ick.a_p2[2] ick._a2p2_lat.p2 vnwp pch_mac
+  W=0.3U L=0.03U NF=1
mick._a2p2_lat.mxp4 ick._a2p2_lat.p1 gwen_p2 vddpe vnwp pch_mac W=0.3U L=0.03U
+  NF=1
mick._a2p2_lat.mxp5 ick._a2p2_lat.p2 ick._a2p2_lat.nsel vddpe vnwp pch_mac
+  W=0.3U L=0.03U NF=1
mick._addr_lat_0.i48.mxnoe ick.na_p2[0] ick.nclk na0 vpw nch_mac W=0.5U
+  L=0.03U NF=1
mick._addr_lat_0.i48.mxpoen ick.na_p2[0] ick.bclk na0 vnwp pch_mac W=0.5U
+  L=0.03U NF=1
mick._addr_lat_0.i50.mxna1 ick.a_p2[0] ick.na_p2[0] vss vpw nch_mac W=0.2U
+  L=0.03U NF=1
mick._addr_lat_0.i50.mxpa1 ick.a_p2[0] ick.na_p2[0] vddpe vnwp pch_mac W=0.3U
+  L=0.03U NF=1
mick._addr_lat_0.i55.mxna1 ick._addr_lat_0.i55.n1 ick.a_p2[0] vss vpw nch_mac
+  W=0.1U L=0.03U NF=1
mick._addr_lat_0.i55.mxnoe ick.na_p2[0] ick.bclk ick._addr_lat_0.i55.n1 vpw
+  nch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_0.i55.mxpa1 ick._addr_lat_0.i55.p1 ick.a_p2[0] vddpe vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_0.i55.mxpoen ick.na_p2[0] ick.nclk ick._addr_lat_0.i55.p1 vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_1.i48.mxnoe ick.na_p2[1] ick.nclk na1 vpw nch_mac W=0.5U
+  L=0.03U NF=1
mick._addr_lat_1.i48.mxpoen ick.na_p2[1] ick.bclk na1 vnwp pch_mac W=0.5U
+  L=0.03U NF=1
mick._addr_lat_1.i50.mxna1 ick.a_p2[1] ick.na_p2[1] vss vpw nch_mac W=0.2U
+  L=0.03U NF=1
mick._addr_lat_1.i50.mxpa1 ick.a_p2[1] ick.na_p2[1] vddpe vnwp pch_mac W=0.3U
+  L=0.03U NF=1
mick._addr_lat_1.i55.mxna1 ick._addr_lat_1.i55.n1 ick.a_p2[1] vss vpw nch_mac
+  W=0.1U L=0.03U NF=1
mick._addr_lat_1.i55.mxnoe ick.na_p2[1] ick.bclk ick._addr_lat_1.i55.n1 vpw
+  nch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_1.i55.mxpa1 ick._addr_lat_1.i55.p1 ick.a_p2[1] vddpe vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_1.i55.mxpoen ick.na_p2[1] ick.nclk ick._addr_lat_1.i55.p1 vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_10.i48.mxnoe ick.na_p2[10] ick.nclk na10 vpw nch_mac W=0.5U
+  L=0.03U NF=1
mick._addr_lat_10.i48.mxpoen ick.na_p2[10] ick.bclk na10 vnwp pch_mac W=0.5U
+  L=0.03U NF=1
mick._addr_lat_10.i50.mxna1 ick.a_p2[10] ick.na_p2[10] vss vpw nch_mac W=0.2U
+  L=0.03U NF=1
mick._addr_lat_10.i50.mxpa1 ick.a_p2[10] ick.na_p2[10] vddpe vnwp pch_mac
+  W=0.3U L=0.03U NF=1
mick._addr_lat_10.i55.mxna1 ick._addr_lat_10.i55.n1 ick.a_p2[10] vss vpw
+  nch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_10.i55.mxnoe ick.na_p2[10] ick.bclk ick._addr_lat_10.i55.n1 vpw
+  nch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_10.i55.mxpa1 ick._addr_lat_10.i55.p1 ick.a_p2[10] vddpe vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_10.i55.mxpoen ick.na_p2[10] ick.nclk ick._addr_lat_10.i55.p1
+  vnwp pch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_2.i48.mxnoe ick.na_p2[2] ick.nclk na2 vpw nch_mac W=0.5U
+  L=0.03U NF=1
mick._addr_lat_2.i48.mxpoen ick.na_p2[2] ick.bclk na2 vnwp pch_mac W=0.5U
+  L=0.03U NF=1
mick._addr_lat_2.i50.mxna1 ick.a_p2[2] ick.na_p2[2] vss vpw nch_mac W=0.2U
+  L=0.03U NF=1
mick._addr_lat_2.i50.mxpa1 ick.a_p2[2] ick.na_p2[2] vddpe vnwp pch_mac W=0.3U
+  L=0.03U NF=1
mick._addr_lat_2.i55.mxna1 ick._addr_lat_2.i55.n1 ick.a_p2[2] vss vpw nch_mac
+  W=0.1U L=0.03U NF=1
mick._addr_lat_2.i55.mxnoe ick.na_p2[2] ick.bclk ick._addr_lat_2.i55.n1 vpw
+  nch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_2.i55.mxpa1 ick._addr_lat_2.i55.p1 ick.a_p2[2] vddpe vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_2.i55.mxpoen ick.na_p2[2] ick.nclk ick._addr_lat_2.i55.p1 vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_3.i48.mxnoe ick.na_p2[3] ick.nclk na3 vpw nch_mac W=0.5U
+  L=0.03U NF=1
mick._addr_lat_3.i48.mxpoen ick.na_p2[3] ick.bclk na3 vnwp pch_mac W=0.5U
+  L=0.03U NF=1
mick._addr_lat_3.i50.mxna1 ick.a_p2[3] ick.na_p2[3] vss vpw nch_mac W=0.2U
+  L=0.03U NF=1
mick._addr_lat_3.i50.mxpa1 ick.a_p2[3] ick.na_p2[3] vddpe vnwp pch_mac W=0.3U
+  L=0.03U NF=1
mick._addr_lat_3.i55.mxna1 ick._addr_lat_3.i55.n1 ick.a_p2[3] vss vpw nch_mac
+  W=0.1U L=0.03U NF=1
mick._addr_lat_3.i55.mxnoe ick.na_p2[3] ick.bclk ick._addr_lat_3.i55.n1 vpw
+  nch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_3.i55.mxpa1 ick._addr_lat_3.i55.p1 ick.a_p2[3] vddpe vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_3.i55.mxpoen ick.na_p2[3] ick.nclk ick._addr_lat_3.i55.p1 vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_4.i48.mxnoe ick.na_p2[4] ick.nclk na4 vpw nch_mac W=0.5U
+  L=0.03U NF=1
mick._addr_lat_4.i48.mxpoen ick.na_p2[4] ick.bclk na4 vnwp pch_mac W=0.5U
+  L=0.03U NF=1
mick._addr_lat_4.i50.mxna1 ick.a_p2[4] ick.na_p2[4] vss vpw nch_mac W=0.2U
+  L=0.03U NF=1
mick._addr_lat_4.i50.mxpa1 ick.a_p2[4] ick.na_p2[4] vddpe vnwp pch_mac W=0.3U
+  L=0.03U NF=1
mick._addr_lat_4.i55.mxna1 ick._addr_lat_4.i55.n1 ick.a_p2[4] vss vpw nch_mac
+  W=0.1U L=0.03U NF=1
mick._addr_lat_4.i55.mxnoe ick.na_p2[4] ick.bclk ick._addr_lat_4.i55.n1 vpw
+  nch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_4.i55.mxpa1 ick._addr_lat_4.i55.p1 ick.a_p2[4] vddpe vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_4.i55.mxpoen ick.na_p2[4] ick.nclk ick._addr_lat_4.i55.p1 vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_5.i48.mxnoe ick.na_p2[5] ick.nclk na5 vpw nch_mac W=0.5U
+  L=0.03U NF=1
mick._addr_lat_5.i48.mxpoen ick.na_p2[5] ick.bclk na5 vnwp pch_mac W=0.5U
+  L=0.03U NF=1
mick._addr_lat_5.i50.mxna1 ick.a_p2[5] ick.na_p2[5] vss vpw nch_mac W=0.2U
+  L=0.03U NF=1
mick._addr_lat_5.i50.mxpa1 ick.a_p2[5] ick.na_p2[5] vddpe vnwp pch_mac W=0.3U
+  L=0.03U NF=1
mick._addr_lat_5.i55.mxna1 ick._addr_lat_5.i55.n1 ick.a_p2[5] vss vpw nch_mac
+  W=0.1U L=0.03U NF=1
mick._addr_lat_5.i55.mxnoe ick.na_p2[5] ick.bclk ick._addr_lat_5.i55.n1 vpw
+  nch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_5.i55.mxpa1 ick._addr_lat_5.i55.p1 ick.a_p2[5] vddpe vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_5.i55.mxpoen ick.na_p2[5] ick.nclk ick._addr_lat_5.i55.p1 vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_6.i48.mxnoe ick.na_p2[6] ick.nclk na6 vpw nch_mac W=0.5U
+  L=0.03U NF=1
mick._addr_lat_6.i48.mxpoen ick.na_p2[6] ick.bclk na6 vnwp pch_mac W=0.5U
+  L=0.03U NF=1
mick._addr_lat_6.i50.mxna1 ick.a_p2[6] ick.na_p2[6] vss vpw nch_mac W=0.2U
+  L=0.03U NF=1
mick._addr_lat_6.i50.mxpa1 ick.a_p2[6] ick.na_p2[6] vddpe vnwp pch_mac W=0.3U
+  L=0.03U NF=1
mick._addr_lat_6.i55.mxna1 ick._addr_lat_6.i55.n1 ick.a_p2[6] vss vpw nch_mac
+  W=0.1U L=0.03U NF=1
mick._addr_lat_6.i55.mxnoe ick.na_p2[6] ick.bclk ick._addr_lat_6.i55.n1 vpw
+  nch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_6.i55.mxpa1 ick._addr_lat_6.i55.p1 ick.a_p2[6] vddpe vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_6.i55.mxpoen ick.na_p2[6] ick.nclk ick._addr_lat_6.i55.p1 vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_7.i48.mxnoe ick.na_p2[7] ick.nclk na7 vpw nch_mac W=0.5U
+  L=0.03U NF=1
mick._addr_lat_7.i48.mxpoen ick.na_p2[7] ick.bclk na7 vnwp pch_mac W=0.5U
+  L=0.03U NF=1
mick._addr_lat_7.i50.mxna1 ick.a_p2[7] ick.na_p2[7] vss vpw nch_mac W=0.2U
+  L=0.03U NF=1
mick._addr_lat_7.i50.mxpa1 ick.a_p2[7] ick.na_p2[7] vddpe vnwp pch_mac W=0.3U
+  L=0.03U NF=1
mick._addr_lat_7.i55.mxna1 ick._addr_lat_7.i55.n1 ick.a_p2[7] vss vpw nch_mac
+  W=0.1U L=0.03U NF=1
mick._addr_lat_7.i55.mxnoe ick.na_p2[7] ick.bclk ick._addr_lat_7.i55.n1 vpw
+  nch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_7.i55.mxpa1 ick._addr_lat_7.i55.p1 ick.a_p2[7] vddpe vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_7.i55.mxpoen ick.na_p2[7] ick.nclk ick._addr_lat_7.i55.p1 vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_8.i48.mxnoe ick.na_p2[8] ick.nclk na8 vpw nch_mac W=0.5U
+  L=0.03U NF=1
mick._addr_lat_8.i48.mxpoen ick.na_p2[8] ick.bclk na8 vnwp pch_mac W=0.5U
+  L=0.03U NF=1
mick._addr_lat_8.i50.mxna1 ick.a_p2[8] ick.na_p2[8] vss vpw nch_mac W=0.2U
+  L=0.03U NF=1
mick._addr_lat_8.i50.mxpa1 ick.a_p2[8] ick.na_p2[8] vddpe vnwp pch_mac W=0.3U
+  L=0.03U NF=1
mick._addr_lat_8.i55.mxna1 ick._addr_lat_8.i55.n1 ick.a_p2[8] vss vpw nch_mac
+  W=0.1U L=0.03U NF=1
mick._addr_lat_8.i55.mxnoe ick.na_p2[8] ick.bclk ick._addr_lat_8.i55.n1 vpw
+  nch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_8.i55.mxpa1 ick._addr_lat_8.i55.p1 ick.a_p2[8] vddpe vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_8.i55.mxpoen ick.na_p2[8] ick.nclk ick._addr_lat_8.i55.p1 vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_9.i48.mxnoe ick.na_p2[9] ick.nclk net89 vpw nch_mac W=0.5U
+  L=0.03U NF=1
mick._addr_lat_9.i48.mxpoen ick.na_p2[9] ick.bclk net89 vnwp pch_mac W=0.5U
+  L=0.03U NF=1
mick._addr_lat_9.i50.mxna1 ick.a_p2[9] ick.na_p2[9] vss vpw nch_mac W=0.2U
+  L=0.03U NF=1
mick._addr_lat_9.i50.mxpa1 ick.a_p2[9] ick.na_p2[9] vddpe vnwp pch_mac W=0.3U
+  L=0.03U NF=1
mick._addr_lat_9.i55.mxna1 ick._addr_lat_9.i55.n1 ick.a_p2[9] vss vpw nch_mac
+  W=0.1U L=0.03U NF=1
mick._addr_lat_9.i55.mxnoe ick.na_p2[9] ick.bclk ick._addr_lat_9.i55.n1 vpw
+  nch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_9.i55.mxpa1 ick._addr_lat_9.i55.p1 ick.a_p2[9] vddpe vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_9.i55.mxpoen ick.na_p2[9] ick.nclk ick._addr_lat_9.i55.p1 vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._blprech.i29.mxna1 blprech_l ick._blprech.nblprech_l vss vpw nch_mac
+  W=4.5U L=0.03U NF=4
mick._blprech.i29.mxpa1 blprech_l ick._blprech.nblprech_l vddpe vnwp pch_mac
+  W=2.8U L=0.03U NF=4
mick._blprech.i36.mxna1 blprech_r ick._blprech.nblprech_r vss vpw nch_mac
+  W=4.5U L=0.03U NF=4
mick._blprech.i36.mxpa1 blprech_r ick._blprech.nblprech_r vddpe vnwp pch_mac
+  W=2.8U L=0.03U NF=4
mick._blprech.i52.mxna1 ick._blprech.dgtp ick._blprech.yr01 vss vpw nch_mac
+  W=0.3U L=0.03U NF=1
mick._blprech.i52.mxna2 ick._blprech.dgtp ick._blprech.yr23 vss vpw nch_mac
+  W=0.3U L=0.03U NF=1
mick._blprech.i52.mxpa1 ick._blprech.dgtp ick._blprech.yr01
+  ick._blprech.i52.p1 vnwp pch_mac W=0.8U L=0.03U NF=1
mick._blprech.i52.mxpa2 ick._blprech.i52.p1 ick._blprech.yr23 vddpe vnwp
+  pch_mac W=0.8U L=0.03U NF=1
mick._blprech.i65.mxna1 ick._blprech.i65.n1 ick._blprech.nret1 vss vpw nch_mac
+  W=0.1U L=0.03U NF=1
mick._blprech.i65.mxnoe ick._blprech.ret2 ick._blprech.nret1
+  ick._blprech.i65.n1 vpw nch_mac W=0.1U L=0.03U NF=1
mick._blprech.i65.mxpa1 ick._blprech.i65.p1 ick._blprech.nret1 vddpe vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._blprech.i65.mxpoen ick._blprech.ret2 ick._blprech.nret1
+  ick._blprech.i65.p1 vnwp pch_mac W=0.1U L=0.03U NF=1
mick._blprech.i75.mxna1 ick._blprech.i75.n1 ick._blprech.ret1 vss vpw nch_mac
+  W=0.1U L=0.03U NF=1
mick._blprech.i75.mxnoe ick._blprech.nret1 ick._blprech.ret1
+  ick._blprech.i75.n1 vpw nch_mac W=0.1U L=0.03U NF=1
mick._blprech.i75.mxpa1 ick._blprech.i75.p1 ick._blprech.ret1 vddpe vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._blprech.i75.mxpoen ick._blprech.nret1 ick._blprech.ret1
+  ick._blprech.i75.p1 vnwp pch_mac W=0.1U L=0.03U NF=1
mick._blprech.i76.mxna1 ick._blprech.i76.n1 nret vss vpw nch_mac W=0.1U
+  L=0.03U NF=1
mick._blprech.i76.mxnoe ick._blprech.ret1 nret ick._blprech.i76.n1 vpw nch_mac
+  W=0.1U L=0.03U NF=1
mick._blprech.i76.mxpa1 ick._blprech.i76.p1 nret vddpe vnwp pch_mac W=0.1U
+  L=0.03U NF=1
mick._blprech.i76.mxpoen ick._blprech.ret1 nret ick._blprech.i76.p1 vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._blprech.i79.mxna1 ick._blprech.i79.n1 ick._blprech.ret2 vss vpw nch_mac
+  W=0.2U L=0.03U NF=1
mick._blprech.i79.mxnoe ick._blprech.nret2 ick._blprech.ret2
+  ick._blprech.i79.n1 vpw nch_mac W=0.2U L=0.03U NF=1
mick._blprech.i79.mxpa1 ick._blprech.i79.p1 ick._blprech.ret2 vddpe vnwp
+  pch_mac W=0.3U L=0.03U NF=1
mick._blprech.i79.mxpoen ick._blprech.nret2 ick._blprech.ret2
+  ick._blprech.i79.p1 vnwp pch_mac W=0.3U L=0.03U NF=1
mick._blprech.i82.mxna1 ick._blprech.yr01 ick.nblpreclk ick._blprech.i82.n2
+  vpw nch_mac W=0.3U L=0.03U NF=1
mick._blprech.i82.mxna2 ick._blprech.i82.n2 nyr0 ick._blprech.i82.n1 vpw
+  nch_mac W=0.3U L=0.03U NF=1
mick._blprech.i82.mxna3 ick._blprech.i82.n1 nyr1 vss vpw nch_mac W=0.3U
+  L=0.03U NF=1
mick._blprech.i82.mxpa1 ick._blprech.yr01 ick.nblpreclk vddpe vnwp pch_mac
+  W=0.2U L=0.03U NF=1
mick._blprech.i82.mxpa2 ick._blprech.yr01 nyr0 vddpe vnwp pch_mac W=0.2U
+  L=0.03U NF=1
mick._blprech.i82.mxpa3 ick._blprech.yr01 nyr1 vddpe vnwp pch_mac W=0.2U
+  L=0.03U NF=1
mick._blprech.i83.mxna1 ick._blprech.yr23 nyr2 ick._blprech.i83.n1 vpw nch_mac
+  W=0.3U L=0.03U NF=1
mick._blprech.i83.mxna2 ick._blprech.i83.n1 nyr3 vss vpw nch_mac W=0.3U
+  L=0.03U NF=1
mick._blprech.i83.mxpa1 ick._blprech.yr23 nyr2 vddpe vnwp pch_mac W=0.2U
+  L=0.03U NF=1
mick._blprech.i83.mxpa2 ick._blprech.yr23 nyr3 vddpe vnwp pch_mac W=0.2U
+  L=0.03U NF=1
mick._blprech.mxn10 ick._blprech.net56 ick._blprech.nret2 vss vpw nch_mac
+  W=0.7U L=0.03U NF=1
mick._blprech.mxn11 ick._blprech.net54 ick._blprech.dgtp ick._blprech.net55
+  vpw nch_mac W=0.7U L=0.03U NF=1
mick._blprech.mxn12 ick._blprech.net57 ick._blprech.dgtp ick._blprech.net56
+  vpw nch_mac W=0.7U L=0.03U NF=1
mick._blprech.mxn13 ick._blprech.nblprech_l ick.nblpreclk ick._blprech.net54
+  vpw nch_mac W=0.7U L=0.03U NF=1
mick._blprech.mxn14 ick._blprech.nblprech_l ick.nblpreclk ick._blprech.net57
+  vpw nch_mac W=0.7U L=0.03U NF=1
mick._blprech.mxn3 ick._blprech.net60 nret vss vpw nch_mac W=0.7U L=0.03U NF=1
mick._blprech.mxn4 ick._blprech.net61 ick._blprech.dgtp ick._blprech.net60 vpw
+  nch_mac W=0.7U L=0.03U NF=1
mick._blprech.mxn5 ick._blprech.nblprech_r ick.nblpreclk ick._blprech.net61
+  vpw nch_mac W=0.7U L=0.03U NF=1
mick._blprech.mxn6 ick._blprech.nblprech_r ick.nblpreclk ick._blprech.net59
+  vpw nch_mac W=0.7U L=0.03U NF=1
mick._blprech.mxn7 ick._blprech.net59 ick._blprech.dgtp ick._blprech.net58 vpw
+  nch_mac W=0.7U L=0.03U NF=1
mick._blprech.mxn8 ick._blprech.net58 nret vss vpw nch_mac W=0.7U L=0.03U NF=1
mick._blprech.mxn9 ick._blprech.net55 ick._blprech.nret2 vss vpw nch_mac
+  W=0.7U L=0.03U NF=1
mick._blprech.mxp1 ick._blprech.nblprech_r nret vddpe vnwp pch_mac W=0.9U
+  L=0.03U NF=2
mick._blprech.mxp2 ick._blprech.nblprech_r ick._blprech.dgtp vddpe vnwp
+  pch_mac W=0.9U L=0.03U NF=2
mick._blprech.mxp3 ick._blprech.nblprech_r ick.nblpreclk vddpe vnwp pch_mac
+  W=0.9U L=0.03U NF=2
mick._blprech.mxp4 ick._blprech.nblprech_l ick.nblpreclk vddpe vnwp pch_mac
+  W=0.9U L=0.03U NF=2
mick._blprech.mxp5 ick._blprech.nblprech_l ick._blprech.dgtp vddpe vnwp
+  pch_mac W=0.9U L=0.03U NF=2
mick._blprech.mxp6 ick._blprech.nblprech_l ick._blprech.nret2 vddpe vnwp
+  pch_mac W=0.9U L=0.03U NF=2
mick._ckgen.iema.i220.mxna1 ick._ckgen.iema.gwen_sa ick._ckgen.iema.gwe_sa vss
+  vpw nch_mac W=0.4U L=0.03U NF=2
mick._ckgen.iema.i220.mxpa1 ick._ckgen.iema.gwen_sa ick._ckgen.iema.gwe_sa
+  vddpe vnwp pch_mac W=0.6U L=0.03U NF=2
mick._ckgen.iema.i249.mxna1 ick.nsetsa ick.gtpsa_split ick._ckgen.iema.i249.n1
+  vpw nch_mac W=2U L=0.03U NF=2
mick._ckgen.iema.i249.mxna2 ick._ckgen.iema.i249.n1 ick._ckgen.iema.gwen_sa
+  vss vpw nch_mac W=2U L=0.03U NF=2
mick._ckgen.iema.i249.mxpa1 ick.nsetsa ick.gtpsa_split vddpe vnwp pch_mac W=1U
+  L=0.03U NF=2
mick._ckgen.iema.i249.mxpa2 ick.nsetsa ick._ckgen.iema.gwen_sa vddpe vnwp
+  pch_mac W=1U L=0.03U NF=2
mick._ckgen.iema.i51.mxna1 ick._ckgen.iema.nwdly ick._ckgen.iema.iwdly vss vpw
+  nch_mac W=0.12U L=0.03U NF=1
mick._ckgen.iema.i51.mxpa1 ick._ckgen.iema.nwdly ick._ckgen.iema.iwdly vddpe
+  vnwp pch_mac W=0.2U L=0.03U NF=1
mick._ckgen.iema.i52.mxna1 ick._ckgen.iema.wdly ick._ckgen.iema.nwdly vss vpw
+  nch_mac W=0.2U L=0.03U NF=1
mick._ckgen.iema.i52.mxpa1 ick._ckgen.iema.wdly ick._ckgen.iema.nwdly vddpe
+  vnwp pch_mac W=0.12U L=0.03U NF=1
mick._ckgen.iema.i55.mxna1 ick._ckgen.iema.i55.n1 ick._ckgen.iema.gwen_sa vss
+  vpw nch_mac W=0.1U L=0.03U NF=1
mick._ckgen.iema.i55.mxnoe ick._ckgen.iema.gwe_sa ick.gtpsa_split
+  ick._ckgen.iema.i55.n1 vpw nch_mac W=0.1U L=0.03U NF=1
mick._ckgen.iema.i55.mxpa1 ick._ckgen.iema.i55.p1 ick._ckgen.iema.gwen_sa
+  vddpe vnwp pch_mac W=0.1U L=0.03U NF=1
mick._ckgen.iema.i55.mxpoen ick._ckgen.iema.gwe_sa ick._ckgen.iema.ngtp_sa
+  ick._ckgen.iema.i55.p1 vnwp pch_mac W=0.1U L=0.03U NF=1
mick._ckgen.iema.i56.mxna1 ick._ckgen.reset ick._ckgen.iema.net37
+  ick._ckgen.iema.i56.n1 vpw nch_mac W=0.8U L=0.03U NF=1
mick._ckgen.iema.i56.mxnb1 ick._ckgen.iema.i56.n1 ick._ckgen.iema.wdly vss vpw
+  nch_mac W=0.8U L=0.03U NF=1
mick._ckgen.iema.i56.mxnb2 ick._ckgen.iema.i56.n1 ick._ckgen.iema.gwen_sa vss
+  vpw nch_mac W=0.8U L=0.03U NF=1
mick._ckgen.iema.i56.mxpa1 ick._ckgen.reset ick._ckgen.iema.net37 vddpe vnwp
+  pch_mac W=0.6U L=0.03U NF=1
mick._ckgen.iema.i56.mxpb1 ick._ckgen.reset ick._ckgen.iema.wdly
+  ick._ckgen.iema.i56.p1 vnwp pch_mac W=0.4U L=0.03U NF=1
mick._ckgen.iema.i56.mxpb2 ick._ckgen.iema.i56.p1 ick._ckgen.iema.gwen_sa
+  vddpe vnwp pch_mac W=0.4U L=0.03U NF=1
mick._ckgen.iema.i58.mxna1 ick._ckgen.iema.ngtp_sa ick.gtpsa_split vss vpw
+  nch_mac W=0.1U L=0.03U NF=1
mick._ckgen.iema.i58.mxpa1 ick._ckgen.iema.ngtp_sa ick.gtpsa_split vddpe vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._ckgen.iema.i61.mxna1 ick._ckgen.iema.net37 ick._ckgen.iema.net34 vss vpw
+  nch_mac W=0.2U L=0.03U NF=1
mick._ckgen.iema.i61.mxpa1 ick._ckgen.iema.net37 ick._ckgen.iema.net34 vddpe
+  vnwp pch_mac W=0.2U L=0.03U NF=1
mick._ckgen.iema.i63.mxna1 ick._ckgen.iema.gwe_dft gwen_p2
+  ick._ckgen.iema.i63.n1 vpw nch_mac W=0.4U L=0.03U NF=1
mick._ckgen.iema.i63.mxna2 ick._ckgen.iema.i63.n1 ick.ndft_p2 vss vpw nch_mac
+  W=0.4U L=0.03U NF=1
mick._ckgen.iema.i63.mxpa1 ick._ckgen.iema.gwe_dft gwen_p2 vddpe vnwp pch_mac
+  W=0.3U L=0.03U NF=1
mick._ckgen.iema.i63.mxpa2 ick._ckgen.iema.gwe_dft ick.ndft_p2 vddpe vnwp
+  pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.i65.mxnoe ick._ckgen.iema.gwe_sa ick._ckgen.iema.ngtp_sa
+  ick._ckgen.iema.gwe_dft vpw nch_mac W=0.2U L=0.03U NF=1
mick._ckgen.iema.i65.mxpoen ick._ckgen.iema.gwe_sa ick.gtpsa_split
+  ick._ckgen.iema.gwe_dft vnwp pch_mac W=0.2U L=0.03U NF=1
mick._ckgen.iema.i66.mxna1 ick._ckgen.iema.net34 dwl ick._ckgen.iema.i66.n1
+  vpw nch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.i66.mxna2 ick._ckgen.iema.i66.n1 ick.gtpsa_split vss vpw
+  nch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.i66.mxpa1 ick._ckgen.iema.net34 dwl vddpe vnwp pch_mac W=0.2U
+  L=0.03U NF=1
mick._ckgen.iema.i66.mxpa2 ick._ckgen.iema.net34 ick.gtpsa_split vddpe vnwp
+  pch_mac W=0.2U L=0.03U NF=1
mick._ckgen.iema.i68.mxna1 ick._ckgen.iema.ck_in dbl vss vpw nch_mac W=0.6U
+  L=0.03U NF=2
mick._ckgen.iema.i68.mxpa1 ick._ckgen.iema.ck_in dbl vddpe vnwp pch_mac W=1.2U
+  L=0.03U NF=2
mick._ckgen.iema.irmux._rdly0.mxn3 ick._ckgen.iema.irmux._rdly0.ndin
+  ick._ckgen.iema.irmux.ckmx1o ick._ckgen.iema.irmux._rdly0.n1 vpw nch_mac
+  W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rdly0.mxn4 ick._ckgen.iema.irmux.ckdly0
+  ick._ckgen.iema.irmux._rdly0.ndin vss vpw nch_mac W=0.2U L=0.03U NF=1
mick._ckgen.iema.irmux._rdly0.mxn9 ick._ckgen.iema.irmux._rdly0.n1
+  ick._ckgen.iema.irmux.ckmx1o vss vpw nch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rdly0.mxp0 ick._ckgen.iema.irmux._rdly0.ndin
+  ick._ckgen.iema.irmux.ckmx1o vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rdly0.mxp2 ick._ckgen.iema.irmux._rdly0.p1
+  ick._ckgen.iema.irmux._rdly0.ndin vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rdly0.mxp4 ick._ckgen.iema.irmux.ckdly0
+  ick._ckgen.iema.irmux._rdly0.ndin ick._ckgen.iema.irmux._rdly0.p1 vnwp
+  pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rdly1.mxn3 ick._ckgen.iema.irmux._rdly1.ndin
+  ick._ckgen.iema.irmux.ckdly2 ick._ckgen.iema.irmux._rdly1.n1 vpw nch_mac
+  W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rdly1.mxn4 ick._ckgen.iema.irmux.ckdly1
+  ick._ckgen.iema.irmux._rdly1.ndin vss vpw nch_mac W=0.2U L=0.03U NF=1
mick._ckgen.iema.irmux._rdly1.mxn9 ick._ckgen.iema.irmux._rdly1.n1
+  ick._ckgen.iema.irmux.ckdly2 vss vpw nch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rdly1.mxp0 ick._ckgen.iema.irmux._rdly1.ndin
+  ick._ckgen.iema.irmux.ckdly2 vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rdly1.mxp2 ick._ckgen.iema.irmux._rdly1.p1
+  ick._ckgen.iema.irmux._rdly1.ndin vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rdly1.mxp4 ick._ckgen.iema.irmux.ckdly1
+  ick._ckgen.iema.irmux._rdly1.ndin ick._ckgen.iema.irmux._rdly1.p1 vnwp
+  pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rdly2.mxn3 ick._ckgen.iema.irmux._rdly2.ndin
+  ick._ckgen.iema.ck_in ick._ckgen.iema.irmux._rdly2.n1 vpw nch_mac W=0.3U
+  L=0.03U NF=1
mick._ckgen.iema.irmux._rdly2.mxn4 ick._ckgen.iema.irmux.ckdly2
+  ick._ckgen.iema.irmux._rdly2.ndin vss vpw nch_mac W=0.2U L=0.03U NF=1
mick._ckgen.iema.irmux._rdly2.mxn9 ick._ckgen.iema.irmux._rdly2.n1
+  ick._ckgen.iema.ck_in vss vpw nch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rdly2.mxp0 ick._ckgen.iema.irmux._rdly2.ndin
+  ick._ckgen.iema.ck_in vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rdly2.mxp2 ick._ckgen.iema.irmux._rdly2.p1
+  ick._ckgen.iema.irmux._rdly2.ndin vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rdly2.mxp4 ick._ckgen.iema.irmux.ckdly2
+  ick._ckgen.iema.irmux._rdly2.ndin ick._ckgen.iema.irmux._rdly2.p1 vnwp
+  pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx0.i19.mxna1 ick._ckgen.iema.irmux._rmx0.nck_out
+  ick._ckgen.iema.irmux.ckmx1o ick._ckgen.iema.irmux._rmx0.i19.n1 vpw nch_mac
+  W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx0.i19.mxnb1 ick._ckgen.iema.irmux._rmx0.i19.n1
+  ick._ckgen.iema.irmux.ckdly0 vss vpw nch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx0.i19.mxnb2 ick._ckgen.iema.irmux._rmx0.i19.n1
+  ick._ckgen.iema.irmux._rmx0.sel_in vss vpw nch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx0.i19.mxpa1 ick._ckgen.iema.irmux._rmx0.nck_out
+  ick._ckgen.iema.irmux.ckmx1o vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx0.i19.mxpb1 ick._ckgen.iema.irmux._rmx0.nck_out
+  ick._ckgen.iema.irmux.ckdly0 ick._ckgen.iema.irmux._rmx0.i19.p1 vnwp
+  pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx0.i19.mxpb2 ick._ckgen.iema.irmux._rmx0.i19.p1
+  ick._ckgen.iema.irmux._rmx0.sel_in vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx0.i2.mxna1 ick._ckgen.iema.irmux._rmx0.sel_in
+  ema[0] vss vpw nch_mac W=0.1U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx0.i2.mxpa1 ick._ckgen.iema.irmux._rmx0.sel_in
+  ema[0] vddpe vnwp pch_mac W=0.1U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx0.i20.mxna1 ick._ckgen.iema.irmux.ckdly_in
+  ick._ckgen.iema.irmux._rmx0.nck_out vss vpw nch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx0.i20.mxpa1 ick._ckgen.iema.irmux.ckdly_in
+  ick._ckgen.iema.irmux._rmx0.nck_out vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx00.i2.mxna1 ick._ckgen.iema.irmux._rmx00.sel_in
+  ema[2] vss vpw nch_mac W=0.1U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx00.i2.mxpa1 ick._ckgen.iema.irmux._rmx00.sel_in
+  ema[2] vddpe vnwp pch_mac W=0.1U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx00.i24.mxna1 ick._ckgen.iema.irmux._rmx00.nck_out
+  ick._ckgen.iema.ck_in ick._ckgen.iema.irmux._rmx00.i24.n2 vpw nch_mac
+  W=0.9U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx00.i24.mxnb1 ick._ckgen.iema.irmux._rmx00.i24.n2
+  gtp ick._ckgen.iema.irmux._rmx00.i24.n1 vpw nch_mac W=0.9U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx00.i24.mxnc1 ick._ckgen.iema.irmux._rmx00.i24.n1
+  ick._ckgen.iema.irmux.ckdly_in vss vpw nch_mac W=0.9U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx00.i24.mxnc2 ick._ckgen.iema.irmux._rmx00.i24.n1
+  ick._ckgen.iema.irmux._rmx00.sel_in vss vpw nch_mac W=0.9U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx00.i24.mxpa1 ick._ckgen.iema.irmux._rmx00.nck_out
+  ick._ckgen.iema.ck_in vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx00.i24.mxpb1 ick._ckgen.iema.irmux._rmx00.nck_out
+  gtp vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx00.i24.mxpc1 ick._ckgen.iema.irmux._rmx00.nck_out
+  ick._ckgen.iema.irmux.ckdly_in ick._ckgen.iema.irmux._rmx00.i24.p1 vnwp
+  pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx00.i24.mxpc2 ick._ckgen.iema.irmux._rmx00.i24.p1
+  ick._ckgen.iema.irmux._rmx00.sel_in vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx00.i25.mxna1 ck_emas
+  ick._ckgen.iema.irmux._rmx00.nck_out vss vpw nch_mac W=0.3U L=0.035U NF=1
mick._ckgen.iema.irmux._rmx00.i25.mxpa1 ck_emas
+  ick._ckgen.iema.irmux._rmx00.nck_out vddpe vnwp pch_mac W=0.4U L=0.035U
+  NF=1
mick._ckgen.iema.irmux._rmx00.mxn4 ick._ckgen.iema.irmux._rmx00.net26
+  ick.ngtpemas vss vpw nch_mac W=0.8U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx00.mxn5 ick.gtpsa_split
+  ick._ckgen.iema.irmux._rmx00.nck_out ick._ckgen.iema.irmux._rmx00.net26 vpw
+  nch_mac W=0.8U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx00.mxn6 ick.gtpsa_split
+  ick._ckgen.iema.irmux._rmx00.nck_out ick._ckgen.iema.irmux._rmx00.net25 vpw
+  nch_mac W=0.8U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx00.mxn7 ick._ckgen.iema.irmux._rmx00.net25
+  ick.ngtpemas vss vpw nch_mac W=0.8U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx00.mxp2 ick.gtpsa_split ick.ngtpemas vddpe vnwp
+  pch_mac W=1.4U L=0.03U NF=2
mick._ckgen.iema.irmux._rmx00.mxp3 ick.gtpsa_split
+  ick._ckgen.iema.irmux._rmx00.nck_out vddpe vnwp pch_mac W=1.4U L=0.03U NF=2
mick._ckgen.iema.irmux._rmx1.i19.mxna1 ick._ckgen.iema.irmux._rmx1.nck_out
+  ick._ckgen.iema.ck_in ick._ckgen.iema.irmux._rmx1.i19.n1 vpw nch_mac W=0.3U
+  L=0.03U NF=1
mick._ckgen.iema.irmux._rmx1.i19.mxnb1 ick._ckgen.iema.irmux._rmx1.i19.n1
+  ick._ckgen.iema.irmux.ckdly1 vss vpw nch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx1.i19.mxnb2 ick._ckgen.iema.irmux._rmx1.i19.n1
+  ick._ckgen.iema.irmux._rmx1.sel_in vss vpw nch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx1.i19.mxpa1 ick._ckgen.iema.irmux._rmx1.nck_out
+  ick._ckgen.iema.ck_in vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx1.i19.mxpb1 ick._ckgen.iema.irmux._rmx1.nck_out
+  ick._ckgen.iema.irmux.ckdly1 ick._ckgen.iema.irmux._rmx1.i19.p1 vnwp
+  pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx1.i19.mxpb2 ick._ckgen.iema.irmux._rmx1.i19.p1
+  ick._ckgen.iema.irmux._rmx1.sel_in vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx1.i2.mxna1 ick._ckgen.iema.irmux._rmx1.sel_in
+  ema[1] vss vpw nch_mac W=0.1U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx1.i2.mxpa1 ick._ckgen.iema.irmux._rmx1.sel_in
+  ema[1] vddpe vnwp pch_mac W=0.1U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx1.i20.mxna1 ick._ckgen.iema.irmux.ckmx1o
+  ick._ckgen.iema.irmux._rmx1.nck_out vss vpw nch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx1.i20.mxpa1 ick._ckgen.iema.irmux.ckmx1o
+  ick._ckgen.iema.irmux._rmx1.nck_out vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema._wdly0.mxn3 ick._ckgen.iema._wdly0.ndin
+  ick._ckgen.iema.wclk00 vss vpw nch_mac W=0.12U L=0.03U NF=1
mick._ckgen.iema._wdly0.mxn4 ick._ckgen.iema.wclk01
+  ick._ckgen.iema._wdly0.ndin vss vpw nch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema._wdly0.mxp0 ick._ckgen.iema._wdly0.ndin
+  ick._ckgen.iema.wclk00 vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema._wdly0.mxp4 ick._ckgen.iema.wclk01
+  ick._ckgen.iema._wdly0.ndin vddpe vnwp pch_mac W=0.12U L=0.03U NF=1
mick._ckgen.iema._wdly1.mxn3 ick._ckgen.iema._wdly1.ndin
+  ick._ckgen.iema.dwclk10 ick._ckgen.iema._wdly1.n1 vpw nch_mac W=0.3U
+  L=0.03U NF=1
mick._ckgen.iema._wdly1.mxn4 ick._ckgen.iema.wclk11
+  ick._ckgen.iema._wdly1.ndin vss vpw nch_mac W=0.2U L=0.03U NF=1
mick._ckgen.iema._wdly1.mxn9 ick._ckgen.iema._wdly1.n1 ick._ckgen.iema.dwclk10
+  vss vpw nch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema._wdly1.mxp0 ick._ckgen.iema._wdly1.ndin
+  ick._ckgen.iema.dwclk10 vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema._wdly1.mxp2 ick._ckgen.iema._wdly1.p1
+  ick._ckgen.iema._wdly1.ndin vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema._wdly1.mxp4 ick._ckgen.iema.wclk11
+  ick._ckgen.iema._wdly1.ndin ick._ckgen.iema._wdly1.p1 vnwp pch_mac W=0.3U
+  L=0.03U NF=1
mick._ckgen.iema._wdly2.mxn3 ick._ckgen.iema._wdly2.ndin ick.gtpsa_split
+  ick._ckgen.iema._wdly2.n1 vpw nch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema._wdly2.mxn4 ick._ckgen.iema.dwclk10
+  ick._ckgen.iema._wdly2.ndin vss vpw nch_mac W=0.2U L=0.03U NF=1
mick._ckgen.iema._wdly2.mxn9 ick._ckgen.iema._wdly2.n1 ick.gtpsa_split vss vpw
+  nch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema._wdly2.mxp0 ick._ckgen.iema._wdly2.ndin ick.gtpsa_split vddpe
+  vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema._wdly2.mxp2 ick._ckgen.iema._wdly2.p1
+  ick._ckgen.iema._wdly2.ndin vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema._wdly2.mxp4 ick._ckgen.iema.dwclk10
+  ick._ckgen.iema._wdly2.ndin ick._ckgen.iema._wdly2.p1 vnwp pch_mac W=0.3U
+  L=0.03U NF=1
mick._ckgen.iema._wmx0.i19.mxna1 ick._ckgen.iema._wmx0.nck_out
+  ick._ckgen.iema.wclk00 ick._ckgen.iema._wmx0.i19.n1 vpw nch_mac W=0.42U
+  L=0.03U NF=1
mick._ckgen.iema._wmx0.i19.mxnb1 ick._ckgen.iema._wmx0.i19.n1
+  ick._ckgen.iema.wclk01 vss vpw nch_mac W=0.42U L=0.03U NF=1
mick._ckgen.iema._wmx0.i19.mxnb2 ick._ckgen.iema._wmx0.i19.n1
+  ick._ckgen.iema._wmx0.sel_in vss vpw nch_mac W=0.42U L=0.03U NF=1
mick._ckgen.iema._wmx0.i19.mxpa1 ick._ckgen.iema._wmx0.nck_out
+  ick._ckgen.iema.wclk00 vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema._wmx0.i19.mxpb1 ick._ckgen.iema._wmx0.nck_out
+  ick._ckgen.iema.wclk01 ick._ckgen.iema._wmx0.i19.p1 vnwp pch_mac W=0.3U
+  L=0.03U NF=1
mick._ckgen.iema._wmx0.i19.mxpb2 ick._ckgen.iema._wmx0.i19.p1
+  ick._ckgen.iema._wmx0.sel_in vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema._wmx0.i2.mxna1 ick._ckgen.iema._wmx0.sel_in emaw[0] vss vpw
+  nch_mac W=0.1U L=0.03U NF=1
mick._ckgen.iema._wmx0.i2.mxpa1 ick._ckgen.iema._wmx0.sel_in emaw[0] vddpe
+  vnwp pch_mac W=0.1U L=0.03U NF=1
mick._ckgen.iema._wmx0.i20.mxna1 ick._ckgen.iema.iwdly
+  ick._ckgen.iema._wmx0.nck_out vss vpw nch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema._wmx0.i20.mxpa1 ick._ckgen.iema.iwdly
+  ick._ckgen.iema._wmx0.nck_out vddpe vnwp pch_mac W=0.42U L=0.03U NF=1
mick._ckgen.iema._wmx1.i19.mxna1 ick._ckgen.iema._wmx1.nck_out ick.gtpsa_split
+  ick._ckgen.iema._wmx1.i19.n1 vpw nch_mac W=0.42U L=0.03U NF=1
mick._ckgen.iema._wmx1.i19.mxnb1 ick._ckgen.iema._wmx1.i19.n1
+  ick._ckgen.iema.wclk11 vss vpw nch_mac W=0.42U L=0.03U NF=1
mick._ckgen.iema._wmx1.i19.mxnb2 ick._ckgen.iema._wmx1.i19.n1
+  ick._ckgen.iema._wmx1.sel_in vss vpw nch_mac W=0.42U L=0.03U NF=1
mick._ckgen.iema._wmx1.i19.mxpa1 ick._ckgen.iema._wmx1.nck_out ick.gtpsa_split
+  vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema._wmx1.i19.mxpb1 ick._ckgen.iema._wmx1.nck_out
+  ick._ckgen.iema.wclk11 ick._ckgen.iema._wmx1.i19.p1 vnwp pch_mac W=0.3U
+  L=0.03U NF=1
mick._ckgen.iema._wmx1.i19.mxpb2 ick._ckgen.iema._wmx1.i19.p1
+  ick._ckgen.iema._wmx1.sel_in vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema._wmx1.i2.mxna1 ick._ckgen.iema._wmx1.sel_in emaw[1] vss vpw
+  nch_mac W=0.1U L=0.03U NF=1
mick._ckgen.iema._wmx1.i2.mxpa1 ick._ckgen.iema._wmx1.sel_in emaw[1] vddpe
+  vnwp pch_mac W=0.1U L=0.03U NF=1
mick._ckgen.iema._wmx1.i20.mxna1 ick._ckgen.iema.wclk00
+  ick._ckgen.iema._wmx1.nck_out vss vpw nch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema._wmx1.i20.mxpa1 ick._ckgen.iema.wclk00
+  ick._ckgen.iema._wmx1.nck_out vddpe vnwp pch_mac W=0.42U L=0.03U NF=1
mick._ckgen.mxn1 dwl ick._ckgen.ngtp vsse vpw nch_mac W=1.6U L=0.03U NF=4
mick._ckgen.mxp1 dwl ick._ckgen.ngtp vddpe vnwp pch_mac W=4U L=0.03U NF=4
mick._ckgen._memgtp.i26.mxna1 ick._ckgen._memgtp.ctr ick._ckgen._memgtp.nctr
+  vss vpw nch_mac W=0.52U L=0.03U NF=2
mick._ckgen._memgtp.i26.mxpa1 ick._ckgen._memgtp.ctr ick._ckgen._memgtp.nctr
+  vddpe vnwp pch_mac W=1.3U L=0.03U NF=2
mick._ckgen._memgtp.i27.mxna1 ick._ckgen._memgtp.bclk ick._ckgen._memgtp.nclk
+  vss vpw nch_mac W=0.12U L=0.03U NF=1
mick._ckgen._memgtp.i27.mxpa1 ick._ckgen._memgtp.bclk ick._ckgen._memgtp.nclk
+  vddpe vnwp pch_mac W=0.15U L=0.03U NF=1
mick._ckgen._memgtp.i28.mxnoe ick._ckgen._memgtp.ncedft_lat
+  ick._ckgen._memgtp.nclk cedft vpw nch_mac W=0.3U L=0.03U NF=1
mick._ckgen._memgtp.i28.mxpoen ick._ckgen._memgtp.ncedft_lat
+  ick._ckgen._memgtp.bclk cedft vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen._memgtp.i29.mxna1 ick._ckgen._memgtp.i29.n1
+  ick._ckgen._memgtp.nctr vss vpw nch_mac W=0.12U L=0.03U NF=1
mick._ckgen._memgtp.i29.mxnoe ick._ckgen._memgtp.ncedft_lat
+  ick._ckgen._memgtp.bclk ick._ckgen._memgtp.i29.n1 vpw nch_mac W=0.12U
+  L=0.03U NF=1
mick._ckgen._memgtp.i29.mxpa1 ick._ckgen._memgtp.i29.p1
+  ick._ckgen._memgtp.nctr vddpe vnwp pch_mac W=0.12U L=0.03U NF=1
mick._ckgen._memgtp.i29.mxpoen ick._ckgen._memgtp.ncedft_lat
+  ick._ckgen._memgtp.nclk ick._ckgen._memgtp.i29.p1 vnwp pch_mac W=0.12U
+  L=0.03U NF=1
mick._ckgen._memgtp.i6.mxna1 gtp ick._ckgen.ngtp vss vpw nch_mac W=4U L=0.03U
+  NF=8
mick._ckgen._memgtp.i6.mxpa1 gtp ick._ckgen.ngtp vddpe vnwp pch_mac W=8U
+  L=0.03U NF=8
mick._ckgen._memgtp.i68.mxna1 ick._ckgen._memgtp.feed ick._ckgen.ngtp vss vpw
+  nch_mac W=0.2U L=0.03U NF=1
mick._ckgen._memgtp.i68.mxpa1 ick._ckgen._memgtp.feed ick._ckgen.ngtp vddpe
+  vnwp pch_mac W=0.7U L=0.03U NF=1
mick._ckgen._memgtp.i7.mxna1 ick._ckgen._memgtp.nclk clk vss vpw nch_mac W=3U
+  L=0.03U NF=4
mick._ckgen._memgtp.i7.mxpa1 ick._ckgen._memgtp.nclk clk vddpe vnwp pch_mac
+  W=3U L=0.03U NF=4
mick._ckgen._memgtp.i74.mxna1 ick._ckgen._memgtp.nfeed ick._ckgen._memgtp.feed
+  vss vpw nch_mac W=0.2U L=0.03U NF=1
mick._ckgen._memgtp.i74.mxpa1 ick._ckgen._memgtp.nfeed ick._ckgen._memgtp.feed
+  vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen._memgtp.i83.mxna1 ick._ckgen._memgtp.nctr
+  ick._ckgen._memgtp.ncedft_lat ick._ckgen._memgtp.i83.n2 vpw nch_mac W=0.65U
+  L=0.03U NF=1
mick._ckgen._memgtp.i83.mxna2 ick._ckgen._memgtp.i83.n2 nret
+  ick._ckgen._memgtp.i83.n1 vpw nch_mac W=0.65U L=0.03U NF=1
mick._ckgen._memgtp.i83.mxna3 ick._ckgen._memgtp.i83.n1
+  ick._ckgen._memgtp.nfeed vss vpw nch_mac W=0.65U L=0.03U NF=1
mick._ckgen._memgtp.i83.mxpa1 ick._ckgen._memgtp.nctr
+  ick._ckgen._memgtp.ncedft_lat vddpe vnwp pch_mac W=0.4U L=0.03U NF=1
mick._ckgen._memgtp.i83.mxpa2 ick._ckgen._memgtp.nctr nret vddpe vnwp pch_mac
+  W=0.4U L=0.03U NF=1
mick._ckgen._memgtp.i83.mxpa3 ick._ckgen._memgtp.nctr ick._ckgen._memgtp.nfeed
+  vddpe vnwp pch_mac W=0.4U L=0.03U NF=1
mick._ckgen._memgtp.mxn0 ick._ckgen._memgtp.nclk ick._ckgen._memgtp.ctr
+  ick._ckgen.ngtp vpw nch_mac W=3U L=0.03U NF=4
mick._ckgen._memgtp.mxn2 ick._ckgen._memgtp.net031 nret vss vpw nch_mac W=0.5U
+  L=0.03U NF=1
mick._ckgen._memgtp.mxn7 ick._ckgen._memgtp.net0150 ick._ckgen._memgtp.feed
+  ick._ckgen._memgtp.net031 vpw nch_mac W=0.26U L=0.03U NF=1
mick._ckgen._memgtp.mxn8 ick._ckgen.ngtp ick._ckgen.reset
+  ick._ckgen._memgtp.net0150 vpw nch_mac W=0.26U L=0.03U NF=1
mick._ckgen._memgtp.mxp1 ick._ckgen.ngtp ick._ckgen.reset vddpe vnwp pch_mac
+  W=3U L=0.03U NF=4
mick._ckgen._memgtp.mxp2 ick._ckgen._memgtp.net127 ick._ckgen._memgtp.ctr
+  vddpe vnwp pch_mac W=0.48U L=0.03U NF=1
mick._ckgen._memgtp.mxp3 ick._ckgen._memgtp.net127 clk vddpe vnwp pch_mac
+  W=0.48U L=0.03U NF=1
mick._ckgen._memgtp.mxp5 ick._ckgen.ngtp ick._ckgen._memgtp.feed
+  ick._ckgen._memgtp.net127 vnwp pch_mac W=0.48U L=0.03U NF=1
mick._ckgen._memgtp.mxpclamp ick._ckgen.ngtp nret vddpe vnwp pch_mac W=0.3U
+  L=0.03U NF=1
mick._dftrambyp_lat.i47.mxna1 ick._dftrambyp_lat.nd log0 vss vpw nch_mac
+  W=0.5U L=0.03U NF=1
mick._dftrambyp_lat.i47.mxpa1 ick._dftrambyp_lat.nd log0 vddpe vnwp pch_mac
+  W=0.62U L=0.03U NF=2
mick._dftrambyp_lat.i48.mxnoe ick.indft_p2 ick.nclk ick._dftrambyp_lat.nd vpw
+  nch_mac W=0.5U L=0.03U NF=1
mick._dftrambyp_lat.i48.mxpoen ick.indft_p2 ick.bclk ick._dftrambyp_lat.nd
+  vnwp pch_mac W=0.5U L=0.03U NF=1
mick._dftrambyp_lat.i50.mxna1 dft_p2 ick.indft_p2 vss vpw nch_mac W=0.2U
+  L=0.03U NF=1
mick._dftrambyp_lat.i50.mxpa1 dft_p2 ick.indft_p2 vddpe vnwp pch_mac W=0.3U
+  L=0.03U NF=1
mick._dftrambyp_lat.i55.mxna1 ick._dftrambyp_lat.i55.n1 dft_p2 vss vpw nch_mac
+  W=0.1U L=0.03U NF=1
mick._dftrambyp_lat.i55.mxnoe ick.indft_p2 ick.bclk ick._dftrambyp_lat.i55.n1
+  vpw nch_mac W=0.1U L=0.03U NF=1
mick._dftrambyp_lat.i55.mxpa1 ick._dftrambyp_lat.i55.p1 dft_p2 vddpe vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._dftrambyp_lat.i55.mxpoen ick.indft_p2 ick.nclk ick._dftrambyp_lat.i55.p1
+  vnwp pch_mac W=0.1U L=0.03U NF=1
mick._gwen_lat.i48.mxnoe ick.igwe_p2 ick.nclk ngwen vpw nch_mac W=0.5U L=0.03U
+  NF=1
mick._gwen_lat.i48.mxpoen ick.igwe_p2 ick.bclk ngwen vnwp pch_mac W=0.5U
+  L=0.03U NF=1
mick._gwen_lat.i50.mxna1 gwen_p2 ick.igwe_p2 vss vpw nch_mac W=0.6U L=0.03U
+  NF=2
mick._gwen_lat.i50.mxpa1 gwen_p2 ick.igwe_p2 vddpe vnwp pch_mac W=0.8U L=0.03U
+  NF=2
mick._gwen_lat.i55.mxna1 ick._gwen_lat.i55.n1 gwen_p2 vss vpw nch_mac W=0.1U
+  L=0.03U NF=1
mick._gwen_lat.i55.mxnoe ick.igwe_p2 ick.bclk ick._gwen_lat.i55.n1 vpw nch_mac
+  W=0.1U L=0.03U NF=1
mick._gwen_lat.i55.mxpa1 ick._gwen_lat.i55.p1 gwen_p2 vddpe vnwp pch_mac
+  W=0.1U L=0.03U NF=1
mick._gwen_lat.i55.mxpoen ick.igwe_p2 ick.nclk ick._gwen_lat.i55.p1 vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._rdt_lat.i47.mxna1 ick._rdt_lat.nd rdt vss vpw nch_mac W=0.5U L=0.03U
+  NF=1
mick._rdt_lat.i47.mxpa1 ick._rdt_lat.nd rdt vddpe vnwp pch_mac W=0.82U L=0.03U
+  NF=2
mick._rdt_lat.i48.mxnoe ick.nrdt_p2 ick.nclk ick._rdt_lat.nd vpw nch_mac
+  W=0.5U L=0.03U NF=1
mick._rdt_lat.i48.mxpoen ick.nrdt_p2 ick.bclk ick._rdt_lat.nd vnwp pch_mac
+  W=0.5U L=0.03U NF=1
mick._rdt_lat.i50.mxna1 ick.rdt_p2 ick.nrdt_p2 vss vpw nch_mac W=0.2U L=0.03U
+  NF=1
mick._rdt_lat.i50.mxpa1 ick.rdt_p2 ick.nrdt_p2 vddpe vnwp pch_mac W=0.3U
+  L=0.03U NF=1
mick._rdt_lat.i55.mxna1 ick._rdt_lat.i55.n1 ick.rdt_p2 vss vpw nch_mac W=0.1U
+  L=0.03U NF=1
mick._rdt_lat.i55.mxnoe ick.nrdt_p2 ick.bclk ick._rdt_lat.i55.n1 vpw nch_mac
+  W=0.1U L=0.03U NF=1
mick._rdt_lat.i55.mxpa1 ick._rdt_lat.i55.p1 ick.rdt_p2 vddpe vnwp pch_mac
+  W=0.1U L=0.03U NF=1
mick._rdt_lat.i55.mxpoen ick.nrdt_p2 ick.nclk ick._rdt_lat.i55.p1 vnwp pch_mac
+  W=0.1U L=0.03U NF=1
mick._sense.delay.mxn3 ick._sense.gtpdly ick._sense.delay.ndin
+  ick._sense.delay.n1 vpw nch_mac W=0.3U L=0.03U NF=1
mick._sense.delay.mxn4 ick._sense.delay.ndin igtpdly vss vpw nch_mac W=0.2U
+  L=0.03U NF=1
mick._sense.delay.mxn9 ick._sense.delay.n1 ick._sense.delay.ndin vss vpw
+  nch_mac W=0.3U L=0.03U NF=1
mick._sense.delay.mxp0 ick._sense.gtpdly ick._sense.delay.ndin vddpe vnwp
+  pch_mac W=0.3U L=0.03U NF=1
mick._sense.delay.mxp2 ick._sense.delay.p1 igtpdly vddpe vnwp pch_mac W=0.3U
+  L=0.03U NF=1
mick._sense.delay.mxp4 ick._sense.delay.ndin igtpdly ick._sense.delay.p1 vnwp
+  pch_mac W=0.3U L=0.03U NF=1
mick._sense.delay1.mxn3 igtpdly ick._sense.delay1.ndin ick._sense.delay1.n1
+  vpw nch_mac W=0.3U L=0.03U NF=1
mick._sense.delay1.mxn4 ick._sense.delay1.ndin ck_emas vss vpw nch_mac W=0.2U
+  L=0.03U NF=1
mick._sense.delay1.mxn9 ick._sense.delay1.n1 ick._sense.delay1.ndin vss vpw
+  nch_mac W=0.3U L=0.03U NF=1
mick._sense.delay1.mxp0 igtpdly ick._sense.delay1.ndin vddpe vnwp pch_mac
+  W=0.3U L=0.03U NF=1
mick._sense.delay1.mxp2 ick._sense.delay1.p1 ck_emas vddpe vnwp pch_mac W=0.3U
+  L=0.03U NF=1
mick._sense.delay1.mxp4 ick._sense.delay1.ndin ck_emas ick._sense.delay1.p1
+  vnwp pch_mac W=0.3U L=0.03U NF=1
mick._sense.i2.mxna1 ick.ngtpemas ck_emasin vss vpw nch_mac W=0.4U L=0.035U
+  NF=1
mick._sense.i2.mxnb1 ick.ngtpemas ick._sense.gtpdly ick._sense.i2.n1 vpw
+  nch_mac W=0.4U L=0.035U NF=1
mick._sense.i2.mxnb2 ick._sense.i2.n1 emas vss vpw nch_mac W=0.4U L=0.035U
+  NF=1
mick._sense.i2.mxpa1 ick.ngtpemas ck_emasin ick._sense.i2.p1 vnwp pch_mac W=1U
+  L=0.035U NF=1
mick._sense.i2.mxpb1 ick._sense.i2.p1 ick._sense.gtpdly vddpe vnwp pch_mac
+  W=1U L=0.035U NF=1
mick._sense.i2.mxpb2 ick._sense.i2.p1 emas vddpe vnwp pch_mac W=1U L=0.035U
+  NF=1
mick._sense.i3.mxna1 ick._sense.isae ick.nsetsa vss vpw nch_mac W=1U L=0.035U
+  NF=4
mick._sense.i3.mxpa1 ick._sense.isae ick.nsetsa vddpe vnwp pch_mac W=2.5U
+  L=0.035U NF=4
mick._sense.i6.mxna1 nsae_l ick._sense.isae vss vpw nch_mac W=5U L=0.035U NF=5
mick._sense.i6.mxpa1 nsae_l ick._sense.isae vddpe vnwp pch_mac W=4.6U L=0.035U
+  NF=5
mick._sense.i60.mxna1 nsae_r ick._sense.isae vss vpw nch_mac W=5U L=0.035U
+  NF=5
mick._sense.i60.mxpa1 nsae_r ick._sense.isae vddpe vnwp pch_mac W=4.6U
+  L=0.035U NF=5
mick._write.i1.mxna1 ick._write.nwclk1 gtp ick._write.i1.n1 vpw nch_mac W=1.9U
+  L=0.03U NF=1
mick._write.i1.mxna2 ick._write.i1.n1 ick.iwen1 vss vpw nch_mac W=1.9U L=0.03U
+  NF=1
mick._write.i1.mxpa1 ick._write.nwclk1 gtp vddpe vnwp pch_mac W=1U L=0.03U
+  NF=1
mick._write.i1.mxpa2 ick._write.nwclk1 ick.iwen1 vddpe vnwp pch_mac W=1U
+  L=0.03U NF=1
mick._write.i14.mxna1 iwclk0 ick._write.nwclk0 vss vpw nch_mac W=3U L=0.03U
+  NF=4
mick._write.i14.mxpa1 iwclk0 ick._write.nwclk0 vddpe vnwp pch_mac W=9U L=0.03U
+  NF=4
mick._write.i53.mxna1 ick._write.nwclk0 gtp ick._write.i53.n1 vpw nch_mac
+  W=1.9U L=0.03U NF=1
mick._write.i53.mxna2 ick._write.i53.n1 ick.iwen0 vss vpw nch_mac W=1.9U
+  L=0.03U NF=1
mick._write.i53.mxpa1 ick._write.nwclk0 gtp vddpe vnwp pch_mac W=1U L=0.03U
+  NF=1
mick._write.i53.mxpa2 ick._write.nwclk0 ick.iwen0 vddpe vnwp pch_mac W=1U
+  L=0.03U NF=1
mick._write.i67.mxna1 iwclk1 ick._write.nwclk1 vss vpw nch_mac W=3U L=0.03U
+  NF=4
mick._write.i67.mxpa1 iwclk1 ick._write.nwclk1 vddpe vnwp pch_mac W=9U L=0.03U
+  NF=4
mick._ydec.i19_0.mxna1 ick._ydec.ysel[0] ick.a_p2[1] vss vpw nch_mac W=0.15U
+  L=0.03U NF=1
mick._ydec.i19_0.mxna2 ick._ydec.ysel[0] ick.a_p2[0] vss vpw nch_mac W=0.15U
+  L=0.03U NF=1
mick._ydec.i19_0.mxpa1 ick._ydec.ysel[0] ick.a_p2[1] ick._ydec.i19_0.p1 vnwp
+  pch_mac W=0.3U L=0.03U NF=1
mick._ydec.i19_0.mxpa2 ick._ydec.i19_0.p1 ick.a_p2[0] vddpe vnwp pch_mac
+  W=0.3U L=0.03U NF=1
mick._ydec.i19_1.mxna1 ick._ydec.ysel[1] ick.a_p2[1] vss vpw nch_mac W=0.15U
+  L=0.03U NF=1
mick._ydec.i19_1.mxna2 ick._ydec.ysel[1] ick.na_p2[0] vss vpw nch_mac W=0.15U
+  L=0.03U NF=1
mick._ydec.i19_1.mxpa1 ick._ydec.ysel[1] ick.a_p2[1] ick._ydec.i19_1.p1 vnwp
+  pch_mac W=0.3U L=0.03U NF=1
mick._ydec.i19_1.mxpa2 ick._ydec.i19_1.p1 ick.na_p2[0] vddpe vnwp pch_mac
+  W=0.3U L=0.03U NF=1
mick._ydec.i19_2.mxna1 ick._ydec.ysel[2] ick.a_p2[1] vss vpw nch_mac W=0.15U
+  L=0.03U NF=1
mick._ydec.i19_2.mxna2 ick._ydec.ysel[2] ick.a_p2[0] vss vpw nch_mac W=0.15U
+  L=0.03U NF=1
mick._ydec.i19_2.mxpa1 ick._ydec.ysel[2] ick.a_p2[1] ick._ydec.i19_2.p1 vnwp
+  pch_mac W=0.3U L=0.03U NF=1
mick._ydec.i19_2.mxpa2 ick._ydec.i19_2.p1 ick.a_p2[0] vddpe vnwp pch_mac
+  W=0.3U L=0.03U NF=1
mick._ydec.i19_3.mxna1 ick._ydec.ysel[3] ick.a_p2[1] vss vpw nch_mac W=0.15U
+  L=0.03U NF=1
mick._ydec.i19_3.mxna2 ick._ydec.ysel[3] ick.na_p2[0] vss vpw nch_mac W=0.15U
+  L=0.03U NF=1
mick._ydec.i19_3.mxpa1 ick._ydec.ysel[3] ick.a_p2[1] ick._ydec.i19_3.p1 vnwp
+  pch_mac W=0.3U L=0.03U NF=1
mick._ydec.i19_3.mxpa2 ick._ydec.i19_3.p1 ick.na_p2[0] vddpe vnwp pch_mac
+  W=0.3U L=0.03U NF=1
mick._ydec.i21.mxna1 ick._ydec.dftrdt ick.nrdt_rd vss vpw nch_mac W=0.3U
+  L=0.03U NF=1
mick._ydec.i21.mxpa1 ick._ydec.dftrdt ick.nrdt_rd vddpe vnwp pch_mac W=0.45U
+  L=0.03U NF=1
mick._ydec.i9.mxna1 ick._ydec.gwe gwen_p2 vss vpw nch_mac W=0.3U L=0.03U NF=1
mick._ydec.i9.mxpa1 ick._ydec.gwe gwen_p2 vddpe vnwp pch_mac W=0.45U L=0.03U
+  NF=1
mick._ydec.mxn0 ick._ydec.rd ick._ydec.gwe vss vpw nch_mac W=0.3U L=0.03U NF=2
mick._ydec.mxn1 ick._ydec.wr gwen_p2 vss vpw nch_mac W=0.3U L=0.03U NF=2
mick._ydec.mxn2 ick._ydec.rd ick._ydec.dftrdt vss vpw nch_mac W=0.3U L=0.03U
+  NF=2
mick._ydec.mxn3 ick._ydec.wr ick._ydec.dftrdt vss vpw nch_mac W=0.3U L=0.03U
+  NF=2
mick._ydec.mxp0 ick._ydec.net37 ick._ydec.dftrdt vddpe vnwp pch_mac W=0.6U
+  L=0.03U NF=1
mick._ydec.mxp1 ick._ydec.rd ick._ydec.gwe ick._ydec.net37 vnwp pch_mac W=0.6U
+  L=0.03U NF=1
mick._ydec.mxp2 ick._ydec.net35 ick._ydec.dftrdt vddpe vnwp pch_mac W=0.6U
+  L=0.03U NF=1
mick._ydec.mxp3 ick._ydec.rd ick._ydec.gwe ick._ydec.net35 vnwp pch_mac W=0.6U
+  L=0.03U NF=1
mick._ydec.mxp4 ick._ydec.wr gwen_p2 ick._ydec.net34 vnwp pch_mac W=0.4U
+  L=0.03U NF=1
mick._ydec.mxp5 ick._ydec.wr gwen_p2 ick._ydec.net36 vnwp pch_mac W=0.4U
+  L=0.03U NF=1
mick._ydec.mxp6 ick._ydec.net36 ick._ydec.dftrdt vddpe vnwp pch_mac W=0.4U
+  L=0.03U NF=1
mick._ydec.mxp7 ick._ydec.net34 ick._ydec.dftrdt vddpe vnwp pch_mac W=0.4U
+  L=0.03U NF=1
mick._ydec._rmux_0.i39.mxna1 nyr0 ick._ydec._rmux_0.iyp vss vpw nch_mac
+  W=3.44U L=0.03U NF=4
mick._ydec._rmux_0.i39.mxpa1 nyr0 ick._ydec._rmux_0.iyp vddpe vnwp pch_mac
+  W=5.52U L=0.03U NF=4
mick._ydec._rmux_0.i46.mxna1 ick._ydec._rmux_0.iyp ick._ydec._rmux_0.inyp vss
+  vpw nch_mac W=0.88U L=0.04U NF=4
mick._ydec._rmux_0.i46.mxpa1 ick._ydec._rmux_0.iyp ick._ydec._rmux_0.inyp
+  vddpe vnwp pch_mac W=1.8U L=0.04U NF=4
mick._ydec._rmux_0.mxn0 ick._ydec._rmux_0.inyp ick._ydec.ysel[0] ick._ydec.rn1
+  vpw nch_mac W=0.4U L=0.03U NF=1
mick._ydec._rmux_0.mxn1 ick._ydec._rmux_0.n2 ick._ydec.rd vss vpw nch_mac
+  W=0.4U L=0.03U NF=1
mick._ydec._rmux_0.mxn2 ick._ydec.rn1 gtp ick._ydec._rmux_0.n2 vpw nch_mac
+  W=0.4U L=0.03U NF=1
mick._ydec._rmux_0.mxp0 ick._ydec._rmux_0.inyp ick._ydec.ysel[0] vddpe vnwp
+  pch_mac W=0.3U L=0.03U NF=1
mick._ydec._rmux_0.mxp1 ick._ydec._rmux_0.inyp ick._ydec.rd vddpe vnwp pch_mac
+  W=0.3U L=0.03U NF=1
mick._ydec._rmux_0.mxp2 ick._ydec._rmux_0.inyp gtp vddpe vnwp pch_mac W=0.3U
+  L=0.03U NF=1
mick._ydec._rmux_1.i39.mxna1 nyr1 ick._ydec._rmux_1.iyp vss vpw nch_mac
+  W=3.44U L=0.03U NF=4
mick._ydec._rmux_1.i39.mxpa1 nyr1 ick._ydec._rmux_1.iyp vddpe vnwp pch_mac
+  W=5.52U L=0.03U NF=4
mick._ydec._rmux_1.i46.mxna1 ick._ydec._rmux_1.iyp ick._ydec._rmux_1.inyp vss
+  vpw nch_mac W=0.88U L=0.04U NF=4
mick._ydec._rmux_1.i46.mxpa1 ick._ydec._rmux_1.iyp ick._ydec._rmux_1.inyp
+  vddpe vnwp pch_mac W=1.8U L=0.04U NF=4
mick._ydec._rmux_1.mxn0 ick._ydec._rmux_1.inyp ick._ydec.ysel[1] ick._ydec.rn1
+  vpw nch_mac W=0.4U L=0.03U NF=1
mick._ydec._rmux_1.mxn1 ick._ydec._rmux_1.n2 ick._ydec.rd vss vpw nch_mac
+  W=0.4U L=0.03U NF=1
mick._ydec._rmux_1.mxn2 ick._ydec.rn1 gtp ick._ydec._rmux_1.n2 vpw nch_mac
+  W=0.4U L=0.03U NF=1
mick._ydec._rmux_1.mxp0 ick._ydec._rmux_1.inyp ick._ydec.ysel[1] vddpe vnwp
+  pch_mac W=0.3U L=0.03U NF=1
mick._ydec._rmux_1.mxp1 ick._ydec._rmux_1.inyp ick._ydec.rd vddpe vnwp pch_mac
+  W=0.3U L=0.03U NF=1
mick._ydec._rmux_1.mxp2 ick._ydec._rmux_1.inyp gtp vddpe vnwp pch_mac W=0.3U
+  L=0.03U NF=1
mick._ydec._rmux_2.i39.mxna1 nyr2 ick._ydec._rmux_2.iyp vss vpw nch_mac
+  W=3.44U L=0.03U NF=4
mick._ydec._rmux_2.i39.mxpa1 nyr2 ick._ydec._rmux_2.iyp vddpe vnwp pch_mac
+  W=5.52U L=0.03U NF=4
mick._ydec._rmux_2.i46.mxna1 ick._ydec._rmux_2.iyp ick._ydec._rmux_2.inyp vss
+  vpw nch_mac W=0.88U L=0.04U NF=4
mick._ydec._rmux_2.i46.mxpa1 ick._ydec._rmux_2.iyp ick._ydec._rmux_2.inyp
+  vddpe vnwp pch_mac W=1.8U L=0.04U NF=4
mick._ydec._rmux_2.mxn0 ick._ydec._rmux_2.inyp ick._ydec.ysel[2] ick._ydec.rn1
+  vpw nch_mac W=0.4U L=0.03U NF=1
mick._ydec._rmux_2.mxn1 ick._ydec._rmux_2.n2 ick._ydec.rd vss vpw nch_mac
+  W=0.4U L=0.03U NF=1
mick._ydec._rmux_2.mxn2 ick._ydec.rn1 gtp ick._ydec._rmux_2.n2 vpw nch_mac
+  W=0.4U L=0.03U NF=1
mick._ydec._rmux_2.mxp0 ick._ydec._rmux_2.inyp ick._ydec.ysel[2] vddpe vnwp
+  pch_mac W=0.3U L=0.03U NF=1
mick._ydec._rmux_2.mxp1 ick._ydec._rmux_2.inyp ick._ydec.rd vddpe vnwp pch_mac
+  W=0.3U L=0.03U NF=1
mick._ydec._rmux_2.mxp2 ick._ydec._rmux_2.inyp gtp vddpe vnwp pch_mac W=0.3U
+  L=0.03U NF=1
mick._ydec._rmux_3.i39.mxna1 nyr3 ick._ydec._rmux_3.iyp vss vpw nch_mac
+  W=3.44U L=0.03U NF=4
mick._ydec._rmux_3.i39.mxpa1 nyr3 ick._ydec._rmux_3.iyp vddpe vnwp pch_mac
+  W=5.52U L=0.03U NF=4
mick._ydec._rmux_3.i46.mxna1 ick._ydec._rmux_3.iyp ick._ydec._rmux_3.inyp vss
+  vpw nch_mac W=0.88U L=0.04U NF=4
mick._ydec._rmux_3.i46.mxpa1 ick._ydec._rmux_3.iyp ick._ydec._rmux_3.inyp
+  vddpe vnwp pch_mac W=1.8U L=0.04U NF=4
mick._ydec._rmux_3.mxn0 ick._ydec._rmux_3.inyp ick._ydec.ysel[3] ick._ydec.rn1
+  vpw nch_mac W=0.4U L=0.03U NF=1
mick._ydec._rmux_3.mxn1 ick._ydec._rmux_3.n2 ick._ydec.rd vss vpw nch_mac
+  W=0.4U L=0.03U NF=1
mick._ydec._rmux_3.mxn2 ick._ydec.rn1 gtp ick._ydec._rmux_3.n2 vpw nch_mac
+  W=0.4U L=0.03U NF=1
mick._ydec._rmux_3.mxp0 ick._ydec._rmux_3.inyp ick._ydec.ysel[3] vddpe vnwp
+  pch_mac W=0.3U L=0.03U NF=1
mick._ydec._rmux_3.mxp1 ick._ydec._rmux_3.inyp ick._ydec.rd vddpe vnwp pch_mac
+  W=0.3U L=0.03U NF=1
mick._ydec._rmux_3.mxp2 ick._ydec._rmux_3.inyp gtp vddpe vnwp pch_mac W=0.3U
+  L=0.03U NF=1
mick._ydec._wmux_0.i39.mxna1 yw0_l ick._ydec._wmux_0.nyp vss vpw nch_mac
+  W=1.11U L=0.03U NF=2
mick._ydec._wmux_0.i39.mxpa1 yw0_l ick._ydec._wmux_0.nyp vddpe vnwp pch_mac
+  W=3U L=0.03U NF=2
mick._ydec._wmux_0.i54.mxna1 ick._ydec._wmux_0.nyp ick._ydec._wmux_0.iyp vss
+  vpw nch_mac W=0.66U L=0.04U NF=2
mick._ydec._wmux_0.i54.mxpa1 ick._ydec._wmux_0.nyp ick._ydec._wmux_0.iyp vddpe
+  vnwp pch_mac W=0.9U L=0.04U NF=2
mick._ydec._wmux_0.i56.mxna1 ick._ydec._wmux_0.iyp ick._ydec._wmux_0.inyp
+  ick._ydec._wmux_0.i56.n1 vpw nch_mac W=0.21U L=0.04U NF=1
mick._ydec._wmux_0.i56.mxna2 ick._ydec._wmux_0.i56.n1 ick._ydec._wmux_0.iinyp
+  vss vpw nch_mac W=0.21U L=0.04U NF=1
mick._ydec._wmux_0.i56.mxpa1 ick._ydec._wmux_0.iyp ick._ydec._wmux_0.inyp
+  vddpe vnwp pch_mac W=0.2U L=0.04U NF=1
mick._ydec._wmux_0.i56.mxpa2 ick._ydec._wmux_0.iyp ick._ydec._wmux_0.iinyp
+  vddpe vnwp pch_mac W=0.2U L=0.04U NF=1
mick._ydec._wmux_0.i57.mxna1 ick._ydec._wmux_0.iiyp ick._ydec._wmux_0.inyp vss
+  vpw nch_mac W=0.12U L=0.04U NF=1
mick._ydec._wmux_0.i57.mxpa1 ick._ydec._wmux_0.iiyp ick._ydec._wmux_0.inyp
+  vddpe vnwp pch_mac W=0.12U L=0.04U NF=1
mick._ydec._wmux_0.i60.mxna1 yw0_r ick._ydec._wmux_0.nyp vss vpw nch_mac
+  W=1.11U L=0.03U NF=2
mick._ydec._wmux_0.i60.mxpa1 yw0_r ick._ydec._wmux_0.nyp vddpe vnwp pch_mac
+  W=3U L=0.03U NF=2
mick._ydec._wmux_0.i61.mxna1 ick._ydec._wmux_0.iinyp ick._ydec._wmux_0.iiyp
+  vss vpw nch_mac W=0.12U L=0.04U NF=1
mick._ydec._wmux_0.i61.mxpa1 ick._ydec._wmux_0.iinyp ick._ydec._wmux_0.iiyp
+  vddpe vnwp pch_mac W=0.12U L=0.04U NF=1
mick._ydec._wmux_0.mxn0 ick._ydec._wmux_0.inyp ick._ydec.ysel[0] ick._ydec.wn1
+  vpw nch_mac W=0.2U L=0.03U NF=1
mick._ydec._wmux_0.mxn1 ick._ydec._wmux_0.n2 ick._ydec.wr vss vpw nch_mac
+  W=0.2U L=0.03U NF=1
mick._ydec._wmux_0.mxn2 ick._ydec.wn1 gtp ick._ydec._wmux_0.n2 vpw nch_mac
+  W=0.2U L=0.03U NF=1
mick._ydec._wmux_0.mxp0 ick._ydec._wmux_0.inyp ick._ydec.ysel[0] vddpe vnwp
+  pch_mac W=0.2U L=0.03U NF=1
mick._ydec._wmux_0.mxp1 ick._ydec._wmux_0.inyp ick._ydec.wr vddpe vnwp pch_mac
+  W=0.2U L=0.03U NF=1
mick._ydec._wmux_0.mxp2 ick._ydec._wmux_0.inyp gtp vddpe vnwp pch_mac W=0.2U
+  L=0.03U NF=1
mick._ydec._wmux_1.i39.mxna1 yw1_l ick._ydec._wmux_1.nyp vss vpw nch_mac
+  W=1.11U L=0.03U NF=2
mick._ydec._wmux_1.i39.mxpa1 yw1_l ick._ydec._wmux_1.nyp vddpe vnwp pch_mac
+  W=3U L=0.03U NF=2
mick._ydec._wmux_1.i54.mxna1 ick._ydec._wmux_1.nyp ick._ydec._wmux_1.iyp vss
+  vpw nch_mac W=0.66U L=0.04U NF=2
mick._ydec._wmux_1.i54.mxpa1 ick._ydec._wmux_1.nyp ick._ydec._wmux_1.iyp vddpe
+  vnwp pch_mac W=0.9U L=0.04U NF=2
mick._ydec._wmux_1.i56.mxna1 ick._ydec._wmux_1.iyp ick._ydec._wmux_1.inyp
+  ick._ydec._wmux_1.i56.n1 vpw nch_mac W=0.21U L=0.04U NF=1
mick._ydec._wmux_1.i56.mxna2 ick._ydec._wmux_1.i56.n1 ick._ydec._wmux_1.iinyp
+  vss vpw nch_mac W=0.21U L=0.04U NF=1
mick._ydec._wmux_1.i56.mxpa1 ick._ydec._wmux_1.iyp ick._ydec._wmux_1.inyp
+  vddpe vnwp pch_mac W=0.2U L=0.04U NF=1
mick._ydec._wmux_1.i56.mxpa2 ick._ydec._wmux_1.iyp ick._ydec._wmux_1.iinyp
+  vddpe vnwp pch_mac W=0.2U L=0.04U NF=1
mick._ydec._wmux_1.i57.mxna1 ick._ydec._wmux_1.iiyp ick._ydec._wmux_1.inyp vss
+  vpw nch_mac W=0.12U L=0.04U NF=1
mick._ydec._wmux_1.i57.mxpa1 ick._ydec._wmux_1.iiyp ick._ydec._wmux_1.inyp
+  vddpe vnwp pch_mac W=0.12U L=0.04U NF=1
mick._ydec._wmux_1.i60.mxna1 yw1_r ick._ydec._wmux_1.nyp vss vpw nch_mac
+  W=1.11U L=0.03U NF=2
mick._ydec._wmux_1.i60.mxpa1 yw1_r ick._ydec._wmux_1.nyp vddpe vnwp pch_mac
+  W=3U L=0.03U NF=2
mick._ydec._wmux_1.i61.mxna1 ick._ydec._wmux_1.iinyp ick._ydec._wmux_1.iiyp
+  vss vpw nch_mac W=0.12U L=0.04U NF=1
mick._ydec._wmux_1.i61.mxpa1 ick._ydec._wmux_1.iinyp ick._ydec._wmux_1.iiyp
+  vddpe vnwp pch_mac W=0.12U L=0.04U NF=1
mick._ydec._wmux_1.mxn0 ick._ydec._wmux_1.inyp ick._ydec.ysel[1] ick._ydec.wn1
+  vpw nch_mac W=0.2U L=0.03U NF=1
mick._ydec._wmux_1.mxn1 ick._ydec._wmux_1.n2 ick._ydec.wr vss vpw nch_mac
+  W=0.2U L=0.03U NF=1
mick._ydec._wmux_1.mxn2 ick._ydec.wn1 gtp ick._ydec._wmux_1.n2 vpw nch_mac
+  W=0.2U L=0.03U NF=1
mick._ydec._wmux_1.mxp0 ick._ydec._wmux_1.inyp ick._ydec.ysel[1] vddpe vnwp
+  pch_mac W=0.2U L=0.03U NF=1
mick._ydec._wmux_1.mxp1 ick._ydec._wmux_1.inyp ick._ydec.wr vddpe vnwp pch_mac
+  W=0.2U L=0.03U NF=1
mick._ydec._wmux_1.mxp2 ick._ydec._wmux_1.inyp gtp vddpe vnwp pch_mac W=0.2U
+  L=0.03U NF=1
mick._ydec._wmux_2.i39.mxna1 yw3_l ick._ydec._wmux_2.nyp vss vpw nch_mac
+  W=1.11U L=0.03U NF=2
mick._ydec._wmux_2.i39.mxpa1 yw3_l ick._ydec._wmux_2.nyp vddpe vnwp pch_mac
+  W=3U L=0.03U NF=2
mick._ydec._wmux_2.i54.mxna1 ick._ydec._wmux_2.nyp ick._ydec._wmux_2.iyp vss
+  vpw nch_mac W=0.66U L=0.04U NF=2
mick._ydec._wmux_2.i54.mxpa1 ick._ydec._wmux_2.nyp ick._ydec._wmux_2.iyp vddpe
+  vnwp pch_mac W=0.9U L=0.04U NF=2
mick._ydec._wmux_2.i56.mxna1 ick._ydec._wmux_2.iyp ick._ydec._wmux_2.inyp
+  ick._ydec._wmux_2.i56.n1 vpw nch_mac W=0.21U L=0.04U NF=1
mick._ydec._wmux_2.i56.mxna2 ick._ydec._wmux_2.i56.n1 ick._ydec._wmux_2.iinyp
+  vss vpw nch_mac W=0.21U L=0.04U NF=1
mick._ydec._wmux_2.i56.mxpa1 ick._ydec._wmux_2.iyp ick._ydec._wmux_2.inyp
+  vddpe vnwp pch_mac W=0.2U L=0.04U NF=1
mick._ydec._wmux_2.i56.mxpa2 ick._ydec._wmux_2.iyp ick._ydec._wmux_2.iinyp
+  vddpe vnwp pch_mac W=0.2U L=0.04U NF=1
mick._ydec._wmux_2.i57.mxna1 ick._ydec._wmux_2.iiyp ick._ydec._wmux_2.inyp vss
+  vpw nch_mac W=0.12U L=0.04U NF=1
mick._ydec._wmux_2.i57.mxpa1 ick._ydec._wmux_2.iiyp ick._ydec._wmux_2.inyp
+  vddpe vnwp pch_mac W=0.12U L=0.04U NF=1
mick._ydec._wmux_2.i60.mxna1 yw3_r ick._ydec._wmux_2.nyp vss vpw nch_mac
+  W=1.11U L=0.03U NF=2
mick._ydec._wmux_2.i60.mxpa1 yw3_r ick._ydec._wmux_2.nyp vddpe vnwp pch_mac
+  W=3U L=0.03U NF=2
mick._ydec._wmux_2.i61.mxna1 ick._ydec._wmux_2.iinyp ick._ydec._wmux_2.iiyp
+  vss vpw nch_mac W=0.12U L=0.04U NF=1
mick._ydec._wmux_2.i61.mxpa1 ick._ydec._wmux_2.iinyp ick._ydec._wmux_2.iiyp
+  vddpe vnwp pch_mac W=0.12U L=0.04U NF=1
mick._ydec._wmux_2.mxn0 ick._ydec._wmux_2.inyp ick._ydec.ysel[3] ick._ydec.wn1
+  vpw nch_mac W=0.2U L=0.03U NF=1
mick._ydec._wmux_2.mxn1 ick._ydec._wmux_2.n2 ick._ydec.wr vss vpw nch_mac
+  W=0.2U L=0.03U NF=1
mick._ydec._wmux_2.mxn2 ick._ydec.wn1 gtp ick._ydec._wmux_2.n2 vpw nch_mac
+  W=0.2U L=0.03U NF=1
mick._ydec._wmux_2.mxp0 ick._ydec._wmux_2.inyp ick._ydec.ysel[3] vddpe vnwp
+  pch_mac W=0.2U L=0.03U NF=1
mick._ydec._wmux_2.mxp1 ick._ydec._wmux_2.inyp ick._ydec.wr vddpe vnwp pch_mac
+  W=0.2U L=0.03U NF=1
mick._ydec._wmux_2.mxp2 ick._ydec._wmux_2.inyp gtp vddpe vnwp pch_mac W=0.2U
+  L=0.03U NF=1
mick._ydec._wmux_3.i39.mxna1 yw2_l ick._ydec._wmux_3.nyp vss vpw nch_mac
+  W=1.11U L=0.03U NF=2
mick._ydec._wmux_3.i39.mxpa1 yw2_l ick._ydec._wmux_3.nyp vddpe vnwp pch_mac
+  W=3U L=0.03U NF=2
mick._ydec._wmux_3.i54.mxna1 ick._ydec._wmux_3.nyp ick._ydec._wmux_3.iyp vss
+  vpw nch_mac W=0.66U L=0.04U NF=2
mick._ydec._wmux_3.i54.mxpa1 ick._ydec._wmux_3.nyp ick._ydec._wmux_3.iyp vddpe
+  vnwp pch_mac W=0.9U L=0.04U NF=2
mick._ydec._wmux_3.i56.mxna1 ick._ydec._wmux_3.iyp ick._ydec._wmux_3.inyp
+  ick._ydec._wmux_3.i56.n1 vpw nch_mac W=0.21U L=0.04U NF=1
mick._ydec._wmux_3.i56.mxna2 ick._ydec._wmux_3.i56.n1 ick._ydec._wmux_3.iinyp
+  vss vpw nch_mac W=0.21U L=0.04U NF=1
mick._ydec._wmux_3.i56.mxpa1 ick._ydec._wmux_3.iyp ick._ydec._wmux_3.inyp
+  vddpe vnwp pch_mac W=0.2U L=0.04U NF=1
mick._ydec._wmux_3.i56.mxpa2 ick._ydec._wmux_3.iyp ick._ydec._wmux_3.iinyp
+  vddpe vnwp pch_mac W=0.2U L=0.04U NF=1
mick._ydec._wmux_3.i57.mxna1 ick._ydec._wmux_3.iiyp ick._ydec._wmux_3.inyp vss
+  vpw nch_mac W=0.12U L=0.04U NF=1
mick._ydec._wmux_3.i57.mxpa1 ick._ydec._wmux_3.iiyp ick._ydec._wmux_3.inyp
+  vddpe vnwp pch_mac W=0.12U L=0.04U NF=1
mick._ydec._wmux_3.i60.mxna1 yw2_r ick._ydec._wmux_3.nyp vss vpw nch_mac
+  W=1.11U L=0.03U NF=2
mick._ydec._wmux_3.i60.mxpa1 yw2_r ick._ydec._wmux_3.nyp vddpe vnwp pch_mac
+  W=3U L=0.03U NF=2
mick._ydec._wmux_3.i61.mxna1 ick._ydec._wmux_3.iinyp ick._ydec._wmux_3.iiyp
+  vss vpw nch_mac W=0.12U L=0.04U NF=1
mick._ydec._wmux_3.i61.mxpa1 ick._ydec._wmux_3.iinyp ick._ydec._wmux_3.iiyp
+  vddpe vnwp pch_mac W=0.12U L=0.04U NF=1
mick._ydec._wmux_3.mxn0 ick._ydec._wmux_3.inyp ick._ydec.ysel[2] ick._ydec.wn1
+  vpw nch_mac W=0.2U L=0.03U NF=1
mick._ydec._wmux_3.mxn1 ick._ydec._wmux_3.n2 ick._ydec.wr vss vpw nch_mac
+  W=0.2U L=0.03U NF=1
mick._ydec._wmux_3.mxn2 ick._ydec.wn1 gtp ick._ydec._wmux_3.n2 vpw nch_mac
+  W=0.2U L=0.03U NF=1
mick._ydec._wmux_3.mxp0 ick._ydec._wmux_3.inyp ick._ydec.ysel[2] vddpe vnwp
+  pch_mac W=0.2U L=0.03U NF=1
mick._ydec._wmux_3.mxp1 ick._ydec._wmux_3.inyp ick._ydec.wr vddpe vnwp pch_mac
+  W=0.2U L=0.03U NF=1
mick._ydec._wmux_3.mxp2 ick._ydec._wmux_3.inyp gtp vddpe vnwp pch_mac W=0.2U
+  L=0.03U NF=1
.ends sram128x46ckm2_noopt
****
.subckt sram128x46ck_blk vddpe vddce nretnvt nactc vddp_nor log1 log0 dbl
+  dwl_turn gtp nla_p2[1] nla_p2[0] la_p2[1] la_p2[0] nra_p2[5] nra_p2[4]
+  nra_p2[3] nra_p2[2] nra_p2[1] nra_p2[0] ra_p2[5] ra_p2[4] ra_p2[3] ra_p2[2]
+  ra_p2[1] ra_p2[0] cen_p2 nret vddc actp vpw dft_p2 gwen_p2 dbl_nbl_wa_turn
+  dbl_nbl_wa penso_term pso1_term pso0_term wablm1_term wablm0_term wabl_term
+  rawlm1 rawlm0 rawl emas ema[0] ema[1] ema[2] emaw[0] emaw[1] ret1n rdt gwen
+  cen clk a0 a1 a2 a3 a4 a5 a6 a7 a8 a9 a10 vddp blprech_r nact_cc yw3_r
+  yw2_r yw1_r yw0_r nyr3 nyr2 nyr1 nyr0 rdmux nsae_r saprech iwclk1 dwl
+  blprech_l yw3_l yw2_l yw1_l yw0_l nsae_l log0_sa iwclk0
** sram128x46ck_blk: 655 flat devices **
xck blprech_l blprech_r cen_p2 dft_p2 gtp gwen_p2 iwclk0 iwclk1 la_p2[0]
+  la_p2[1] nla_p2[0] nla_p2[1] nra_p2[0] nra_p2[1] nra_p2[2] nra_p2[3]
+  nra_p2[4] nra_p2[5] nsae_l nsae_r nyr0 nyr1 nyr2 nyr3 ra_p2[0] ra_p2[1]
+  ra_p2[2] ra_p2[3] ra_p2[4] ra_p2[5] rdmux saprech yw0_l yw0_r yw1_l yw1_r
+  yw2_l yw2_r yw3_l yw3_r actp ck_emas ck_emas dbl dbl_nbl_wa dbl_nbl_wa_turn
+  dwl dwl_turn igtpdly log0 log0_sa log1 nact_cc nactc nretnvt penso_term
+  pso0_term pso1_term rawl rawlm0 rawlm1 ret1n vddc vddce vddp vddp_nor vddpe
+  vddce vddpe vpw vpw vpw wabl_term wablm0_term wablm1_term a0 a1 a2 a3 a4 a5
+  a6 a7 a8 a9 a10 cen clk ema[0] ema[1] ema[2] emas emaw[0] emaw[1] gwen nret
+  rdt sram128x46ckm2_noopt
.ends sram128x46ck_blk
****
.subckt sram128x46iocdm_r bl3_11 nbl3_11 nbl2_11 bl2_11 vddc_11 bl1_11 nbl1_11
+  nbl0_11 bl0_11 bl3_10 nbl3_10 nbl2_10 bl2_10 vddc_10 vddp bl1_10 nbl1_10
+  nbl0_10 bl0_10 bl3_9 nbl3_9 nbl2_9 bl2_9 vddc_9 bl1_9 nbl1_9 nbl0_9 bl0_9
+  bl3_8 nbl3_8 nbl2_8 bl2_8 vddc_8 bl1_8 nbl1_8 nbl0_8 bl0_8 bl3_7 nbl3_7
+  nbl2_7 bl2_7 vddc_7 bl1_7 nbl1_7 nbl0_7 bl0_7 bl3_6 nbl3_6 nbl2_6 bl2_6
+  vddc_6 vddce bl1_6 nbl1_6 nbl0_6 bl0_6 bl3_5 nbl3_5 nbl2_5 bl2_5 vddc_5
+  bl1_5 nbl1_5 nbl0_5 bl0_5 bl3_4 nbl3_4 nbl2_4 bl2_4 vddc_4 bl1_4 nbl1_4
+  nbl0_4 bl0_4 bl3_3 nbl3_3 nbl2_3 bl2_3 vddc_3 bl1_3 nbl1_3 nbl0_3 bl0_3
+  bl3_2 nbl3_2 nbl2_2 bl2_2 vddc_2 bl1_2 nbl1_2 nbl0_2 bl0_2 bl3_1 nbl3_1
+  nbl2_1 bl2_1 vddc_1 bl1_1 nbl1_1 nbl0_1 bl0_1 bl3_0 nbl3_0 nbl2_0 bl2_0
+  vddc_0 bl1_0 nbl1_0 nbl0_0 bl0_0 q1_11 d1_11 weny1_term_11 vss_ast1_11
+  vss_ast0_11 weny0_term_11 d0_11 q0_11 cap_ctrl10_term_11 cap_ctrl11_term_11
+  cap_ctrl12_term_11 q1_10 d1_10 weny1_term_10 vss_ast1_10 vss_ast0_10
+  weny0_term_10 d0_10 q0_10 cap_ctrl10_term_10 cap_ctrl11_term_10
+  cap_ctrl12_term_10 q1_9 d1_9 weny1_term_9 vss_ast1_9 vss_ast0_9
+  weny0_term_9 d0_9 q0_9 cap_ctrl10_term_9 cap_ctrl11_term_9
+  cap_ctrl12_term_9 q1_8 d1_8 weny1_term_8 vss_ast1_8 vss_ast0_8 weny0_term_8
+  d0_8 q0_8 cap_ctrl10_term_8 cap_ctrl11_term_8 cap_ctrl12_term_8 q1_7 d1_7
+  weny1_term_7 vss_ast1_7 vss_ast0_7 weny0_term_7 d0_7 q0_7 cap_ctrl10_term_7
+  cap_ctrl11_term_7 cap_ctrl12_term_7 q1_6 d1_6 weny1_term_6 vss_ast1_6
+  vss_ast0_6 weny0_term_6 d0_6 q0_6 cap_ctrl10_term_6 cap_ctrl11_term_6
+  cap_ctrl12_term_6 q1_5 d1_5 weny1_term_5 log0 vss_ast1_5 vss_ast0_5
+  weny0_term_5 d0_5 q0_5 cap_ctrl10_term_5 cap_ctrl11_term_5
+  cap_ctrl12_term_5 q1_4 d1_4 weny1_term_4 vss_ast1_4 vss_ast0_4 weny0_term_4
+  d0_4 q0_4 cap_ctrl10_term_4 cap_ctrl11_term_4 cap_ctrl12_term_4 q1_3 d1_3
+  weny1_term_3 vss_ast1_3 vss_ast0_3 weny0_term_3 d0_3 q0_3 cap_ctrl10_term_3
+  cap_ctrl11_term_3 cap_ctrl12_term_3 q1_2 d1_2 weny1_term_2 vss_ast1_2
+  vss_ast0_2 weny0_term_2 d0_2 q0_2 cap_ctrl10_term_2 cap_ctrl11_term_2
+  cap_ctrl12_term_2 q1_1 d1_1 weny1_term_1 vss_ast1_1 vss_ast0_1 weny0_term_1
+  vpw d0_1 q0_1 cap_ctrl10_term_1 cap_ctrl11_term_1 cap_ctrl12_term_1 q1_0
+  d1_0 weny1_term_0 vss_ast1_0 vss_ast0_0 weny0_term_0 d0_0 q0_0
+  cap_ctrl10_term_0 cap_ctrl11_term_0 cap_ctrl12_term_0 blprech nact_cc yw1
+  yw0 nyr1 nyr0 rdmux nsae saprech log0_sa iwclk0 iwclk1 dwl_main dwl_turn
+  yw3 yw2 nyr3 nyr2 dwl_mainbreak
** sram128x46iocdm_r: 1632 flat devices **
xr_io_1 q0_1 q1_1 bl0_1 bl1_1 bl2_1 bl3_1 blprech cap_ctrl00_term_21
+  cap_ctrl01_term_23 cap_ctrl02_term_25 cap_ctrl10_term_1 cap_ctrl11_term_1
+  cap_ctrl12_term_1 d0_1 d1_1 dwl_mainbreak dwl_mainbreak dwl_mainbreak
+  dwl_mainbreak iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_1 nbl1_1 nbl2_1
+  nbl3_1 nsae nyr0 nyr1 nyr2 nyr3 rdmux saprech vddc_1 vddce vddp vddp vddp
+  vpw vpw vss_ast0_1 vss_ast1_1 vpw weny0_term_1 weny1_term_1 yw0 yw1 yw2 yw3
+  sram128x46colm2x2_noopt
xr_io_10 q0_10 q1_10 bl0_10 bl1_10 bl2_10 bl3_10 blprech cap_ctrl00_term_9
+  cap_ctrl01_term_11 cap_ctrl02_term_13 cap_ctrl10_term_10 cap_ctrl11_term_10
+  cap_ctrl12_term_10 d0_10 d1_10 dwl_main dwl_main dwl_turn dwl_turn iwclk0
+  iwclk1 log0 log0_sa nact_cc nbl0_10 nbl1_10 nbl2_10 nbl3_10 nsae nyr0 nyr1
+  nyr2 nyr3 rdmux saprech vddc_10 vddce vddp vddp vddp vpw vpw vss_ast0_10
+  vss_ast1_10 vpw weny0_term_10 weny1_term_10 yw0 yw1 yw2 yw3
+  sram128x46colm2x2_noopt
xr_io_2 q0_2 q1_2 bl0_2 bl1_2 bl2_2 bl3_2 blprech cap_ctrl00_term_33
+  cap_ctrl01_term_35 cap_ctrl02_term_37 cap_ctrl10_term_2 cap_ctrl11_term_2
+  cap_ctrl12_term_2 d0_2 d1_2 dwl_mainbreak dwl_mainbreak dwl_mainbreak
+  dwl_mainbreak iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_2 nbl1_2 nbl2_2
+  nbl3_2 nsae nyr0 nyr1 nyr2 nyr3 rdmux saprech vddc_2 vddce vddp vddp vddp
+  vpw vpw vss_ast0_2 vss_ast1_2 vpw weny0_term_2 weny1_term_2 yw0 yw1 yw2 yw3
+  sram128x46colm2x2_noopt
xr_io_3 q0_3 q1_3 bl0_3 bl1_3 bl2_3 bl3_3 blprech cap_ctrl00_term_39
+  cap_ctrl01_term_41 cap_ctrl02_term_43 cap_ctrl10_term_3 cap_ctrl11_term_3
+  cap_ctrl12_term_3 d0_3 d1_3 dwl_mainbreak dwl_mainbreak dwl_mainbreak
+  dwl_mainbreak iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_3 nbl1_3 nbl2_3
+  nbl3_3 nsae nyr0 nyr1 nyr2 nyr3 rdmux saprech vddc_3 vddce vddp vddp vddp
+  vpw vpw vss_ast0_3 vss_ast1_3 vpw weny0_term_3 weny1_term_3 yw0 yw1 yw2 yw3
+  sram128x46colm2x2_noopt
xr_io_4 q0_4 q1_4 bl0_4 bl1_4 bl2_4 bl3_4 blprech cap_ctrl00_term_45
+  cap_ctrl01_term_47 cap_ctrl02_term_49 cap_ctrl10_term_4 cap_ctrl11_term_4
+  cap_ctrl12_term_4 d0_4 d1_4 dwl_mainbreak dwl_mainbreak dwl_mainbreak
+  dwl_mainbreak iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_4 nbl1_4 nbl2_4
+  nbl3_4 nsae nyr0 nyr1 nyr2 nyr3 rdmux saprech vddc_4 vddce vddp vddp vddp
+  vpw vpw vss_ast0_4 vss_ast1_4 vpw weny0_term_4 weny1_term_4 yw0 yw1 yw2 yw3
+  sram128x46colm2x2_noopt
xr_io_5 q0_5 q1_5 bl0_5 bl1_5 bl2_5 bl3_5 blprech cap_ctrl00_term_51
+  cap_ctrl01_term_53 cap_ctrl02_term_55 cap_ctrl10_term_5 cap_ctrl11_term_5
+  cap_ctrl12_term_5 d0_5 d1_5 dwl_main dwl_mainbreak dwl_turn dwl_mainbreak
+  iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_5 nbl1_5 nbl2_5 nbl3_5 nsae nyr0
+  nyr1 nyr2 nyr3 rdmux saprech vddc_5 vddce vddp vddp vddp vpw vpw vss_ast0_5
+  vss_ast1_5 vpw weny0_term_5 weny1_term_5 yw0 yw1 yw2 yw3
+  sram128x46colm2x2_noopt
xr_io_6 q0_6 q1_6 bl0_6 bl1_6 bl2_6 bl3_6 blprech cap_ctrl00_term_57
+  cap_ctrl01_term_59 cap_ctrl02_term_61 cap_ctrl10_term_6 cap_ctrl11_term_6
+  cap_ctrl12_term_6 d0_6 d1_6 dwl_main dwl_main dwl_turn dwl_turn iwclk0
+  iwclk1 log0 log0_sa nact_cc nbl0_6 nbl1_6 nbl2_6 nbl3_6 nsae nyr0 nyr1 nyr2
+  nyr3 rdmux saprech vddc_6 vddce vddp vddp vddp vpw vpw vss_ast0_6
+  vss_ast1_6 vpw weny0_term_6 weny1_term_6 yw0 yw1 yw2 yw3
+  sram128x46colm2x2_noopt
xr_io_7 q0_7 q1_7 bl0_7 bl1_7 bl2_7 bl3_7 blprech cap_ctrl00_term_63
+  cap_ctrl01_term_65 cap_ctrl02_term_67 cap_ctrl10_term_7 cap_ctrl11_term_7
+  cap_ctrl12_term_7 d0_7 d1_7 dwl_main dwl_main dwl_turn dwl_turn iwclk0
+  iwclk1 log0 log0_sa nact_cc nbl0_7 nbl1_7 nbl2_7 nbl3_7 nsae nyr0 nyr1 nyr2
+  nyr3 rdmux saprech vddc_7 vddce vddp vddp vddp vpw vpw vss_ast0_7
+  vss_ast1_7 vpw weny0_term_7 weny1_term_7 yw0 yw1 yw2 yw3
+  sram128x46colm2x2_noopt
xr_io_8 q0_8 q1_8 bl0_8 bl1_8 bl2_8 bl3_8 blprech cap_ctrl00_term
+  cap_ctrl01_term cap_ctrl02_term cap_ctrl10_term_8 cap_ctrl11_term_8
+  cap_ctrl12_term_8 d0_8 d1_8 dwl_main dwl_main dwl_turn dwl_turn iwclk0
+  iwclk1 log0 log0_sa nact_cc nbl0_8 nbl1_8 nbl2_8 nbl3_8 nsae nyr0 nyr1 nyr2
+  nyr3 rdmux saprech vddc_8 vddce vddp vddp vddp vpw vpw vss_ast0_8
+  vss_ast1_8 vpw weny0_term_8 weny1_term_8 yw0 yw1 yw2 yw3
+  sram128x46colm2x2_noopt
xr_io_9 q0_9 q1_9 bl0_9 bl1_9 bl2_9 bl3_9 blprech cap_ctrl00_term_3
+  cap_ctrl01_term_5 cap_ctrl02_term_7 cap_ctrl10_term_9 cap_ctrl11_term_9
+  cap_ctrl12_term_9 d0_9 d1_9 dwl_main dwl_main dwl_turn dwl_turn iwclk0
+  iwclk1 log0 log0_sa nact_cc nbl0_9 nbl1_9 nbl2_9 nbl3_9 nsae nyr0 nyr1 nyr2
+  nyr3 rdmux saprech vddc_9 vddce vddp vddp vddp vpw vpw vss_ast0_9
+  vss_ast1_9 vpw weny0_term_9 weny1_term_9 yw0 yw1 yw2 yw3
+  sram128x46colm2x2_noopt
xr_io_l q0_0 q1_0 bl0_0 bl1_0 bl2_0 bl3_0 blprech cap_ctrl00_term_15
+  cap_ctrl01_term_17 cap_ctrl02_term_19 cap_ctrl10_term_0 cap_ctrl11_term_0
+  cap_ctrl12_term_0 d0_0 d1_0 dwl_mainbreak dwl_mainbreak dwl_mainbreak
+  dwl_mainbreak iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_0 nbl1_0 nbl2_0
+  nbl3_0 nsae nyr0 nyr1 nyr2 nyr3 rdmux saprech vddc_0 vddce vddp vddp vddp
+  vpw vpw vss_ast0_0 vss_ast1_0 vpw weny0_term_0 weny1_term_0 yw0 yw1 yw2 yw3
+  sram128x46colm2x2_noopt
xr_io_r q0_11 q1_11 bl0_11 bl1_11 bl2_11 bl3_11 blprech cap_ctrl00_term_27
+  cap_ctrl01_term_29 cap_ctrl02_term_31 cap_ctrl10_term_11 cap_ctrl11_term_11
+  cap_ctrl12_term_11 d0_11 d1_11 dwl_main dwl_main dwl_turn dwl_turn iwclk0
+  iwclk1 log0 log0_sa nact_cc nbl0_11 nbl1_11 nbl2_11 nbl3_11 nsae nyr0 nyr1
+  nyr2 nyr3 rdmux saprech vddc_11 vddce vddp vddp vddp vpw vpw vss_ast0_11
+  vss_ast1_11 vpw weny0_term_11 weny1_term_11 yw0 yw1 yw2 yw3
+  sram128x46colm2x2_noopt
.ends sram128x46iocdm_r
****
.subckt sram128x46io_row_r bl3_11 nbl3_11 nbl2_11 bl2_11 vddc_11 bl1_11
+  nbl1_11 nbl0_11 bl0_11 bl3_10 nbl3_10 nbl2_10 bl2_10 vddc_10 bl1_10 nbl1_10
+  nbl0_10 bl0_10 bl3_9 nbl3_9 nbl2_9 bl2_9 vddc_9 bl1_9 nbl1_9 nbl0_9 bl0_9
+  bl3_8 nbl3_8 nbl2_8 bl2_8 vddc_8 bl1_8 nbl1_8 nbl0_8 bl0_8 bl3_7 nbl3_7
+  nbl2_7 bl2_7 vddc_7 bl1_7 nbl1_7 nbl0_7 bl0_7 bl3_6 nbl3_6 nbl2_6 bl2_6
+  vddc_6 vddce bl1_6 nbl1_6 nbl0_6 bl0_6 bl3_5 nbl3_5 nbl2_5 bl2_5 vddc_5
+  bl1_5 nbl1_5 nbl0_5 bl0_5 bl3_4 nbl3_4 nbl2_4 bl2_4 vddc_4 bl1_4 nbl1_4
+  nbl0_4 bl0_4 bl3_3 nbl3_3 nbl2_3 bl2_3 vddc_3 bl1_3 nbl1_3 nbl0_3 bl0_3
+  bl3_2 nbl3_2 nbl2_2 bl2_2 vddc_2 bl1_2 nbl1_2 nbl0_2 bl0_2 bl3_1 nbl3_1
+  nbl2_1 bl2_1 vddc_1 bl1_1 nbl1_1 nbl0_1 bl0_1 bl3_0 nbl3_0 nbl2_0 bl2_0
+  vddc_0 bl1_0 nbl1_0 nbl0_0 bl0_0 q1_11 d1_11 weny1_term_11 vss_ast1_11
+  vss_ast0_11 weny0_term_11 d0_11 q0_11 cap_ctrl10_term_11 cap_ctrl11_term_11
+  cap_ctrl12_term_11 q1_10 d1_10 weny1_term_10 vss_ast1_10 vss_ast0_10
+  weny0_term_10 d0_10 q0_10 cap_ctrl10_term_10 cap_ctrl11_term_10
+  cap_ctrl12_term_10 q1_9 d1_9 weny1_term_9 vss_ast1_9 vss_ast0_9
+  weny0_term_9 d0_9 q0_9 cap_ctrl10_term_9 cap_ctrl11_term_9
+  cap_ctrl12_term_9 q1_8 d1_8 weny1_term_8 vss_ast1_8 vss_ast0_8 weny0_term_8
+  d0_8 q0_8 cap_ctrl10_term_8 cap_ctrl11_term_8 cap_ctrl12_term_8 q1_7 d1_7
+  weny1_term_7 vss_ast1_7 vss_ast0_7 weny0_term_7 d0_7 q0_7 cap_ctrl10_term_7
+  cap_ctrl11_term_7 cap_ctrl12_term_7 q1_6 d1_6 weny1_term_6 vss_ast1_6
+  vss_ast0_6 weny0_term_6 d0_6 q0_6 cap_ctrl10_term_6 cap_ctrl11_term_6
+  cap_ctrl12_term_6 q1_5 d1_5 weny1_term_5 vss_ast1_5 vss_ast0_5 weny0_term_5
+  vpw d0_5 q0_5 cap_ctrl10_term_5 cap_ctrl11_term_5 cap_ctrl12_term_5 q1_4
+  d1_4 weny1_term_4 vss_ast1_4 vss_ast0_4 weny0_term_4 d0_4 q0_4
+  cap_ctrl10_term_4 cap_ctrl11_term_4 cap_ctrl12_term_4 q1_3 d1_3
+  weny1_term_3 vss_ast1_3 vss_ast0_3 weny0_term_3 d0_3 q0_3 cap_ctrl10_term_3
+  cap_ctrl11_term_3 cap_ctrl12_term_3 q1_2 d1_2 weny1_term_2 vss_ast1_2 log0
+  vss_ast0_2 weny0_term_2 d0_2 q0_2 cap_ctrl10_term_2 cap_ctrl11_term_2
+  cap_ctrl12_term_2 q1_1 d1_1 weny1_term_1 vss_ast1_1 vss_ast0_1 weny0_term_1
+  d0_1 q0_1 cap_ctrl10_term_1 cap_ctrl11_term_1 cap_ctrl12_term_1 q1_0 d1_0
+  weny1_term_0 vss_ast1_0 vss_ast0_0 weny0_term_0 d0_0 vddpe q0_0
+  cap_ctrl10_term_0 cap_ctrl11_term_0 cap_ctrl12_term_0 blprech nact_cc yw3
+  yw2 yw1 yw0 nyr3 nyr2 nyr1 nyr0 rdmux nsae saprech log0_sa iwclk0 iwclk1
+  dwl_mainbreak
** sram128x46io_row_r: 1632 flat devices **
xio_cdm_row_r bl3_11 nbl3_11 nbl2_11 bl2_11 vddc_11 bl1_11 nbl1_11 nbl0_11
+  bl0_11 bl3_10 nbl3_10 nbl2_10 bl2_10 vddc_10 vddpe bl1_10 nbl1_10 nbl0_10
+  bl0_10 bl3_9 nbl3_9 nbl2_9 bl2_9 vddc_9 bl1_9 nbl1_9 nbl0_9 bl0_9 bl3_8
+  nbl3_8 nbl2_8 bl2_8 vddc_8 bl1_8 nbl1_8 nbl0_8 bl0_8 bl3_7 nbl3_7 nbl2_7
+  bl2_7 vddc_7 bl1_7 nbl1_7 nbl0_7 bl0_7 bl3_6 nbl3_6 nbl2_6 bl2_6 vddc_6
+  vddce bl1_6 nbl1_6 nbl0_6 bl0_6 bl3_5 nbl3_5 nbl2_5 bl2_5 vddc_5 bl1_5
+  nbl1_5 nbl0_5 bl0_5 bl3_4 nbl3_4 nbl2_4 bl2_4 vddc_4 bl1_4 nbl1_4 nbl0_4
+  bl0_4 bl3_3 nbl3_3 nbl2_3 bl2_3 vddc_3 bl1_3 nbl1_3 nbl0_3 bl0_3 bl3_2
+  nbl3_2 nbl2_2 bl2_2 vddc_2 bl1_2 nbl1_2 nbl0_2 bl0_2 bl3_1 nbl3_1 nbl2_1
+  bl2_1 vddc_1 bl1_1 nbl1_1 nbl0_1 bl0_1 bl3_0 nbl3_0 nbl2_0 bl2_0 vddc_0
+  bl1_0 nbl1_0 nbl0_0 bl0_0 q1_11 d1_11 weny1_term_11 vss_ast1_11 vss_ast0_11
+  weny0_term_11 d0_11 q0_11 cap_ctrl10_term_11 cap_ctrl11_term_11
+  cap_ctrl12_term_11 q1_10 d1_10 weny1_term_10 vss_ast1_10 vss_ast0_10
+  weny0_term_10 d0_10 q0_10 cap_ctrl10_term_10 cap_ctrl11_term_10
+  cap_ctrl12_term_10 q1_9 d1_9 weny1_term_9 vss_ast1_9 vss_ast0_9
+  weny0_term_9 d0_9 q0_9 cap_ctrl10_term_9 cap_ctrl11_term_9
+  cap_ctrl12_term_9 q1_8 d1_8 weny1_term_8 vss_ast1_8 vss_ast0_8 weny0_term_8
+  d0_8 q0_8 cap_ctrl10_term_8 cap_ctrl11_term_8 cap_ctrl12_term_8 q1_7 d1_7
+  weny1_term_7 vss_ast1_7 vss_ast0_7 weny0_term_7 d0_7 q0_7 cap_ctrl10_term_7
+  cap_ctrl11_term_7 cap_ctrl12_term_7 q1_6 d1_6 weny1_term_6 vss_ast1_6
+  vss_ast0_6 weny0_term_6 d0_6 q0_6 cap_ctrl10_term_6 cap_ctrl11_term_6
+  cap_ctrl12_term_6 q1_5 d1_5 weny1_term_5 log0 vss_ast1_5 vss_ast0_5
+  weny0_term_5 d0_5 q0_5 cap_ctrl10_term_5 cap_ctrl11_term_5
+  cap_ctrl12_term_5 q1_4 d1_4 weny1_term_4 vss_ast1_4 vss_ast0_4 weny0_term_4
+  d0_4 q0_4 cap_ctrl10_term_4 cap_ctrl11_term_4 cap_ctrl12_term_4 q1_3 d1_3
+  weny1_term_3 vss_ast1_3 vss_ast0_3 weny0_term_3 d0_3 q0_3 cap_ctrl10_term_3
+  cap_ctrl11_term_3 cap_ctrl12_term_3 q1_2 d1_2 weny1_term_2 vss_ast1_2
+  vss_ast0_2 weny0_term_2 d0_2 q0_2 cap_ctrl10_term_2 cap_ctrl11_term_2
+  cap_ctrl12_term_2 q1_1 d1_1 weny1_term_1 vss_ast1_1 vss_ast0_1 weny0_term_1
+  vpw d0_1 q0_1 cap_ctrl10_term_1 cap_ctrl11_term_1 cap_ctrl12_term_1 q1_0
+  d1_0 weny1_term_0 vss_ast1_0 vss_ast0_0 weny0_term_0 d0_0 q0_0
+  cap_ctrl10_term_0 cap_ctrl11_term_0 cap_ctrl12_term_0 blprech nact_cc yw1
+  yw0 nyr1 nyr0 rdmux nsae saprech log0_sa iwclk0 iwclk1 dwl_main log0 yw3
+  yw2 nyr3 nyr2 dwl_mainbreak sram128x46iocdm_r
.ends sram128x46io_row_r
****
.subckt sram128x46io_slice bl3_22 nbl3_22 nbl2_22 bl2_22 vddc_23 bl1_22
+  nbl1_22 nbl0_22 bl0_22 bl3_21 nbl3_21 nbl2_21 bl2_21 vddc_22 bl1_21 nbl1_21
+  nbl0_21 bl0_21 bl3_20 nbl3_20 nbl2_20 bl2_20 vddc_21 bl1_20 nbl1_20 nbl0_20
+  bl0_20 bl3_19 nbl3_19 nbl2_19 bl2_19 vddc_20 bl1_19 nbl1_19 nbl0_19 bl0_19
+  bl3_18 nbl3_18 nbl2_18 bl2_18 vddc_19 bl1_18 nbl1_18 nbl0_18 bl0_18 bl3_17
+  nbl3_17 nbl2_17 bl2_17 vddc_18 bl1_17 nbl1_17 nbl0_17 bl0_17 bl3_16 nbl3_16
+  nbl2_16 bl2_16 vddc_17 bl1_16 nbl1_16 nbl0_16 bl0_16 bl3_15 nbl3_15 nbl2_15
+  bl2_15 vddc_16 bl1_15 nbl1_15 nbl0_15 bl0_15 bl3_14 nbl3_14 nbl2_14 bl2_14
+  vddc_15 bl1_14 nbl1_14 nbl0_14 bl0_14 bl3_13 nbl3_13 nbl2_13 bl2_13 vddc_14
+  bl1_13 nbl1_13 nbl0_13 bl0_13 bl3_12 nbl3_12 nbl2_12 bl2_12 vddc_13 bl1_12
+  nbl1_12 nbl0_12 bl0_12 bl3_11 nbl3_11 nbl2_11 bl2_11 vddc_12 bl1_11 nbl1_11
+  nbl0_11 bl0_11 nact_cc nretnvt nactc vddp_nor log1 log0_sa dbl dwl_turn gtp
+  nla_p2[1] nla_p2[0] la_p2[1] la_p2[0] nra_p2[5] nra_p2[4] nra_p2[3]
+  nra_p2[2] nra_p2[1] nra_p2[0] ra_p2[5] ra_p2[4] ra_p2[3] ra_p2[2] ra_p2[1]
+  ra_p2[0] cen_p2 nret vddc_11 bl0_10 nbl0_10 nbl1_10 bl1_10 vddc_10 bl2_10
+  nbl2_10 nbl3_10 bl3_10 bl0_9 nbl0_9 nbl1_9 bl1_9 vddc_9 bl2_9 nbl2_9 nbl3_9
+  bl3_9 bl0_8 nbl0_8 nbl1_8 bl1_8 vddc_8 bl2_8 nbl2_8 nbl3_8 bl3_8 bl0_7
+  nbl0_7 nbl1_7 bl1_7 vddc_7 bl2_7 nbl2_7 nbl3_7 bl3_7 bl0_6 nbl0_6 nbl1_6
+  bl1_6 vddc_6 bl2_6 nbl2_6 nbl3_6 bl3_6 bl0_5 nbl0_5 nbl1_5 bl1_5 vddc_5
+  bl2_5 nbl2_5 nbl3_5 bl3_5 bl0_4 nbl0_4 nbl1_4 bl1_4 vddce vddc_4 bl2_4
+  nbl2_4 nbl3_4 bl3_4 bl0_3 nbl0_3 nbl1_3 bl1_3 vddc_3 bl2_3 nbl2_3 nbl3_3
+  bl3_3 bl0_2 nbl0_2 nbl1_2 bl1_2 vddc_2 bl2_2 nbl2_2 nbl3_2 bl3_2 bl0_1
+  nbl0_1 nbl1_1 bl1_1 vddc_1 bl2_1 nbl2_1 nbl3_1 bl3_1 bl0_0 nbl0_0 nbl1_0
+  bl1_0 vddc_0 bl2_0 nbl2_0 nbl3_0 bl3_0 q1_22 d1_22 weny1_term_22
+  vss_ast1_22 vss_ast0_22 weny0_term_22 d0_22 q0_22 cap_ctrl10_term_22
+  cap_ctrl11_term_22 cap_ctrl12_term_22 q1_21 d1_21 weny1_term_21 vss_ast1_21
+  vss_ast0_21 weny0_term_21 d0_21 q0_21 cap_ctrl10_term_21 cap_ctrl11_term_21
+  cap_ctrl12_term_21 q1_20 d1_20 weny1_term_20 vss_ast1_20 vss_ast0_20
+  weny0_term_20 d0_20 q0_20 cap_ctrl10_term_20 cap_ctrl11_term_20
+  cap_ctrl12_term_20 q1_19 d1_19 weny1_term_19 vss_ast1_19 vss_ast0_19
+  weny0_term_19 d0_19 vddpe q0_19 cap_ctrl10_term_19 cap_ctrl11_term_19
+  cap_ctrl12_term_19 q1_18 d1_18 weny1_term_18 vss_ast1_18 log0 vss_ast0_18
+  weny0_term_18 d0_18 q0_18 cap_ctrl10_term_18 cap_ctrl11_term_18
+  cap_ctrl12_term_18 q1_17 d1_17 weny1_term_17 vss_ast1_17 vss_ast0_17
+  weny0_term_17 d0_17 q0_17 cap_ctrl10_term_17 cap_ctrl11_term_17
+  cap_ctrl12_term_17 q1_16 d1_16 weny1_term_16 vss_ast1_16 vss_ast0_16
+  weny0_term_16 d0_16 q0_16 cap_ctrl10_term_16 cap_ctrl11_term_16
+  cap_ctrl12_term_16 q1_15 d1_15 weny1_term_15 vss_ast1_15 vss_ast0_15
+  weny0_term_15 vpw d0_15 q0_15 cap_ctrl10_term_15 cap_ctrl11_term_15
+  cap_ctrl12_term_15 q1_14 d1_14 weny1_term_14 vss_ast1_14 vss_ast0_14
+  weny0_term_14 d0_14 q0_14 cap_ctrl10_term_14 cap_ctrl11_term_14
+  cap_ctrl12_term_14 q1_13 d1_13 weny1_term_13 vss_ast1_13 vss_ast0_13
+  weny0_term_13 d0_13 q0_13 cap_ctrl10_term_13 cap_ctrl11_term_13
+  cap_ctrl12_term_13 q1_12 d1_12 weny1_term_12 vss_ast1_12 vss_ast0_12
+  weny0_term_12 d0_12 q0_12 cap_ctrl10_term_12 cap_ctrl11_term_12
+  cap_ctrl12_term_12 q1_11 d1_11 weny1_term_11 vss_ast1_11 vss_ast0_11
+  weny0_term_11 d0_11 q0_11 cap_ctrl10_term_11 cap_ctrl11_term_11
+  cap_ctrl12_term_11 actp dft_p2 gwen_p2 dbl_nbl_wa_turn dbl_nbl_wa
+  penso_term pso1_term pso0_term wablm1_term wablm0_term wabl_term rawlm1
+  rawlm0 rawl emas ema[0] ema[1] ema[2] emaw[0] emaw[1] ret1n rdt gwen cen
+  clk a0 a1 a2 a3 a4 a5 a6 a7 a8 a9 a10 cap_ctrl12_term_10 cap_ctrl11_term_10
+  cap_ctrl10_term_10 q0_10 d0_10 weny0_term_10 vss_ast0_10 vss_ast1_10
+  weny1_term_10 d1_10 q1_10 cap_ctrl12_term_9 cap_ctrl11_term_9
+  cap_ctrl10_term_9 q0_9 d0_9 weny0_term_9 vss_ast0_9 vss_ast1_9 weny1_term_9
+  d1_9 q1_9 cap_ctrl12_term_8 cap_ctrl11_term_8 cap_ctrl10_term_8 q0_8 d0_8
+  weny0_term_8 vss_ast0_8 vss_ast1_8 weny1_term_8 d1_8 q1_8 cap_ctrl12_term_7
+  cap_ctrl11_term_7 cap_ctrl10_term_7 q0_7 d0_7 weny0_term_7 vss_ast0_7
+  vss_ast1_7 weny1_term_7 d1_7 q1_7 cap_ctrl12_term_6 cap_ctrl11_term_6
+  cap_ctrl10_term_6 q0_6 d0_6 weny0_term_6 vss_ast0_6 vss_ast1_6 weny1_term_6
+  d1_6 q1_6 cap_ctrl12_term_5 cap_ctrl11_term_5 cap_ctrl10_term_5 q0_5 d0_5
+  weny0_term_5 vss_ast0_5 vss_ast1_5 weny1_term_5 d1_5 q1_5 cap_ctrl12_term_4
+  cap_ctrl11_term_4 cap_ctrl10_term_4 q0_4 d0_4 weny0_term_4 vss_ast0_4
+  vss_ast1_4 weny1_term_4 d1_4 q1_4 cap_ctrl12_term_3 cap_ctrl11_term_3
+  cap_ctrl10_term_3 q0_3 d0_3 weny0_term_3 vss_ast0_3 vss_ast1_3 weny1_term_3
+  d1_3 q1_3 cap_ctrl12_term_2 cap_ctrl11_term_2 cap_ctrl10_term_2 q0_2 d0_2
+  weny0_term_2 vss_ast0_2 vss_ast1_2 weny1_term_2 d1_2 q1_2 cap_ctrl12_term_1
+  cap_ctrl11_term_1 cap_ctrl10_term_1 q0_1 d0_1 weny0_term_1 vss_ast0_1
+  vss_ast1_1 weny1_term_1 d1_1 q1_1 cap_ctrl12_term_0 cap_ctrl11_term_0
+  cap_ctrl10_term_0 q0_0 d0_0 weny0_term_0 vss_ast0_0 vss_ast1_0 weny1_term_0
+  d1_0 q1_0
** sram128x46io_slice: 3783 flat devices **
xck_blk vddpe vddce nretnvt nactc vddp_nor log1 log0 dbl dwl_turn gtp
+  nla_p2[1] nla_p2[0] la_p2[1] la_p2[0] nra_p2[5] nra_p2[4] nra_p2[3]
+  nra_p2[2] nra_p2[1] nra_p2[0] ra_p2[5] ra_p2[4] ra_p2[3] ra_p2[2] ra_p2[1]
+  ra_p2[0] cen_p2 nret vddc_11 actp vpw dft_p2 gwen_p2 dbl_nbl_wa_turn
+  dbl_nbl_wa penso_term pso1_term pso0_term wablm1_term wablm0_term wabl_term
+  rawlm1 rawlm0 rawl emas ema[0] ema[1] ema[2] emaw[0] emaw[1] ret1n rdt gwen
+  cen clk a0 a1 a2 a3 a4 a5 a6 a7 a8 a9 a10 vddpe blprech_r nact_cc yw3_r
+  yw2_r yw1_r yw0_r nyr3 nyr2 nyr1 nyr0 rdmux nsae_r saprech iwclk1 dwl_turn
+  blprech yw3 yw2 yw1 yw0 nsae log0_sa iwclk0 sram128x46ck_blk
xio_left bl0_10 nbl0_10 nbl1_10 bl1_10 vddc_10 bl2_10 nbl2_10 nbl3_10 bl3_10
+  bl0_9 nbl0_9 nbl1_9 bl1_9 vddc_9 bl2_9 nbl2_9 nbl3_9 bl3_9 bl0_8 nbl0_8
+  nbl1_8 bl1_8 vddc_8 bl2_8 nbl2_8 nbl3_8 bl3_8 bl0_7 nbl0_7 nbl1_7 bl1_7
+  vddc_7 bl2_7 nbl2_7 nbl3_7 bl3_7 bl0_6 nbl0_6 nbl1_6 bl1_6 vddc_6 bl2_6
+  nbl2_6 nbl3_6 bl3_6 bl0_5 nbl0_5 nbl1_5 bl1_5 vddce vddc_5 bl2_5 nbl2_5
+  nbl3_5 bl3_5 bl0_4 nbl0_4 nbl1_4 bl1_4 vddpe vddc_4 bl2_4 nbl2_4 nbl3_4
+  bl3_4 bl0_3 nbl0_3 nbl1_3 bl1_3 vddc_3 bl2_3 nbl2_3 nbl3_3 bl3_3 bl0_2
+  nbl0_2 nbl1_2 bl1_2 vddc_2 bl2_2 nbl2_2 nbl3_2 bl3_2 bl0_1 nbl0_1 nbl1_1
+  bl1_1 vddc_1 bl2_1 nbl2_1 nbl3_1 bl3_1 bl0_0 nbl0_0 nbl1_0 bl1_0 vddc_0
+  bl2_0 nbl2_0 nbl3_0 bl3_0 cap_ctrl12_term_10 cap_ctrl11_term_10
+  cap_ctrl10_term_10 q0_10 d0_10 weny0_term_10 vss_ast0_10 vss_ast1_10
+  weny1_term_10 d1_10 q1_10 cap_ctrl12_term_9 cap_ctrl11_term_9
+  cap_ctrl10_term_9 q0_9 d0_9 weny0_term_9 vss_ast0_9 vss_ast1_9 weny1_term_9
+  d1_9 q1_9 cap_ctrl12_term_8 cap_ctrl11_term_8 cap_ctrl10_term_8 q0_8 d0_8
+  weny0_term_8 vss_ast0_8 vss_ast1_8 weny1_term_8 d1_8 q1_8 cap_ctrl12_term_7
+  cap_ctrl11_term_7 cap_ctrl10_term_7 q0_7 d0_7 weny0_term_7 vss_ast0_7
+  vss_ast1_7 weny1_term_7 d1_7 q1_7 cap_ctrl12_term_6 cap_ctrl11_term_6
+  cap_ctrl10_term_6 q0_6 d0_6 weny0_term_6 vss_ast0_6 vss_ast1_6 weny1_term_6
+  d1_6 q1_6 cap_ctrl12_term_5 cap_ctrl11_term_5 cap_ctrl10_term_5 q0_5 d0_5
+  weny0_term_5 vss_ast0_5 vss_ast1_5 weny1_term_5 d1_5 q1_5 cap_ctrl12_term_4
+  cap_ctrl11_term_4 cap_ctrl10_term_4 q0_4 d0_4 weny0_term_4 vss_ast0_4
+  vss_ast1_4 weny1_term_4 d1_4 q1_4 cap_ctrl12_term_3 cap_ctrl11_term_3
+  cap_ctrl10_term_3 q0_3 d0_3 weny0_term_3 vss_ast0_3 log0 vss_ast1_3
+  weny1_term_3 d1_3 q1_3 cap_ctrl12_term_2 cap_ctrl11_term_2
+  cap_ctrl10_term_2 q0_2 d0_2 vpw weny0_term_2 vss_ast0_2 vss_ast1_2
+  weny1_term_2 d1_2 q1_2 cap_ctrl12_term_1 cap_ctrl11_term_1
+  cap_ctrl10_term_1 q0_1 d0_1 weny0_term_1 vss_ast0_1 vss_ast1_1 weny1_term_1
+  d1_1 q1_1 cap_ctrl12_term_0 cap_ctrl11_term_0 cap_ctrl10_term_0 q0_0 d0_0
+  weny0_term_0 vss_ast0_0 vss_ast1_0 weny1_term_0 d1_0 q1_0 blprech nact_cc
+  yw3 yw2 yw1 yw0 nyr3 nyr2 nyr1 nyr0 rdmux nsae saprech log0_sa iwclk0
+  iwclk1 log0 sram128x46io_row_l
xio_right bl3_22 nbl3_22 nbl2_22 bl2_22 vddc_23 bl1_22 nbl1_22 nbl0_22 bl0_22
+  bl3_21 nbl3_21 nbl2_21 bl2_21 vddc_22 bl1_21 nbl1_21 nbl0_21 bl0_21 bl3_20
+  nbl3_20 nbl2_20 bl2_20 vddc_21 bl1_20 nbl1_20 nbl0_20 bl0_20 bl3_19 nbl3_19
+  nbl2_19 bl2_19 vddc_20 bl1_19 nbl1_19 nbl0_19 bl0_19 bl3_18 nbl3_18 nbl2_18
+  bl2_18 vddc_19 bl1_18 nbl1_18 nbl0_18 bl0_18 bl3_17 nbl3_17 nbl2_17 bl2_17
+  vddc_18 vddce bl1_17 nbl1_17 nbl0_17 bl0_17 bl3_16 nbl3_16 nbl2_16 bl2_16
+  vddc_17 bl1_16 nbl1_16 nbl0_16 bl0_16 bl3_15 nbl3_15 nbl2_15 bl2_15 vddc_16
+  bl1_15 nbl1_15 nbl0_15 bl0_15 bl3_14 nbl3_14 nbl2_14 bl2_14 vddc_15 bl1_14
+  nbl1_14 nbl0_14 bl0_14 bl3_13 nbl3_13 nbl2_13 bl2_13 vddc_14 bl1_13 nbl1_13
+  nbl0_13 bl0_13 bl3_12 nbl3_12 nbl2_12 bl2_12 vddc_13 bl1_12 nbl1_12 nbl0_12
+  bl0_12 bl3_11 nbl3_11 nbl2_11 bl2_11 vddc_12 bl1_11 nbl1_11 nbl0_11 bl0_11
+  q1_22 d1_22 weny1_term_22 vss_ast1_22 vss_ast0_22 weny0_term_22 d0_22 q0_22
+  cap_ctrl10_term_22 cap_ctrl11_term_22 cap_ctrl12_term_22 q1_21 d1_21
+  weny1_term_21 vss_ast1_21 vss_ast0_21 weny0_term_21 d0_21 q0_21
+  cap_ctrl10_term_21 cap_ctrl11_term_21 cap_ctrl12_term_21 q1_20 d1_20
+  weny1_term_20 vss_ast1_20 vss_ast0_20 weny0_term_20 d0_20 q0_20
+  cap_ctrl10_term_20 cap_ctrl11_term_20 cap_ctrl12_term_20 q1_19 d1_19
+  weny1_term_19 vss_ast1_19 vss_ast0_19 weny0_term_19 d0_19 q0_19
+  cap_ctrl10_term_19 cap_ctrl11_term_19 cap_ctrl12_term_19 q1_18 d1_18
+  weny1_term_18 vss_ast1_18 vss_ast0_18 weny0_term_18 d0_18 q0_18
+  cap_ctrl10_term_18 cap_ctrl11_term_18 cap_ctrl12_term_18 q1_17 d1_17
+  weny1_term_17 vss_ast1_17 vss_ast0_17 weny0_term_17 d0_17 q0_17
+  cap_ctrl10_term_17 cap_ctrl11_term_17 cap_ctrl12_term_17 q1_16 d1_16
+  weny1_term_16 vss_ast1_16 vss_ast0_16 weny0_term_16 vpw d0_16 q0_16
+  cap_ctrl10_term_16 cap_ctrl11_term_16 cap_ctrl12_term_16 q1_15 d1_15
+  weny1_term_15 vss_ast1_15 vss_ast0_15 weny0_term_15 d0_15 q0_15
+  cap_ctrl10_term_15 cap_ctrl11_term_15 cap_ctrl12_term_15 q1_14 d1_14
+  weny1_term_14 vss_ast1_14 vss_ast0_14 weny0_term_14 d0_14 q0_14
+  cap_ctrl10_term_14 cap_ctrl11_term_14 cap_ctrl12_term_14 q1_13 d1_13
+  weny1_term_13 vss_ast1_13 log0 vss_ast0_13 weny0_term_13 d0_13 q0_13
+  cap_ctrl10_term_13 cap_ctrl11_term_13 cap_ctrl12_term_13 q1_12 d1_12
+  weny1_term_12 vss_ast1_12 vss_ast0_12 weny0_term_12 d0_12 q0_12
+  cap_ctrl10_term_12 cap_ctrl11_term_12 cap_ctrl12_term_12 q1_11 d1_11
+  weny1_term_11 vss_ast1_11 vss_ast0_11 weny0_term_11 d0_11 vddpe q0_11
+  cap_ctrl10_term_11 cap_ctrl11_term_11 cap_ctrl12_term_11 blprech_r nact_cc
+  yw3_r yw2_r yw1_r yw0_r nyr3 nyr2 nyr1 nyr0 rdmux nsae_r saprech log0_sa
+  iwclk0 iwclk1 dwl_turn sram128x46io_row_r
.ends sram128x46io_slice
****
.subckt sram128x46cchs4wd_edgbl_dummy_ull dbl dwl vddc vnwc vnwp vpw vssc
+  wl[0] wl[1]
** sram128x46cchs4wd_edgbl_dummy_ull: 12 flat devices **
mi0.mxn0 net11 wl[0] vssc vpw nchpg_ullsr W=0.105U L=0.035U NF=1
mi0.mxn1 i0.cored vssc vssc vpw nchpd_ullsr W=0.14U L=0.035U NF=1
mi0.mxn2 vssc i0.core vssc vpw nchpd_ullsr W=0.14U L=0.035U NF=1
mi0.mxn3 dbl vssc i0.cored vpw nchpg_ullsr W=0.105U L=0.035U NF=1
mi0.mxp0 vssc i0.core vddc vnwc pchpu_ullsr W=0.05U L=0.035U NF=1
mi0.mxp1 i0.core vssc vddc vnwc pchpu_ullsr W=0.05U L=0.035U NF=1
mi14.mxn0 net11 wl[1] vssc vpw nchpg_ullsr W=0.105U L=0.035U NF=1
mi14.mxn1 i14.cored vssc vssc vpw nchpd_ullsr W=0.14U L=0.035U NF=1
mi14.mxn2 vssc i14.core vssc vpw nchpd_ullsr W=0.14U L=0.035U NF=1
mi14.mxn3 dbl vssc i14.cored vpw nchpg_ullsr W=0.105U L=0.035U NF=1
mi14.mxp0 vssc i14.core vddc vnwc pchpu_ullsr W=0.05U L=0.035U NF=1
mi14.mxp1 i14.core vssc vddc vnwc pchpu_ullsr W=0.05U L=0.035U NF=1
.ends sram128x46cchs4wd_edgbl_dummy_ull
****
.subckt sram128x46cchs4_ull bl[0] bl[1] bl[2] bl[3] cored00 cored01 cored10
+  cored11 cored20 cored21 cored30 cored31 nbl[0] nbl[1] nbl[2] nbl[3]
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc vddce vddpe vnwc vpw vssc vsse wl[0] wl[1]
** sram128x46cchs4_ull: 48 flat devices **
mi26.mxnpdl ncored01 cored01 vssc vpw nchpd_ullsr W=0.14U L=0.035U NF=1
mi26.mxnpdr cored01 ncored01 vssc vpw nchpd_ullsr W=0.14U L=0.035U NF=1
mi26.mxnpgl nbl[0] wl[1] ncored01 vpw nchpg_ullsr W=0.105U L=0.035U NF=1
mi26.mxnpgr bl[0] wl[1] cored01 vpw nchpg_ullsr W=0.105U L=0.035U NF=1
mi26.mxppul ncored01 cored01 vddc vnwc pchpu_ullsr W=0.05U L=0.035U NF=1
mi26.mxppur cored01 ncored01 vddc vnwc pchpu_ullsr W=0.05U L=0.035U NF=1
mi27.mxnpdl ncored00 cored00 vssc vpw nchpd_ullsr W=0.14U L=0.035U NF=1
mi27.mxnpdr cored00 ncored00 vssc vpw nchpd_ullsr W=0.14U L=0.035U NF=1
mi27.mxnpgl nbl[0] wl[0] ncored00 vpw nchpg_ullsr W=0.105U L=0.035U NF=1
mi27.mxnpgr bl[0] wl[0] cored00 vpw nchpg_ullsr W=0.105U L=0.035U NF=1
mi27.mxppul ncored00 cored00 vddc vnwc pchpu_ullsr W=0.05U L=0.035U NF=1
mi27.mxppur cored00 ncored00 vddc vnwc pchpu_ullsr W=0.05U L=0.035U NF=1
mi28.mxnpdl ncored11 cored11 vssc vpw nchpd_ullsr W=0.14U L=0.035U NF=1
mi28.mxnpdr cored11 ncored11 vssc vpw nchpd_ullsr W=0.14U L=0.035U NF=1
mi28.mxnpgl nbl[1] wl[1] ncored11 vpw nchpg_ullsr W=0.105U L=0.035U NF=1
mi28.mxnpgr bl[1] wl[1] cored11 vpw nchpg_ullsr W=0.105U L=0.035U NF=1
mi28.mxppul ncored11 cored11 vddc vnwc pchpu_ullsr W=0.05U L=0.035U NF=1
mi28.mxppur cored11 ncored11 vddc vnwc pchpu_ullsr W=0.05U L=0.035U NF=1
mi29.mxnpdl ncored10 cored10 vssc vpw nchpd_ullsr W=0.14U L=0.035U NF=1
mi29.mxnpdr cored10 ncored10 vssc vpw nchpd_ullsr W=0.14U L=0.035U NF=1
mi29.mxnpgl nbl[1] wl[0] ncored10 vpw nchpg_ullsr W=0.105U L=0.035U NF=1
mi29.mxnpgr bl[1] wl[0] cored10 vpw nchpg_ullsr W=0.105U L=0.035U NF=1
mi29.mxppul ncored10 cored10 vddc vnwc pchpu_ullsr W=0.05U L=0.035U NF=1
mi29.mxppur cored10 ncored10 vddc vnwc pchpu_ullsr W=0.05U L=0.035U NF=1
mi30.mxnpdl ncored21 cored21 vssc vpw nchpd_ullsr W=0.14U L=0.035U NF=1
mi30.mxnpdr cored21 ncored21 vssc vpw nchpd_ullsr W=0.14U L=0.035U NF=1
mi30.mxnpgl nbl[2] wl[1] ncored21 vpw nchpg_ullsr W=0.105U L=0.035U NF=1
mi30.mxnpgr bl[2] wl[1] cored21 vpw nchpg_ullsr W=0.105U L=0.035U NF=1
mi30.mxppul ncored21 cored21 vddc vnwc pchpu_ullsr W=0.05U L=0.035U NF=1
mi30.mxppur cored21 ncored21 vddc vnwc pchpu_ullsr W=0.05U L=0.035U NF=1
mi31.mxnpdl ncored20 cored20 vssc vpw nchpd_ullsr W=0.14U L=0.035U NF=1
mi31.mxnpdr cored20 ncored20 vssc vpw nchpd_ullsr W=0.14U L=0.035U NF=1
mi31.mxnpgl nbl[2] wl[0] ncored20 vpw nchpg_ullsr W=0.105U L=0.035U NF=1
mi31.mxnpgr bl[2] wl[0] cored20 vpw nchpg_ullsr W=0.105U L=0.035U NF=1
mi31.mxppul ncored20 cored20 vddc vnwc pchpu_ullsr W=0.05U L=0.035U NF=1
mi31.mxppur cored20 ncored20 vddc vnwc pchpu_ullsr W=0.05U L=0.035U NF=1
mi32.mxnpdl ncored31 cored31 vssc vpw nchpd_ullsr W=0.14U L=0.035U NF=1
mi32.mxnpdr cored31 ncored31 vssc vpw nchpd_ullsr W=0.14U L=0.035U NF=1
mi32.mxnpgl nbl[3] wl[1] ncored31 vpw nchpg_ullsr W=0.105U L=0.035U NF=1
mi32.mxnpgr bl[3] wl[1] cored31 vpw nchpg_ullsr W=0.105U L=0.035U NF=1
mi32.mxppul ncored31 cored31 vddc vnwc pchpu_ullsr W=0.05U L=0.035U NF=1
mi32.mxppur cored31 ncored31 vddc vnwc pchpu_ullsr W=0.05U L=0.035U NF=1
mi33.mxnpdl ncored30 cored30 vssc vpw nchpd_ullsr W=0.14U L=0.035U NF=1
mi33.mxnpdr cored30 ncored30 vssc vpw nchpd_ullsr W=0.14U L=0.035U NF=1
mi33.mxnpgl nbl[3] wl[0] ncored30 vpw nchpg_ullsr W=0.105U L=0.035U NF=1
mi33.mxnpgr bl[3] wl[0] cored30 vpw nchpg_ullsr W=0.105U L=0.035U NF=1
mi33.mxppul ncored30 cored30 vddc vnwc pchpu_ullsr W=0.05U L=0.035U NF=1
mi33.mxppur cored30 ncored30 vddc vnwc pchpu_ullsr W=0.05U L=0.035U NF=1
.ends sram128x46cchs4_ull
****
.subckt sram128x46mem_l_test10row vddc_11 vnwc_12 dbl dwl vddc_10 vnwc_11
+  bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10 bl[0]_9 nbl[0]_9 bl[1]_9 vddpe_9
+  vddce_9 vnwc_10 nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 nbl[0]_7
+  nbl[1]_7 vddpe_7 vpw_8 vddpe_6 vddce_6 vpw_7 bl[2]_6 nbl[2]_6 bl[0]_5
+  vddce_5 vddc_5 vnwc_6 vpw_6 nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4
+  vddpe_4 vddce_4 vnwc_5 nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe_3 vpw_4 nbl[0]_2
+  nbl[1]_2 vddpe_2 vddce_2 vnwc_3 vssc vpw_3 vddpe_1 vddce_1 vnwc_2 vpw_2
+  bl[2]_1 bl[3]_1 vddce_0 vddc_0 vnwc_1 vpw_1 bl[3]_0 vnwp_0 vpw_12 vnwp_1
+  bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vpw_11 nbl[1]_9
+  vddc_9 vpw_10 bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddce_8 vddc_8 vnwc_9 vpw_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddce_7 vddc_7 vnwc_8
+  bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc_6
+  vnwc_7 nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe_5 bl[2]_5 bl[3]_5
+  nbl[1]_4 vddc_4 vpw_5 bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddce_3
+  vddc_3 vnwc_4 bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc_2
+  bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc_1
+  nbl[2]_1 nbl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe_0 bl[2]_0
+  nbl[2]_0 nbl[3]_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_l_test10row: 540 flat devices **
xmem_l_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_edger dbl dwl vddc_11 vnwc_12 vnwp_1 vpw_12 vssc wl[0] wl[1]
+  sram128x46cchs4wd_edgbl_dummy_ull
.ends sram128x46mem_l_test10row
****
.subckt sram128x46mem_l_test11row vddc_11 vpw_12 vnwc_12 vddc_10 vnwc_11
+  bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10 bl[0]_9 nbl[0]_9 bl[1]_9 vddpe_9
+  vddce_9 vnwc_10 nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 nbl[0]_7
+  nbl[1]_7 vddpe_7 vpw_8 vddpe_6 vddce_6 vpw_7 bl[2]_6 nbl[2]_6 bl[0]_5
+  vddce_5 vddc_5 vnwc_6 vpw_6 nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4
+  vddpe_4 vddce_4 vnwc_5 nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe_3 vpw_4 nbl[0]_2
+  nbl[1]_2 vddpe_2 vddce_2 vnwc_3 vssc vpw_3 vddpe_1 vddce_1 vnwc_2 vpw_2
+  bl[2]_1 bl[3]_1 vddce_0 vddc_0 vnwc_1 vpw_1 bl[3]_0 vnwp_0 vnwp_1 dbl dwl
+  bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vpw_11 nbl[1]_9
+  vddc_9 vpw_10 bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddce_8 vddc_8 vnwc_9 vpw_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddce_7 vddc_7 vnwc_8
+  bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc_6
+  vnwc_7 nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe_5 bl[2]_5 bl[3]_5
+  nbl[1]_4 vddc_4 vpw_5 bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddce_3
+  vddc_3 vnwc_4 bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc_2
+  bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc_1
+  nbl[2]_1 nbl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe_0 bl[2]_0
+  nbl[2]_0 nbl[3]_0 vnwc_0 vpw_0 wl[0] wl[1]
** sram128x46mem_l_test11row: 540 flat devices **
xmem_l_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[1] wl[0]
+  sram128x46cchs4_ull
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[1] wl[0]
+  sram128x46cchs4_ull
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_edger dbl dwl vddc_11 vnwc_12 vnwp_1 vpw_12 vssc wl[0] wl[1]
+  sram128x46cchs4wd_edgbl_dummy_ull
.ends sram128x46mem_l_test11row
****
.subckt sram128x46cchs4wd_edgbl_1discharge_ull dbl dwl vddc vnwc vnwp vpw vssc
+  wl[0] wl[1]
** sram128x46cchs4wd_edgbl_1discharge_ull: 12 flat devices **
mi0.mxn0 net017 wl[0] vssc vpw nchpg_ullsr W=0.105U L=0.035U NF=1
mi0.mxn1 i0.cored vssc vssc vpw nchpd_ullsr W=0.14U L=0.035U NF=1
mi0.mxn2 vssc i0.core vssc vpw nchpd_ullsr W=0.14U L=0.035U NF=1
mi0.mxn3 dbl vssc i0.cored vpw nchpg_ullsr W=0.105U L=0.035U NF=1
mi0.mxp0 vssc i0.core vddc vnwc pchpu_ullsr W=0.05U L=0.035U NF=1
mi0.mxp1 i0.core vssc vddc vnwc pchpu_ullsr W=0.05U L=0.035U NF=1
mi14.mxn0 net017 wl[1] i14.ncored vpw nchpg_ullsr W=0.105U L=0.035U NF=1
mi14.mxn1 i14.ncored i14.core vssc vpw nchpd_ullsr W=0.14U L=0.035U NF=1
mi14.mxn2 i14.cored vddc vssc vpw nchpd_ullsr W=0.14U L=0.035U NF=1
mi14.mxn3 dbl dwl i14.cored vpw nchpg_ullsr W=0.105U L=0.035U NF=1
mi14.mxp0 vddc i14.core vddc vnwc pchpu_ullsr W=0.05U L=0.035U NF=1
mi14.mxp1 i14.core vddc vddc vnwc pchpu_ullsr W=0.05U L=0.035U NF=1
.ends sram128x46cchs4wd_edgbl_1discharge_ull
****
.subckt sram128x46mem_l_test30row vddc_11 vnwc_12 vddc_10 vnwc_11 bl[2]_10
+  nbl[2]_10 nbl[3]_10 bl[3]_10 bl[0]_9 nbl[0]_9 bl[1]_9 vddpe_9 vddce_9
+  vnwc_10 nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 nbl[0]_7 nbl[1]_7
+  vddpe_7 vpw_8 vddpe_6 vddce_6 vpw_7 bl[2]_6 nbl[2]_6 bl[0]_5 vddce_5 vddc_5
+  vnwc_6 vpw_6 nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4 vddpe_4 vddce_4
+  vnwc_5 nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe_3 vpw_4 nbl[0]_2 nbl[1]_2 vddpe_2
+  vddce_2 vnwc_3 vssc vpw_3 vddpe_1 vddce_1 vnwc_2 vpw_2 bl[2]_1 bl[3]_1
+  vddce_0 vddc_0 vnwc_1 vpw_1 bl[3]_0 vnwp_0 vpw_12 vnwp_1 dbl dwl bl[0]_10
+  nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vpw_11 nbl[1]_9 vddc_9
+  vpw_10 bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddce_8 vddc_8 vnwc_9 vpw_9 bl[2]_8
+  nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddce_7 vddc_7 vnwc_8 bl[2]_7
+  nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc_6 vnwc_7
+  nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe_5 bl[2]_5 bl[3]_5 nbl[1]_4
+  vddc_4 vpw_5 bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddce_3 vddc_3 vnwc_4
+  bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc_2 bl[2]_2 nbl[2]_2
+  nbl[3]_2 bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc_1 nbl[2]_1 nbl[3]_1
+  bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe_0 bl[2]_0 nbl[2]_0 nbl[3]_0 vnwc_0
+  vpw_0 wl[0] wl[1]
** sram128x46mem_l_test30row: 540 flat devices **
xmem_l_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[1] wl[0]
+  sram128x46cchs4_ull
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[1] wl[0]
+  sram128x46cchs4_ull
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_edger dbl dwl vddc_11 vnwc_12 vnwp_1 vpw_12 vssc wl[0] wl[1]
+  sram128x46cchs4wd_edgbl_1discharge_ull
.ends sram128x46mem_l_test30row
****
.subckt sram128x46mem_l_test12row vddc_11 vnwc_12 dbl dwl vddc_10 vnwc_11
+  bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10 bl[0]_9 nbl[0]_9 bl[1]_9 vddpe_9
+  vddce_9 vnwc_10 nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 nbl[0]_7
+  nbl[1]_7 vddpe_7 vpw_8 vddpe_6 vddce_6 vpw_7 bl[2]_6 nbl[2]_6 bl[0]_5
+  vddce_5 vddc_5 vnwc_6 vpw_6 nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4
+  vddpe_4 vddce_4 vnwc_5 nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe_3 vpw_4 nbl[0]_2
+  nbl[1]_2 vddpe_2 vddce_2 vnwc_3 vssc vpw_3 vddpe_1 vddce_1 vnwc_2 vpw_2
+  bl[2]_1 bl[3]_1 vddce_0 vddc_0 vnwc_1 vpw_1 bl[3]_0 vnwp_0 vpw_12 vnwp_1
+  bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vpw_11 nbl[1]_9
+  vddc_9 vpw_10 bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddce_8 vddc_8 vnwc_9 vpw_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddce_7 vddc_7 vnwc_8
+  bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc_6
+  vnwc_7 nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe_5 bl[2]_5 bl[3]_5
+  nbl[1]_4 vddc_4 vpw_5 bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddce_3
+  vddc_3 vnwc_4 bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc_2
+  bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc_1
+  nbl[2]_1 nbl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe_0 bl[2]_0
+  nbl[2]_0 nbl[3]_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_l_test12row: 540 flat devices **
xmem_l_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_edger dbl dwl vddc_11 vnwc_12 vnwp_1 vpw_12 vssc wl[0] wl[1]
+  sram128x46cchs4wd_edgbl_dummy_ull
.ends sram128x46mem_l_test12row
****
.subckt sram128x46mem_l_test13row vddc_11 vpw_12 vnwc_12 vddc_10 vnwc_11
+  bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10 bl[0]_9 nbl[0]_9 bl[1]_9 vddpe_9
+  vddce_9 vnwc_10 nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 nbl[0]_7
+  nbl[1]_7 vddpe_7 vpw_8 vddpe_6 vddce_6 vpw_7 bl[2]_6 nbl[2]_6 bl[0]_5
+  vddce_5 vddc_5 vnwc_6 vpw_6 nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4
+  vddpe_4 vddce_4 vnwc_5 nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe_3 vpw_4 nbl[0]_2
+  nbl[1]_2 vddpe_2 vddce_2 vnwc_3 vssc vpw_3 vddpe_1 vddce_1 vnwc_2 vpw_2
+  bl[2]_1 bl[3]_1 vddce_0 vddc_0 vnwc_1 vpw_1 bl[3]_0 vnwp_0 vnwp_1 dbl dwl
+  bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vpw_11 nbl[1]_9
+  vddc_9 vpw_10 bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddce_8 vddc_8 vnwc_9 vpw_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddce_7 vddc_7 vnwc_8
+  bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc_6
+  vnwc_7 nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe_5 bl[2]_5 bl[3]_5
+  nbl[1]_4 vddc_4 vpw_5 bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddce_3
+  vddc_3 vnwc_4 bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc_2
+  bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc_1
+  nbl[2]_1 nbl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe_0 bl[2]_0
+  nbl[2]_0 nbl[3]_0 vnwc_0 vpw_0 wl[0] wl[1]
** sram128x46mem_l_test13row: 540 flat devices **
xmem_l_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[1] wl[0]
+  sram128x46cchs4_ull
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[1] wl[0]
+  sram128x46cchs4_ull
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_edger dbl dwl vddc_11 vnwc_12 vnwp_1 vpw_12 vssc wl[0] wl[1]
+  sram128x46cchs4wd_edgbl_dummy_ull
.ends sram128x46mem_l_test13row
****
.subckt sram128x46mem_l_test17row vddc_11 vpw_12 vnwc_12 vddc_10 vnwc_11
+  bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10 bl[0]_9 nbl[0]_9 bl[1]_9 vddpe_9
+  vddce_9 vnwc_10 nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 nbl[0]_7
+  nbl[1]_7 vddpe_7 vpw_8 vddpe_6 vddce_6 vpw_7 bl[2]_6 nbl[2]_6 bl[0]_5
+  vddce_5 vddc_5 vnwc_6 vpw_6 nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4
+  vddpe_4 vddce_4 vnwc_5 nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe_3 vpw_4 nbl[0]_2
+  nbl[1]_2 vddpe_2 vddce_2 vnwc_3 vssc vpw_3 vddpe_1 vddce_1 vnwc_2 vpw_2
+  bl[2]_1 bl[3]_1 vddce_0 vddc_0 vnwc_1 vpw_1 bl[3]_0 vnwp_0 vnwp_1 dbl dwl
+  bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vpw_11 nbl[1]_9
+  vddc_9 vpw_10 bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddce_8 vddc_8 vnwc_9 vpw_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddce_7 vddc_7 vnwc_8
+  bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc_6
+  vnwc_7 nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe_5 bl[2]_5 bl[3]_5
+  nbl[1]_4 vddc_4 vpw_5 bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddce_3
+  vddc_3 vnwc_4 bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc_2
+  bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc_1
+  nbl[2]_1 nbl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe_0 bl[2]_0
+  nbl[2]_0 nbl[3]_0 vnwc_0 vpw_0 wl[0] wl[1]
** sram128x46mem_l_test17row: 540 flat devices **
xmem_l_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[1] wl[0]
+  sram128x46cchs4_ull
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[1] wl[0]
+  sram128x46cchs4_ull
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_edger dbl dwl vddc_11 vnwc_12 vnwp_1 vpw_12 vssc wl[0] wl[1]
+  sram128x46cchs4wd_edgbl_dummy_ull
.ends sram128x46mem_l_test17row
****
.subckt sram128x46mem_l_test18row vddc_11 vnwc_12 dbl dwl vddc_10 vnwc_11
+  bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10 bl[0]_9 nbl[0]_9 bl[1]_9 vddpe_9
+  vddce_9 vnwc_10 nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 nbl[0]_7
+  nbl[1]_7 vddpe_7 vpw_8 vddpe_6 vddce_6 vpw_7 bl[2]_6 nbl[2]_6 bl[0]_5
+  vddce_5 vddc_5 vnwc_6 vpw_6 nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4
+  vddpe_4 vddce_4 vnwc_5 nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe_3 vpw_4 nbl[0]_2
+  nbl[1]_2 vddpe_2 vddce_2 vnwc_3 vssc vpw_3 vddpe_1 vddce_1 vnwc_2 vpw_2
+  bl[2]_1 bl[3]_1 vddce_0 vddc_0 vnwc_1 vpw_1 bl[3]_0 vnwp_0 vpw_12 vnwp_1
+  bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vpw_11 nbl[1]_9
+  vddc_9 vpw_10 bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddce_8 vddc_8 vnwc_9 vpw_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddce_7 vddc_7 vnwc_8
+  bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc_6
+  vnwc_7 nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe_5 bl[2]_5 bl[3]_5
+  nbl[1]_4 vddc_4 vpw_5 bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddce_3
+  vddc_3 vnwc_4 bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc_2
+  bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc_1
+  nbl[2]_1 nbl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe_0 bl[2]_0
+  nbl[2]_0 nbl[3]_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_l_test18row: 540 flat devices **
xmem_l_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_edger dbl dwl vddc_11 vnwc_12 vnwp_1 vpw_12 vssc wl[0] wl[1]
+  sram128x46cchs4wd_edgbl_dummy_ull
.ends sram128x46mem_l_test18row
****
.subckt sram128x46mem_l_test19row vddc_11 vpw_12 vnwc_12 vddc_10 vnwc_11
+  bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10 bl[0]_9 nbl[0]_9 bl[1]_9 vddpe_9
+  vddce_9 vnwc_10 nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 nbl[0]_7
+  nbl[1]_7 vddpe_7 vpw_8 vddpe_6 vddce_6 vpw_7 bl[2]_6 nbl[2]_6 bl[0]_5
+  vddce_5 vddc_5 vnwc_6 vpw_6 nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4
+  vddpe_4 vddce_4 vnwc_5 nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe_3 vpw_4 nbl[0]_2
+  nbl[1]_2 vddpe_2 vddce_2 vnwc_3 vssc vpw_3 vddpe_1 vddce_1 vnwc_2 vpw_2
+  bl[2]_1 bl[3]_1 vddce_0 vddc_0 vnwc_1 vpw_1 bl[3]_0 vnwp_0 vnwp_1 dbl dwl
+  bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vpw_11 nbl[1]_9
+  vddc_9 vpw_10 bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddce_8 vddc_8 vnwc_9 vpw_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddce_7 vddc_7 vnwc_8
+  bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc_6
+  vnwc_7 nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe_5 bl[2]_5 bl[3]_5
+  nbl[1]_4 vddc_4 vpw_5 bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddce_3
+  vddc_3 vnwc_4 bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc_2
+  bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc_1
+  nbl[2]_1 nbl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe_0 bl[2]_0
+  nbl[2]_0 nbl[3]_0 vnwc_0 vpw_0 wl[0] wl[1]
** sram128x46mem_l_test19row: 540 flat devices **
xmem_l_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[1] wl[0]
+  sram128x46cchs4_ull
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[1] wl[0]
+  sram128x46cchs4_ull
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_edger dbl dwl vddc_11 vnwc_12 vnwp_1 vpw_12 vssc wl[0] wl[1]
+  sram128x46cchs4wd_edgbl_dummy_ull
.ends sram128x46mem_l_test19row
****
.subckt sram128x46mem_l_midt_row vddc_11 vnwc_12 dbl dwl vddc_10 vnwc_11
+  bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10 bl[0]_9 nbl[0]_9 bl[1]_9 vddpe_9
+  vddce_9 vnwc_10 nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 nbl[0]_7
+  nbl[1]_7 vddpe_7 vpw_8 vddpe_6 vddce_6 vpw_7 bl[2]_6 nbl[2]_6 bl[0]_5
+  vddce_5 vddc_5 vnwc_6 vpw_6 nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4
+  vddpe_4 vddce_4 vnwc_5 nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe_3 vpw_4 nbl[0]_2
+  nbl[1]_2 vddpe_2 vddce_2 vnwc_3 vssc vpw_3 vddpe_1 vddce_1 vnwc_2 vpw_2
+  bl[2]_1 bl[3]_1 vddce_0 vddc_0 vnwc_1 vpw_1 bl[3]_0 vnwp_0 vpw_12 vnwp_1
+  bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vpw_11 nbl[1]_9
+  vddc_9 vpw_10 bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddce_8 vddc_8 vnwc_9 vpw_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddce_7 vddc_7 vnwc_8
+  bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc_6
+  vnwc_7 nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe_5 bl[2]_5 bl[3]_5
+  nbl[1]_4 vddc_4 vpw_5 bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddce_3
+  vddc_3 vnwc_4 bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc_2
+  bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc_1
+  nbl[2]_1 nbl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe_0 bl[2]_0
+  nbl[2]_0 nbl[3]_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_l_midt_row: 540 flat devices **
xmem_l_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_edger dbl dwl vddc_11 vnwc_12 vnwp_1 vpw_12 vssc wl[0] wl[1]
+  sram128x46cchs4wd_edgbl_dummy_ull
.ends sram128x46mem_l_midt_row
****
.subckt sram128x46mem_l_mid_row vddc_11 vpw_12 vnwc_12 vddc_10 vnwc_11
+  bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10 bl[0]_9 nbl[0]_9 bl[1]_9 vddpe_9
+  vddce_9 vnwc_10 nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 nbl[0]_7
+  nbl[1]_7 vddpe_7 vpw_8 vddpe_6 vddce_6 vpw_7 bl[2]_6 nbl[2]_6 bl[0]_5
+  vddce_5 vddc_5 vnwc_6 vpw_6 nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4
+  vddpe_4 vddce_4 vnwc_5 nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe_3 vpw_4 nbl[0]_2
+  nbl[1]_2 vddpe_2 vddce_2 vnwc_3 vssc vpw_3 vddpe_1 vddce_1 vnwc_2 vpw_2
+  bl[2]_1 bl[3]_1 vddce_0 vddc_0 vnwc_1 vpw_1 bl[3]_0 vnwp_0 vnwp_1 dbl dwl
+  bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vpw_11 nbl[1]_9
+  vddc_9 vpw_10 bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddce_8 vddc_8 vnwc_9 vpw_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddce_7 vddc_7 vnwc_8
+  bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc_6
+  vnwc_7 nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe_5 bl[2]_5 bl[3]_5
+  nbl[1]_4 vddc_4 vpw_5 bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddce_3
+  vddc_3 vnwc_4 bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc_2
+  bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc_1
+  nbl[2]_1 nbl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe_0 bl[2]_0
+  nbl[2]_0 nbl[3]_0 vnwc_0 vpw_0 wl[0] wl[1]
** sram128x46mem_l_mid_row: 540 flat devices **
xmem_l_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[1] wl[0]
+  sram128x46cchs4_ull
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[1] wl[0]
+  sram128x46cchs4_ull
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_edger dbl dwl vddc_11 vnwc_12 vnwp_1 vpw_12 vssc wl[0] wl[1]
+  sram128x46cchs4wd_edgbl_dummy_ull
.ends sram128x46mem_l_mid_row
****
.subckt sram128x46mem_l_test20row vddc_11 vnwc_12 dbl dwl vddc_10 vnwc_11
+  bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10 bl[0]_9 nbl[0]_9 bl[1]_9 vddpe_9
+  vddce_9 vnwc_10 nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 nbl[0]_7
+  nbl[1]_7 vddpe_7 vpw_8 vddpe_6 vddce_6 vpw_7 bl[2]_6 nbl[2]_6 bl[0]_5
+  vddce_5 vddc_5 vnwc_6 vpw_6 nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4
+  vddpe_4 vddce_4 vnwc_5 nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe_3 vpw_4 nbl[0]_2
+  nbl[1]_2 vddpe_2 vddce_2 vnwc_3 vssc vpw_3 vddpe_1 vddce_1 vnwc_2 vpw_2
+  bl[2]_1 bl[3]_1 vddce_0 vddc_0 vnwc_1 vpw_1 bl[3]_0 vnwp_0 vpw_12 vnwp_1
+  bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vpw_11 nbl[1]_9
+  vddc_9 vpw_10 bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddce_8 vddc_8 vnwc_9 vpw_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddce_7 vddc_7 vnwc_8
+  bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc_6
+  vnwc_7 nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe_5 bl[2]_5 bl[3]_5
+  nbl[1]_4 vddc_4 vpw_5 bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddce_3
+  vddc_3 vnwc_4 bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc_2
+  bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc_1
+  nbl[2]_1 nbl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe_0 bl[2]_0
+  nbl[2]_0 nbl[3]_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_l_test20row: 540 flat devices **
xmem_l_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_edger dbl dwl vddc_11 vnwc_12 vnwp_1 vpw_12 vssc wl[0] wl[1]
+  sram128x46cchs4wd_edgbl_dummy_ull
.ends sram128x46mem_l_test20row
****
.subckt sram128x46mem_l_test21row vddc_11 vpw_12 vnwc_12 vddc_10 vnwc_11
+  bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10 bl[0]_9 nbl[0]_9 bl[1]_9 vddpe_9
+  vddce_9 vnwc_10 nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 nbl[0]_7
+  nbl[1]_7 vddpe_7 vpw_8 vddpe_6 vddce_6 vpw_7 bl[2]_6 nbl[2]_6 bl[0]_5
+  vddce_5 vddc_5 vnwc_6 vpw_6 nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4
+  vddpe_4 vddce_4 vnwc_5 nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe_3 vpw_4 nbl[0]_2
+  nbl[1]_2 vddpe_2 vddce_2 vnwc_3 vssc vpw_3 vddpe_1 vddce_1 vnwc_2 vpw_2
+  bl[2]_1 bl[3]_1 vddce_0 vddc_0 vnwc_1 vpw_1 bl[3]_0 vnwp_0 vnwp_1 dbl dwl
+  bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vpw_11 nbl[1]_9
+  vddc_9 vpw_10 bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddce_8 vddc_8 vnwc_9 vpw_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddce_7 vddc_7 vnwc_8
+  bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc_6
+  vnwc_7 nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe_5 bl[2]_5 bl[3]_5
+  nbl[1]_4 vddc_4 vpw_5 bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddce_3
+  vddc_3 vnwc_4 bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc_2
+  bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc_1
+  nbl[2]_1 nbl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe_0 bl[2]_0
+  nbl[2]_0 nbl[3]_0 vnwc_0 vpw_0 wl[0] wl[1]
** sram128x46mem_l_test21row: 540 flat devices **
xmem_l_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[1] wl[0]
+  sram128x46cchs4_ull
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[1] wl[0]
+  sram128x46cchs4_ull
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_edger dbl dwl vddc_11 vnwc_12 vnwp_1 vpw_12 vssc wl[0] wl[1]
+  sram128x46cchs4wd_edgbl_dummy_ull
.ends sram128x46mem_l_test21row
****
.subckt sram128x46mem_l_test22row vddc_11 vnwc_12 dbl dwl vddc_10 vnwc_11
+  bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10 bl[0]_9 nbl[0]_9 bl[1]_9 vddpe_9
+  vddce_9 vnwc_10 nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 nbl[0]_7
+  nbl[1]_7 vddpe_7 vpw_8 vddpe_6 vddce_6 vpw_7 bl[2]_6 nbl[2]_6 bl[0]_5
+  vddce_5 vddc_5 vnwc_6 vpw_6 nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4
+  vddpe_4 vddce_4 vnwc_5 nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe_3 vpw_4 nbl[0]_2
+  nbl[1]_2 vddpe_2 vddce_2 vnwc_3 vssc vpw_3 vddpe_1 vddce_1 vnwc_2 vpw_2
+  bl[2]_1 bl[3]_1 vddce_0 vddc_0 vnwc_1 vpw_1 bl[3]_0 vnwp_0 vpw_12 vnwp_1
+  bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vpw_11 nbl[1]_9
+  vddc_9 vpw_10 bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddce_8 vddc_8 vnwc_9 vpw_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddce_7 vddc_7 vnwc_8
+  bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc_6
+  vnwc_7 nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe_5 bl[2]_5 bl[3]_5
+  nbl[1]_4 vddc_4 vpw_5 bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddce_3
+  vddc_3 vnwc_4 bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc_2
+  bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc_1
+  nbl[2]_1 nbl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe_0 bl[2]_0
+  nbl[2]_0 nbl[3]_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_l_test22row: 540 flat devices **
xmem_l_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_edger dbl dwl vddc_11 vnwc_12 vnwp_1 vpw_12 vssc wl[0] wl[1]
+  sram128x46cchs4wd_edgbl_dummy_ull
.ends sram128x46mem_l_test22row
****
.subckt sram128x46mem_l_bot_row vddc_11 vnwc_12 dbl dwl vddc_10 vnwc_11
+  bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10 bl[0]_9 nbl[0]_9 bl[1]_9 vddpe_9
+  vddce_9 vnwc_10 nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 nbl[0]_7
+  nbl[1]_7 vddpe_7 vpw_8 vddpe_6 vddce_6 vpw_7 bl[2]_6 nbl[2]_6 bl[0]_5
+  vddce_5 vddc_5 vnwc_6 vpw_6 nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4
+  vddpe_4 vddce_4 vnwc_5 nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe_3 vpw_4 nbl[0]_2
+  nbl[1]_2 vddpe_2 vddce_2 vnwc_3 vssc vpw_3 vddpe_1 vddce_1 vnwc_2 vpw_2
+  bl[2]_1 bl[3]_1 vddce_0 vddc_0 vnwc_1 vsse_0 vpw_1 bl[3]_0 vnwp_0 vpw_12
+  vnwp_1 bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vsse_1
+  vpw_11 nbl[1]_9 vddc_9 vpw_10 bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddce_8
+  vddc_8 vnwc_9 vpw_9 bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7
+  vddce_7 vddc_7 vnwc_8 bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6
+  nbl[1]_6 bl[1]_6 vddc_6 vnwc_7 nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5
+  vddpe_5 bl[2]_5 bl[3]_5 nbl[1]_4 vddc_4 vpw_5 bl[2]_4 bl[3]_4 bl[0]_3
+  nbl[1]_3 bl[1]_3 vddce_3 vddc_3 vnwc_4 bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3
+  bl[0]_2 bl[1]_2 vddc_2 bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[0]_1 nbl[0]_1
+  nbl[1]_1 bl[1]_1 vddc_1 nbl[2]_1 nbl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0
+  vddpe_0 bl[2]_0 nbl[2]_0 nbl[3]_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_l_bot_row: 540 flat devices **
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_1 nbl[1]_1 nbl[2]_1 nbl[3]_1
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_1 vddce_1 vddpe_1 vnwc_2 vpw_2 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_4 nbl[1]_4
+  nbl[2]_4 nbl[3]_4 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_4 vddce_4 vddpe_4
+  vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_bot_l bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_0
+  vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vsse_0 wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_bot_r bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vsse_1 wl[0]
+  wl[1] sram128x46cchs4_ull
xmem_l_col_edger dbl dwl vddc_11 vnwc_12 vnwp_1 vpw_12 vssc wl[0] wl[1]
+  sram128x46cchs4wd_edgbl_dummy_ull
.ends sram128x46mem_l_bot_row
****
.subckt sram128x46mem_l_test23row vddc_11 vpw_12 vnwc_12 vddc_10 vnwc_11
+  bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10 bl[0]_9 nbl[0]_9 bl[1]_9 vddpe_9
+  vddce_9 vnwc_10 nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 nbl[0]_7
+  nbl[1]_7 vddpe_7 vpw_8 vddpe_6 vddce_6 vpw_7 bl[2]_6 nbl[2]_6 bl[0]_5
+  vddce_5 vddc_5 vnwc_6 vpw_6 nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4
+  vddpe_4 vddce_4 vnwc_5 nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe_3 vpw_4 nbl[0]_2
+  nbl[1]_2 vddpe_2 vddce_2 vnwc_3 vssc vpw_3 vddpe_1 vddce_1 vnwc_2 vpw_2
+  bl[2]_1 bl[3]_1 vddce_0 vddc_0 vnwc_1 vpw_1 bl[3]_0 vnwp_0 vnwp_1 dbl dwl
+  bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vpw_11 nbl[1]_9
+  vddc_9 vpw_10 bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddce_8 vddc_8 vnwc_9 vpw_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddce_7 vddc_7 vnwc_8
+  bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc_6
+  vnwc_7 nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe_5 bl[2]_5 bl[3]_5
+  nbl[1]_4 vddc_4 vpw_5 bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddce_3
+  vddc_3 vnwc_4 bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc_2
+  bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc_1
+  nbl[2]_1 nbl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe_0 bl[2]_0
+  nbl[2]_0 nbl[3]_0 vnwc_0 vpw_0 wl[0] wl[1]
** sram128x46mem_l_test23row: 540 flat devices **
xmem_l_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[1] wl[0]
+  sram128x46cchs4_ull
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[1] wl[0]
+  sram128x46cchs4_ull
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_edger dbl dwl vddc_11 vnwc_12 vnwp_1 vpw_12 vssc wl[0] wl[1]
+  sram128x46cchs4wd_edgbl_dummy_ull
.ends sram128x46mem_l_test23row
****
.subckt sram128x46mem_l_test24row vddc_11 vnwc_12 dbl dwl vddc_10 vnwc_11
+  bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10 bl[0]_9 nbl[0]_9 bl[1]_9 vddpe_9
+  vddce_9 vnwc_10 nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 nbl[0]_7
+  nbl[1]_7 vddpe_7 vpw_8 vddpe_6 vddce_6 vpw_7 bl[2]_6 nbl[2]_6 bl[0]_5
+  vddce_5 vddc_5 vnwc_6 vpw_6 nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4
+  vddpe_4 vddce_4 vnwc_5 nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe_3 vpw_4 nbl[0]_2
+  nbl[1]_2 vddpe_2 vddce_2 vnwc_3 vssc vpw_3 vddpe_1 vddce_1 vnwc_2 vpw_2
+  bl[2]_1 bl[3]_1 vddce_0 vddc_0 vnwc_1 vpw_1 bl[3]_0 vnwp_0 vpw_12 vnwp_1
+  bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vpw_11 nbl[1]_9
+  vddc_9 vpw_10 bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddce_8 vddc_8 vnwc_9 vpw_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddce_7 vddc_7 vnwc_8
+  bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc_6
+  vnwc_7 nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe_5 bl[2]_5 bl[3]_5
+  nbl[1]_4 vddc_4 vpw_5 bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddce_3
+  vddc_3 vnwc_4 bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc_2
+  bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc_1
+  nbl[2]_1 nbl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe_0 bl[2]_0
+  nbl[2]_0 nbl[3]_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_l_test24row: 540 flat devices **
xmem_l_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_edger dbl dwl vddc_11 vnwc_12 vnwp_1 vpw_12 vssc wl[0] wl[1]
+  sram128x46cchs4wd_edgbl_dummy_ull
.ends sram128x46mem_l_test24row
****
.subckt sram128x46mem_l_test25row vddc_11 vpw_12 vnwc_12 vddc_10 vnwc_11
+  bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10 bl[0]_9 nbl[0]_9 bl[1]_9 vddpe_9
+  vddce_9 vnwc_10 nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 nbl[0]_7
+  nbl[1]_7 vddpe_7 vpw_8 vddpe_6 vddce_6 vpw_7 bl[2]_6 nbl[2]_6 bl[0]_5
+  vddce_5 vddc_5 vnwc_6 vpw_6 nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4
+  vddpe_4 vddce_4 vnwc_5 nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe_3 vpw_4 nbl[0]_2
+  nbl[1]_2 vddpe_2 vddce_2 vnwc_3 vssc vpw_3 vddpe_1 vddce_1 vnwc_2 vpw_2
+  bl[2]_1 bl[3]_1 vddce_0 vddc_0 vnwc_1 vpw_1 bl[3]_0 vnwp_0 vnwp_1 dbl dwl
+  bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vpw_11 nbl[1]_9
+  vddc_9 vpw_10 bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddce_8 vddc_8 vnwc_9 vpw_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddce_7 vddc_7 vnwc_8
+  bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc_6
+  vnwc_7 nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe_5 bl[2]_5 bl[3]_5
+  nbl[1]_4 vddc_4 vpw_5 bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddce_3
+  vddc_3 vnwc_4 bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc_2
+  bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc_1
+  nbl[2]_1 nbl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe_0 bl[2]_0
+  nbl[2]_0 nbl[3]_0 vnwc_0 vpw_0 wl[0] wl[1]
** sram128x46mem_l_test25row: 540 flat devices **
xmem_l_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[1] wl[0]
+  sram128x46cchs4_ull
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[1] wl[0]
+  sram128x46cchs4_ull
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_edger dbl dwl vddc_11 vnwc_12 vnwp_1 vpw_12 vssc wl[0] wl[1]
+  sram128x46cchs4wd_edgbl_dummy_ull
.ends sram128x46mem_l_test25row
****
.subckt sram128x46mem_l_test26row vddc_11 vnwc_12 dbl dwl vddc_10 vnwc_11
+  bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10 bl[0]_9 nbl[0]_9 bl[1]_9 vddpe_9
+  vddce_9 vnwc_10 nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 nbl[0]_7
+  nbl[1]_7 vddpe_7 vpw_8 vddpe_6 vddce_6 vpw_7 bl[2]_6 nbl[2]_6 bl[0]_5
+  vddce_5 vddc_5 vnwc_6 vpw_6 nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4
+  vddpe_4 vddce_4 vnwc_5 nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe_3 vpw_4 nbl[0]_2
+  nbl[1]_2 vddpe_2 vddce_2 vnwc_3 vssc vpw_3 vddpe_1 vddce_1 vnwc_2 vpw_2
+  bl[2]_1 bl[3]_1 vddce_0 vddc_0 vnwc_1 vpw_1 bl[3]_0 vnwp_0 vpw_12 vnwp_1
+  bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vpw_11 nbl[1]_9
+  vddc_9 vpw_10 bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddce_8 vddc_8 vnwc_9 vpw_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddce_7 vddc_7 vnwc_8
+  bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc_6
+  vnwc_7 nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe_5 bl[2]_5 bl[3]_5
+  nbl[1]_4 vddc_4 vpw_5 bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddce_3
+  vddc_3 vnwc_4 bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc_2
+  bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc_1
+  nbl[2]_1 nbl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe_0 bl[2]_0
+  nbl[2]_0 nbl[3]_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_l_test26row: 540 flat devices **
xmem_l_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_edger dbl dwl vddc_11 vnwc_12 vnwp_1 vpw_12 vssc wl[0] wl[1]
+  sram128x46cchs4wd_edgbl_dummy_ull
.ends sram128x46mem_l_test26row
****
.subckt sram128x46mem_l_test27row vddc_11 vpw_12 vnwc_12 vddc_10 vnwc_11
+  bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10 bl[0]_9 nbl[0]_9 bl[1]_9 vddpe_9
+  vddce_9 vnwc_10 nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 nbl[0]_7
+  nbl[1]_7 vddpe_7 vpw_8 vddpe_6 vddce_6 vpw_7 bl[2]_6 nbl[2]_6 bl[0]_5
+  vddce_5 vddc_5 vnwc_6 vpw_6 nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4
+  vddpe_4 vddce_4 vnwc_5 nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe_3 vpw_4 nbl[0]_2
+  nbl[1]_2 vddpe_2 vddce_2 vnwc_3 vssc vpw_3 vddpe_1 vddce_1 vnwc_2 vpw_2
+  bl[2]_1 bl[3]_1 vddce_0 vddc_0 vnwc_1 vpw_1 bl[3]_0 vnwp_0 vnwp_1 dbl dwl
+  bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vpw_11 nbl[1]_9
+  vddc_9 vpw_10 bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddce_8 vddc_8 vnwc_9 vpw_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddce_7 vddc_7 vnwc_8
+  bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc_6
+  vnwc_7 nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe_5 bl[2]_5 bl[3]_5
+  nbl[1]_4 vddc_4 vpw_5 bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddce_3
+  vddc_3 vnwc_4 bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc_2
+  bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc_1
+  nbl[2]_1 nbl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe_0 bl[2]_0
+  nbl[2]_0 nbl[3]_0 vnwc_0 vpw_0 wl[0] wl[1]
** sram128x46mem_l_test27row: 540 flat devices **
xmem_l_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[1] wl[0]
+  sram128x46cchs4_ull
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[1] wl[0]
+  sram128x46cchs4_ull
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_edger dbl dwl vddc_11 vnwc_12 vnwp_1 vpw_12 vssc wl[0] wl[1]
+  sram128x46cchs4wd_edgbl_dummy_ull
.ends sram128x46mem_l_test27row
****
.subckt sram128x46mem_l_test28row vddc_11 vnwc_12 dbl dwl vddc_10 vnwc_11
+  bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10 bl[0]_9 nbl[0]_9 bl[1]_9 vddpe_9
+  vddce_9 vnwc_10 nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 nbl[0]_7
+  nbl[1]_7 vddpe_7 vpw_8 vddpe_6 vddce_6 vpw_7 bl[2]_6 nbl[2]_6 bl[0]_5
+  vddce_5 vddc_5 vnwc_6 vpw_6 nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4
+  vddpe_4 vddce_4 vnwc_5 nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe_3 vpw_4 nbl[0]_2
+  nbl[1]_2 vddpe_2 vddce_2 vnwc_3 vssc vpw_3 vddpe_1 vddce_1 vnwc_2 vpw_2
+  bl[2]_1 bl[3]_1 vddce_0 vddc_0 vnwc_1 vpw_1 bl[3]_0 vnwp_0 vpw_12 vnwp_1
+  bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vpw_11 nbl[1]_9
+  vddc_9 vpw_10 bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddce_8 vddc_8 vnwc_9 vpw_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddce_7 vddc_7 vnwc_8
+  bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc_6
+  vnwc_7 nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe_5 bl[2]_5 bl[3]_5
+  nbl[1]_4 vddc_4 vpw_5 bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddce_3
+  vddc_3 vnwc_4 bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc_2
+  bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc_1
+  nbl[2]_1 nbl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe_0 bl[2]_0
+  nbl[2]_0 nbl[3]_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_l_test28row: 540 flat devices **
xmem_l_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_edger dbl dwl vddc_11 vnwc_12 vnwp_1 vpw_12 vssc wl[0] wl[1]
+  sram128x46cchs4wd_edgbl_dummy_ull
.ends sram128x46mem_l_test28row
****
.subckt sram128x46mem_l_test29row vddc_11 vpw_12 vnwc_12 vddc_10 vnwc_11
+  bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10 bl[0]_9 nbl[0]_9 bl[1]_9 vddpe_9
+  vddce_9 vnwc_10 nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 nbl[0]_7
+  nbl[1]_7 vddpe_7 vpw_8 vddpe_6 vddce_6 vpw_7 bl[2]_6 nbl[2]_6 bl[0]_5
+  vddce_5 vddc_5 vnwc_6 vpw_6 nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4
+  vddpe_4 vddce_4 vnwc_5 nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe_3 vpw_4 nbl[0]_2
+  nbl[1]_2 vddpe_2 vddce_2 vnwc_3 vssc vpw_3 vddpe_1 vddce_1 vnwc_2 vpw_2
+  bl[2]_1 bl[3]_1 vddce_0 vddc_0 vnwc_1 vpw_1 bl[3]_0 vnwp_0 vnwp_1 dbl dwl
+  bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vpw_11 nbl[1]_9
+  vddc_9 vpw_10 bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddce_8 vddc_8 vnwc_9 vpw_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddce_7 vddc_7 vnwc_8
+  bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc_6
+  vnwc_7 nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe_5 bl[2]_5 bl[3]_5
+  nbl[1]_4 vddc_4 vpw_5 bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddce_3
+  vddc_3 vnwc_4 bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc_2
+  bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc_1
+  nbl[2]_1 nbl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe_0 bl[2]_0
+  nbl[2]_0 nbl[3]_0 vnwc_0 vpw_0 wl[0] wl[1]
** sram128x46mem_l_test29row: 540 flat devices **
xmem_l_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[1] wl[0]
+  sram128x46cchs4_ull
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[1] wl[0]
+  sram128x46cchs4_ull
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_edger dbl dwl vddc_11 vnwc_12 vnwp_1 vpw_12 vssc wl[0] wl[1]
+  sram128x46cchs4wd_edgbl_dummy_ull
.ends sram128x46mem_l_test29row
****
.subckt sram128x46mem_l_test1row vddc_11 vpw_12 vnwc_12 vddc_10 vnwc_11
+  bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10 bl[0]_9 nbl[0]_9 bl[1]_9 vddpe_9
+  vddce_9 vnwc_10 nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 nbl[0]_7
+  nbl[1]_7 vddpe_7 vpw_8 vddpe_6 vddce_6 vpw_7 bl[2]_6 nbl[2]_6 bl[0]_5
+  vddce_5 vddc_5 vnwc_6 vpw_6 nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4
+  vddpe_4 vddce_4 vnwc_5 nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe_3 vpw_4 nbl[0]_2
+  nbl[1]_2 vddpe_2 vddce_2 vnwc_3 vssc vpw_3 vddpe_1 vddce_1 vnwc_2 vpw_2
+  bl[2]_1 bl[3]_1 vddce_0 vddc_0 vnwc_1 vpw_1 bl[3]_0 vnwp_0 vnwp_1 dbl dwl
+  bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vpw_11 nbl[1]_9
+  vddc_9 vpw_10 bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddce_8 vddc_8 vnwc_9 vpw_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddce_7 vddc_7 vnwc_8
+  bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc_6
+  vnwc_7 nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe_5 bl[2]_5 bl[3]_5
+  nbl[1]_4 vddc_4 vpw_5 bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddce_3
+  vddc_3 vnwc_4 bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc_2
+  bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc_1
+  nbl[2]_1 nbl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe_0 bl[2]_0
+  nbl[2]_0 nbl[3]_0 vnwc_0 vpw_0 wl[0] wl[1]
** sram128x46mem_l_test1row: 540 flat devices **
xmem_l_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[1] wl[0]
+  sram128x46cchs4_ull
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[1] wl[0]
+  sram128x46cchs4_ull
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_288 ncored01_290 ncored10_292
+  ncored11_294 ncored20_296 ncored21_298 ncored30_300 ncored31_302 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[1] wl[0] sram128x46cchs4_ull
xmem_l_col_edger dbl dwl vddc_11 vnwc_12 vnwp_1 vpw_12 vssc wl[0] wl[1]
+  sram128x46cchs4wd_edgbl_dummy_ull
.ends sram128x46mem_l_test1row
****
.subckt sram128x46mem_l_test2row vddc_11 vnwc_12 dbl dwl vddc_10 vnwc_11
+  bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10 bl[0]_9 nbl[0]_9 bl[1]_9 vddpe_9
+  vddce_9 vnwc_10 nbl[3]_9 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 nbl[0]_7
+  nbl[1]_7 vddpe_7 vpw_8 vddpe_6 vddce_6 vpw_7 bl[2]_6 nbl[2]_6 bl[0]_5
+  vddce_5 vddc_5 vnwc_6 vpw_6 nbl[2]_5 nbl[3]_5 bl[0]_4 nbl[0]_4 bl[1]_4
+  vddpe_4 vddce_4 vnwc_5 nbl[2]_4 nbl[3]_4 nbl[0]_3 vddpe_3 vpw_4 nbl[0]_2
+  nbl[1]_2 vddpe_2 vddce_2 vnwc_3 vssc vpw_3 vddpe_1 vddce_1 vnwc_2 vpw_2
+  bl[2]_1 bl[3]_1 vddce_0 vddc_0 vnwc_1 vpw_1 bl[3]_0 vnwp_0 vpw_12 vnwp_1
+  bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vpw_11 nbl[1]_9
+  vddc_9 vpw_10 bl[2]_9 nbl[2]_9 bl[3]_9 bl[0]_8 vddce_8 vddc_8 vnwc_9 vpw_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[0]_7 bl[1]_7 vddce_7 vddc_7 vnwc_8
+  bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddc_6
+  vnwc_7 nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe_5 bl[2]_5 bl[3]_5
+  nbl[1]_4 vddc_4 vpw_5 bl[2]_4 bl[3]_4 bl[0]_3 nbl[1]_3 bl[1]_3 vddce_3
+  vddc_3 vnwc_4 bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3 bl[0]_2 bl[1]_2 vddc_2
+  bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddc_1
+  nbl[2]_1 nbl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe_0 bl[2]_0
+  nbl[2]_0 nbl[3]_0 vnwc_0 vpw_0 wl[1] wl[0]
** sram128x46mem_l_test2row: 540 flat devices **
xmem_l_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_16 cored01_18 cored10_20
+  cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_1 nbl[1]_1
+  nbl[2]_1 nbl[3]_1 ncored00_32 ncored01_34 ncored10_36 ncored11_38
+  ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_1 vddce_1 vddpe_1
+  vnwc_2 vpw_2 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  sram128x46cchs4_ull
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_48 cored01_50 cored10_52
+  cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_2 nbl[1]_2
+  nbl[2]_2 nbl[3]_2 ncored00_64 ncored01_66 ncored10_68 ncored11_70
+  ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_2 vddce_2 vddpe_2
+  vnwc_3 vpw_3 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_80 cored01_82 cored10_84
+  cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_3 nbl[1]_3
+  nbl[2]_3 nbl[3]_3 ncored00_96 ncored01_98 ncored10_100 ncored11_102
+  ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_3 vddce_3 vddpe_3
+  vnwc_4 vpw_4 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_128 ncored01_130 ncored10_132
+  ncored11_134 ncored20_136 ncored21_138 ncored30_140 ncored31_142 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_160 ncored01_162 ncored10_164
+  ncored11_166 ncored20_168 ncored21_170 ncored30_172 ncored31_174 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_192 ncored01_194 ncored10_196
+  ncored11_198 ncored20_200 ncored21_202 ncored30_204 ncored31_206 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_224 ncored01_226 ncored10_228
+  ncored11_230 ncored20_232 ncored21_234 ncored30_236 ncored31_238 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_256 ncored01_258 ncored10_260
+  ncored11_262 ncored20_264 ncored21_266 ncored30_268 ncored31_270 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] sram128x46cchs4_ull
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286

m_wd8.mxp13 wl17_r ra_en1_r wl16_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd8.mxp14 wl17_l ra_en1_l wl16_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd8.mxp15 wl17_l ra_en0_l wl16_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd8._rowdrv_0.mxn0 wl16_r _wd8._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd8._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd8._rowdrv_0.mxn11 wl16_l _wd8._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd8._rowdrv_0.mxn8 _wd8._rowdrv_0.nwl _wd8.rowsel ni0 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd8._rowdrv_0.mxp0 wl16_r _wd8._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd8._rowdrv_0.mxp12 _wd8._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd8._rowdrv_0.mxp13 _wd8._rowdrv_0.nwl _wd8.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd8._rowdrv_0.mxp7 wl16_l _wd8._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd8._rowdrv_1.mxn0 wl17_r _wd8._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd8._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd8._rowdrv_1.mxn11 wl17_l _wd8._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd8._rowdrv_1.mxn8 _wd8._rowdrv_1.nwl _wd8.rowsel ni1 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd8._rowdrv_1.mxp0 wl17_r _wd8._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd8._rowdrv_1.mxp12 _wd8._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd8._rowdrv_1.mxp13 _wd8._rowdrv_1.nwl _wd8.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd8._rowdrv_1.mxp7 wl17_l _wd8._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd9.i69.mxn0 _wd9.rowsel nxp1_1 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd9.i69.mxn15 _wd9.rowsel nxp0_1 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd9.i69.mxp1 _wd9.rowsel nxp0_1 _wd9.i69.p1 vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd9.i69.mxp15 _wd9.i69.p1 nxp1_1 vddp_nor vnwp pch_mac W=1.35U L=0.035U NF=1
m_wd9.i69.mx_npd _wd9.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wd9.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U NF=1
m_wd9.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wd9.mxp12 wl19_r ra_en0_r wl18_r vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd9.mxp13 wl19_r ra_en1_r wl18_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd9.mxp14 wl19_l ra_en1_l wl18_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd9.mxp15 wl19_l ra_en0_l wl18_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd9._rowdrv_0.mxn0 wl18_r _wd9._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd9._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd9._rowdrv_0.mxn11 wl18_l _wd9._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd9._rowdrv_0.mxn8 _wd9._rowdrv_0.nwl _wd9.rowsel ni0 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd9._rowdrv_0.mxp0 wl18_r _wd9._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd9._rowdrv_0.mxp12 _wd9._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd9._rowdrv_0.mxp13 _wd9._rowdrv_0.nwl _wd9.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd9._rowdrv_0.mxp7 wl18_l _wd9._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd9._rowdrv_1.mxn0 wl19_r _wd9._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd9._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd9._rowdrv_1.mxn11 wl19_l _wd9._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd9._rowdrv_1.mxn8 _wd9._rowdrv_1.nwl _wd9.rowsel ni1 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd9._rowdrv_1.mxp0 wl19_r _wd9._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd9._rowdrv_1.mxp12 _wd9._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd9._rowdrv_1.mxp13 _wd9._rowdrv_1.nwl _wd9.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd9._rowdrv_1.mxp7 wl19_l _wd9._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wdxtop.i69.mxn0 _wdxtop.rowsel nxp1_3 vsse vpw nch_mac W=0.515U L=0.035U
+  NF=1
m_wdxtop.i69.mxn15 _wdxtop.rowsel nxp0_7 vsse vpw nch_mac W=0.515U L=0.035U
+  NF=1
m_wdxtop.i69.mxp1 _wdxtop.rowsel nxp0_7 _wdxtop.i69.p1 vnwp pch_mac W=1.35U
+  L=0.035U NF=1
m_wdxtop.i69.mxp15 _wdxtop.i69.p1 nxp1_3 vddp_nor vnwp pch_mac W=1.35U
+  L=0.035U NF=1
m_wdxtop.i69.mx_npd _wdxtop.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wdxtop.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U
+  NF=1
m_wdxtop.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wdxtop.mxp12 wl63_r ra_en0_r wl62_r vnwc pch_mac W=0.15U L=0.035U NF=1
m_wdxtop.mxp13 wl63_r ra_en1_r wl62_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wdxtop.mxp14 wl63_l ra_en1_l wl62_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wdxtop.mxp15 wl63_l ra_en0_l wl62_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wdxtop._rowdrv_0.mxn0 wl62_r _wdxtop._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wdxtop._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wdxtop._rowdrv_0.mxn11 wl62_l _wdxtop._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wdxtop._rowdrv_0.mxn8 _wdxtop._rowdrv_0.nwl _wdxtop.rowsel ni0 vpw nch_mac
+  W=1.2U L=0.035U NF=2
m_wdxtop._rowdrv_0.mxp0 wl62_r _wdxtop._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wdxtop._rowdrv_0.mxp12 _wdxtop._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac
+  W=0.2U L=0.035U NF=1
m_wdxtop._rowdrv_0.mxp13 _wdxtop._rowdrv_0.nwl _wdxtop.rowsel vddce vnwc
+  pch_mac W=0.16U L=0.035U NF=1
m_wdxtop._rowdrv_0.mxp7 wl62_l _wdxtop._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wdxtop._rowdrv_1.mxn0 wl63_r _wdxtop._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wdxtop._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wdxtop._rowdrv_1.mxn11 wl63_l _wdxtop._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wdxtop._rowdrv_1.mxn8 _wdxtop._rowdrv_1.nwl _wdxtop.rowsel ni1 vpw nch_mac
+  W=1.2U L=0.035U NF=2
m_wdxtop._rowdrv_1.mxp0 wl63_r _wdxtop._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wdxtop._rowdrv_1.mxp12 _wdxtop._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac
+  W=0.2U L=0.035U NF=1
m_wdxtop._rowdrv_1.mxp13 _wdxtop._rowdrv_1.nwl _wdxtop.rowsel vddce vnwc
+  pch_mac W=0.16U L=0.035U NF=1
m_wdxtop._rowdrv_1.mxp7 wl63_l _wdxtop._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_xdec0._dec.i1_0.mxna1 _xdec0._dec.ndec[0] nra_p2[0] _xdec0._dec.i1_0.n2 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec0._dec.i1_0.mxna2 _xdec0._dec.i1_0.n2 nra_p2[1] _xdec0._dec.i1_0.n1 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec0._dec.i1_0.mxna3 _xdec0._dec.i1_0.n1 nra_p2[2] vss vpw nch_mac W=0.48U
+  L=0.035U NF=1
m_xdec0._dec.i1_0.mxpa1 _xdec0._dec.ndec[0] nra_p2[0] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i1_0.mxpa2 _xdec0._dec.ndec[0] nra_p2[1] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i1_0.mxpa3 _xdec0._dec.ndec[0] nra_p2[2] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i1_1.mxna1 _xdec0._dec.ndec[1] ra_p2[0] _xdec0._dec.i1_1.n2 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec0._dec.i1_1.mxna2 _xdec0._dec.i1_1.n2 nra_p2[1] _xdec0._dec.i1_1.n1 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec0._dec.i1_1.mxna3 _xdec0._dec.i1_1.n1 nra_p2[2] vss vpw nch_mac W=0.48U
+  L=0.035U NF=1
m_xdec0._dec.i1_1.mxpa1 _xdec0._dec.ndec[1] ra_p2[0] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i1_1.mxpa2 _xdec0._dec.ndec[1] nra_p2[1] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i1_1.mxpa3 _xdec0._dec.ndec[1] nra_p2[2] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i1_2.mxna1 _xdec0._dec.ndec[2] nra_p2[0] _xdec0._dec.i1_2.n2 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec0._dec.i1_2.mxna2 _xdec0._dec.i1_2.n2 ra_p2[1] _xdec0._dec.i1_2.n1 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec0._dec.i1_2.mxna3 _xdec0._dec.i1_2.n1 nra_p2[2] vss vpw nch_mac W=0.48U
+  L=0.035U NF=1
m_xdec0._dec.i1_2.mxpa1 _xdec0._dec.ndec[2] nra_p2[0] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i1_2.mxpa2 _xdec0._dec.ndec[2] ra_p2[1] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i1_2.mxpa3 _xdec0._dec.ndec[2] nra_p2[2] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i1_3.mxna1 _xdec0._dec.ndec[3] ra_p2[0] _xdec0._dec.i1_3.n2 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec0._dec.i1_3.mxna2 _xdec0._dec.i1_3.n2 ra_p2[1] _xdec0._dec.i1_3.n1 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec0._dec.i1_3.mxna3 _xdec0._dec.i1_3.n1 nra_p2[2] vss vpw nch_mac W=0.48U
+  L=0.035U NF=1
m_xdec0._dec.i1_3.mxpa1 _xdec0._dec.ndec[3] ra_p2[0] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i1_3.mxpa2 _xdec0._dec.ndec[3] ra_p2[1] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i1_3.mxpa3 _xdec0._dec.ndec[3] nra_p2[2] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i1_4.mxna1 _xdec0._dec.ndec[4] nra_p2[0] _xdec0._dec.i1_4.n2 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec0._dec.i1_4.mxna2 _xdec0._dec.i1_4.n2 nra_p2[1] _xdec0._dec.i1_4.n1 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec0._dec.i1_4.mxna3 _xdec0._dec.i1_4.n1 ra_p2[2] vss vpw nch_mac W=0.48U
+  L=0.035U NF=1
m_xdec0._dec.i1_4.mxpa1 _xdec0._dec.ndec[4] nra_p2[0] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i1_4.mxpa2 _xdec0._dec.ndec[4] nra_p2[1] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i1_4.mxpa3 _xdec0._dec.ndec[4] ra_p2[2] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i1_5.mxna1 _xdec0._dec.ndec[5] ra_p2[0] _xdec0._dec.i1_5.n2 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec0._dec.i1_5.mxna2 _xdec0._dec.i1_5.n2 nra_p2[1] _xdec0._dec.i1_5.n1 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec0._dec.i1_5.mxna3 _xdec0._dec.i1_5.n1 ra_p2[2] vss vpw nch_mac W=0.48U
+  L=0.035U NF=1
m_xdec0._dec.i1_5.mxpa1 _xdec0._dec.ndec[5] ra_p2[0] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i1_5.mxpa2 _xdec0._dec.ndec[5] nra_p2[1] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i1_5.mxpa3 _xdec0._dec.ndec[5] ra_p2[2] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i1_6.mxna1 _xdec0._dec.ndec[6] nra_p2[0] _xdec0._dec.i1_6.n2 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec0._dec.i1_6.mxna2 _xdec0._dec.i1_6.n2 ra_p2[1] _xdec0._dec.i1_6.n1 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec0._dec.i1_6.mxna3 _xdec0._dec.i1_6.n1 ra_p2[2] vss vpw nch_mac W=0.48U
+  L=0.035U NF=1
m_xdec0._dec.i1_6.mxpa1 _xdec0._dec.ndec[6] nra_p2[0] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i1_6.mxpa2 _xdec0._dec.ndec[6] ra_p2[1] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i1_6.mxpa3 _xdec0._dec.ndec[6] ra_p2[2] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i1_7.mxna1 _xdec0._dec.ndec[7] ra_p2[0] _xdec0._dec.i1_7.n2 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec0._dec.i1_7.mxna2 _xdec0._dec.i1_7.n2 ra_p2[1] _xdec0._dec.i1_7.n1 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec0._dec.i1_7.mxna3 _xdec0._dec.i1_7.n1 ra_p2[2] vss vpw nch_mac W=0.48U
+  L=0.035U NF=1
m_xdec0._dec.i1_7.mxpa1 _xdec0._dec.ndec[7] ra_p2[0] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i1_7.mxpa2 _xdec0._dec.ndec[7] ra_p2[1] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i1_7.mxpa3 _xdec0._dec.ndec[7] ra_p2[2] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i3_0.mxna1 _xdec0.xp[0] _xdec0._dec.ndec[0] vss vpw nch_mac
+  W=0.39U L=0.035U NF=3
m_xdec0._dec.i3_0.mxpa1 _xdec0.xp[0] _xdec0._dec.ndec[0] vddpe vnwp pch_mac
+  W=0.6U L=0.035U NF=2
m_xdec0._dec.i3_1.mxna1 _xdec0.xp[1] _xdec0._dec.ndec[1] vss vpw nch_mac
+  W=0.39U L=0.035U NF=3
m_xdec0._dec.i3_1.mxpa1 _xdec0.xp[1] _xdec0._dec.ndec[1] vddpe vnwp pch_mac
+  W=0.6U L=0.035U NF=2
m_xdec0._dec.i3_2.mxna1 _xdec0.xp[2] _xdec0._dec.ndec[2] vss vpw nch_mac
+  W=0.39U L=0.035U NF=3
m_xdec0._dec.i3_2.mxpa1 _xdec0.xp[2] _xdec0._dec.ndec[2] vddpe vnwp pch_mac
+  W=0.6U L=0.035U NF=2
m_xdec0._dec.i3_3.mxna1 _xdec0.xp[3] _xdec0._dec.ndec[3] vss vpw nch_mac
+  W=0.39U L=0.035U NF=3
m_xdec0._dec.i3_3.mxpa1 _xdec0.xp[3] _xdec0._dec.ndec[3] vddpe vnwp pch_mac
+  W=0.6U L=0.035U NF=2
m_xdec0._dec.i3_4.mxna1 _xdec0.xp[4] _xdec0._dec.ndec[4] vss vpw nch_mac
+  W=0.39U L=0.035U NF=3
m_xdec0._dec.i3_4.mxpa1 _xdec0.xp[4] _xdec0._dec.ndec[4] vddpe vnwp pch_mac
+  W=0.6U L=0.035U NF=2
m_xdec0._dec.i3_5.mxna1 _xdec0.xp[5] _xdec0._dec.ndec[5] vss vpw nch_mac
+  W=0.39U L=0.035U NF=3
m_xdec0._dec.i3_5.mxpa1 _xdec0.xp[5] _xdec0._dec.ndec[5] vddpe vnwp pch_mac
+  W=0.6U L=0.035U NF=2
m_xdec0._dec.i3_6.mxna1 _xdec0.xp[6] _xdec0._dec.ndec[6] vss vpw nch_mac
+  W=0.39U L=0.035U NF=3
m_xdec0._dec.i3_6.mxpa1 _xdec0.xp[6] _xdec0._dec.ndec[6] vddpe vnwp pch_mac
+  W=0.6U L=0.035U NF=2
m_xdec0._dec.i3_7.mxna1 _xdec0.xp[7] _xdec0._dec.ndec[7] vss vpw nch_mac
+  W=0.39U L=0.035U NF=3
m_xdec0._dec.i3_7.mxpa1 _xdec0.xp[7] _xdec0._dec.ndec[7] vddpe vnwp pch_mac
+  W=0.6U L=0.035U NF=2
m_xdec0._iv_nxp_0.mxna1 nxp0_0 _xdec0.xp[0] vss vpw nch_mac W=1.68U L=0.035U
+  NF=4
m_xdec0._iv_nxp_0.mxpa1 nxp0_0 _xdec0.xp[0] vddpe vnwp pch_mac W=2.24U
+  L=0.035U NF=4
m_xdec0._iv_nxp_1.mxna1 nxp0_1 _xdec0.xp[1] vss vpw nch_mac W=1.68U L=0.035U
+  NF=4
m_xdec0._iv_nxp_1.mxpa1 nxp0_1 _xdec0.xp[1] vddpe vnwp pch_mac W=2.24U
+  L=0.035U NF=4
m_xdec0._iv_nxp_2.mxna1 nxp0_2 _xdec0.xp[2] vss vpw nch_mac W=1.68U L=0.035U
+  NF=4
m_xdec0._iv_nxp_2.mxpa1 nxp0_2 _xdec0.xp[2] vddpe vnwp pch_mac W=2.24U
+  L=0.035U NF=4
m_xdec0._iv_nxp_3.mxna1 nxp0_3 _xdec0.xp[3] vss vpw nch_mac W=1.68U L=0.035U
+  NF=4
m_xdec0._iv_nxp_3.mxpa1 nxp0_3 _xdec0.xp[3] vddpe vnwp pch_mac W=2.24U
+  L=0.035U NF=4
m_xdec0._iv_nxp_4.mxna1 nxp0_4 _xdec0.xp[4] vss vpw nch_mac W=1.68U L=0.035U
+  NF=4
m_xdec0._iv_nxp_4.mxpa1 nxp0_4 _xdec0.xp[4] vddpe vnwp pch_mac W=2.24U
+  L=0.035U NF=4
m_xdec0._iv_nxp_5.mxna1 nxp0_5 _xdec0.xp[5] vss vpw nch_mac W=1.68U L=0.035U
+  NF=4
m_xdec0._iv_nxp_5.mxpa1 nxp0_5 _xdec0.xp[5] vddpe vnwp pch_mac W=2.24U
+  L=0.035U NF=4
m_xdec0._iv_nxp_6.mxna1 nxp0_6 _xdec0.xp[6] vss vpw nch_mac W=1.68U L=0.035U
+  NF=4
m_xdec0._iv_nxp_6.mxpa1 nxp0_6 _xdec0.xp[6] vddpe vnwp pch_mac W=2.24U
+  L=0.035U NF=4
m_xdec0._iv_nxp_7.mxna1 nxp0_7 _xdec0.xp[7] vss vpw nch_mac W=1.68U L=0.035U
+  NF=4
m_xdec0._iv_nxp_7.mxpa1 nxp0_7 _xdec0.xp[7] vddpe vnwp pch_mac W=2.24U
+  L=0.035U NF=4
m_xdec1._dec.i1_0.mxna1 _xdec1._dec.ndec[0] nra_p2[3] _xdec1._dec.i1_0.n2 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec1._dec.i1_0.mxna2 _xdec1._dec.i1_0.n2 nra_p2[4] _xdec1._dec.i1_0.n1 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec1._dec.i1_0.mxna3 _xdec1._dec.i1_0.n1 nra_p2[5] vss vpw nch_mac W=0.48U
+  L=0.035U NF=1
m_xdec1._dec.i1_0.mxpa1 _xdec1._dec.ndec[0] nra_p2[3] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i1_0.mxpa2 _xdec1._dec.ndec[0] nra_p2[4] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i1_0.mxpa3 _xdec1._dec.ndec[0] nra_p2[5] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i1_1.mxna1 _xdec1._dec.ndec[1] ra_p2[3] _xdec1._dec.i1_1.n2 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec1._dec.i1_1.mxna2 _xdec1._dec.i1_1.n2 nra_p2[4] _xdec1._dec.i1_1.n1 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec1._dec.i1_1.mxna3 _xdec1._dec.i1_1.n1 nra_p2[5] vss vpw nch_mac W=0.48U
+  L=0.035U NF=1
m_xdec1._dec.i1_1.mxpa1 _xdec1._dec.ndec[1] ra_p2[3] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i1_1.mxpa2 _xdec1._dec.ndec[1] nra_p2[4] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i1_1.mxpa3 _xdec1._dec.ndec[1] nra_p2[5] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i1_2.mxna1 _xdec1._dec.ndec[2] nra_p2[3] _xdec1._dec.i1_2.n2 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec1._dec.i1_2.mxna2 _xdec1._dec.i1_2.n2 ra_p2[4] _xdec1._dec.i1_2.n1 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec1._dec.i1_2.mxna3 _xdec1._dec.i1_2.n1 nra_p2[5] vss vpw nch_mac W=0.48U
+  L=0.035U NF=1
m_xdec1._dec.i1_2.mxpa1 _xdec1._dec.ndec[2] nra_p2[3] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i1_2.mxpa2 _xdec1._dec.ndec[2] ra_p2[4] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i1_2.mxpa3 _xdec1._dec.ndec[2] nra_p2[5] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i1_3.mxna1 _xdec1._dec.ndec[3] ra_p2[3] _xdec1._dec.i1_3.n2 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec1._dec.i1_3.mxna2 _xdec1._dec.i1_3.n2 ra_p2[4] _xdec1._dec.i1_3.n1 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec1._dec.i1_3.mxna3 _xdec1._dec.i1_3.n1 nra_p2[5] vss vpw nch_mac W=0.48U
+  L=0.035U NF=1
m_xdec1._dec.i1_3.mxpa1 _xdec1._dec.ndec[3] ra_p2[3] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i1_3.mxpa2 _xdec1._dec.ndec[3] ra_p2[4] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i1_3.mxpa3 _xdec1._dec.ndec[3] nra_p2[5] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i1_4.mxna1 _xdec1._dec.ndec[4] nra_p2[3] _xdec1._dec.i1_4.n2 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec1._dec.i1_4.mxna2 _xdec1._dec.i1_4.n2 nra_p2[4] _xdec1._dec.i1_4.n1 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec1._dec.i1_4.mxna3 _xdec1._dec.i1_4.n1 ra_p2[5] vss vpw nch_mac W=0.48U
+  L=0.035U NF=1
m_xdec1._dec.i1_4.mxpa1 _xdec1._dec.ndec[4] nra_p2[3] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i1_4.mxpa2 _xdec1._dec.ndec[4] nra_p2[4] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i1_4.mxpa3 _xdec1._dec.ndec[4] ra_p2[5] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i1_5.mxna1 _xdec1._dec.ndec[5] ra_p2[3] _xdec1._dec.i1_5.n2 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec1._dec.i1_5.mxna2 _xdec1._dec.i1_5.n2 nra_p2[4] _xdec1._dec.i1_5.n1 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec1._dec.i1_5.mxna3 _xdec1._dec.i1_5.n1 ra_p2[5] vss vpw nch_mac W=0.48U
+  L=0.035U NF=1
m_xdec1._dec.i1_5.mxpa1 _xdec1._dec.ndec[5] ra_p2[3] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i1_5.mxpa2 _xdec1._dec.ndec[5] nra_p2[4] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i1_5.mxpa3 _xdec1._dec.ndec[5] ra_p2[5] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i1_6.mxna1 _xdec1._dec.ndec[6] nra_p2[3] _xdec1._dec.i1_6.n2 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec1._dec.i1_6.mxna2 _xdec1._dec.i1_6.n2 ra_p2[4] _xdec1._dec.i1_6.n1 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec1._dec.i1_6.mxna3 _xdec1._dec.i1_6.n1 ra_p2[5] vss vpw nch_mac W=0.48U
+  L=0.035U NF=1
m_xdec1._dec.i1_6.mxpa1 _xdec1._dec.ndec[6] nra_p2[3] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i1_6.mxpa2 _xdec1._dec.ndec[6] ra_p2[4] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i1_6.mxpa3 _xdec1._dec.ndec[6] ra_p2[5] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i1_7.mxna1 _xdec1._dec.ndec[7] ra_p2[3] _xdec1._dec.i1_7.n2 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec1._dec.i1_7.mxna2 _xdec1._dec.i1_7.n2 ra_p2[4] _xdec1._dec.i1_7.n1 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec1._dec.i1_7.mxna3 _xdec1._dec.i1_7.n1 ra_p2[5] vss vpw nch_mac W=0.48U
+  L=0.035U NF=1
m_xdec1._dec.i1_7.mxpa1 _xdec1._dec.ndec[7] ra_p2[3] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i1_7.mxpa2 _xdec1._dec.ndec[7] ra_p2[4] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i1_7.mxpa3 _xdec1._dec.ndec[7] ra_p2[5] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i3_0.mxna1 _xdec1.xp[0] _xdec1._dec.ndec[0] vss vpw nch_mac
+  W=0.39U L=0.035U NF=3
m_xdec1._dec.i3_0.mxpa1 _xdec1.xp[0] _xdec1._dec.ndec[0] vddpe vnwp pch_mac
+  W=0.6U L=0.035U NF=2
m_xdec1._dec.i3_1.mxna1 _xdec1.xp[1] _xdec1._dec.ndec[1] vss vpw nch_mac
+  W=0.39U L=0.035U NF=3
m_xdec1._dec.i3_1.mxpa1 _xdec1.xp[1] _xdec1._dec.ndec[1] vddpe vnwp pch_mac
+  W=0.6U L=0.035U NF=2
m_xdec1._dec.i3_2.mxna1 _xdec1.xp[2] _xdec1._dec.ndec[2] vss vpw nch_mac
+  W=0.39U L=0.035U NF=3
m_xdec1._dec.i3_2.mxpa1 _xdec1.xp[2] _xdec1._dec.ndec[2] vddpe vnwp pch_mac
+  W=0.6U L=0.035U NF=2
m_xdec1._dec.i3_3.mxna1 _xdec1.xp[3] _xdec1._dec.ndec[3] vss vpw nch_mac
+  W=0.39U L=0.035U NF=3
m_xdec1._dec.i3_3.mxpa1 _xdec1.xp[3] _xdec1._dec.ndec[3] vddpe vnwp pch_mac
+  W=0.6U L=0.035U NF=2
m_xdec1._dec.i3_4.mxna1 _xdec1.xp[4] _xdec1._dec.ndec[4] vss vpw nch_mac
+  W=0.39U L=0.035U NF=3
m_xdec1._dec.i3_4.mxpa1 _xdec1.xp[4] _xdec1._dec.ndec[4] vddpe vnwp pch_mac
+  W=0.6U L=0.035U NF=2
m_xdec1._dec.i3_5.mxna1 _xdec1.xp[5] _xdec1._dec.ndec[5] vss vpw nch_mac
+  W=0.39U L=0.035U NF=3
m_xdec1._dec.i3_5.mxpa1 _xdec1.xp[5] _xdec1._dec.ndec[5] vddpe vnwp pch_mac
+  W=0.6U L=0.035U NF=2
m_xdec1._dec.i3_6.mxna1 _xdec1.xp[6] _xdec1._dec.ndec[6] vss vpw nch_mac
+  W=0.39U L=0.035U NF=3
m_xdec1._dec.i3_6.mxpa1 _xdec1.xp[6] _xdec1._dec.ndec[6] vddpe vnwp pch_mac
+  W=0.6U L=0.035U NF=2
m_xdec1._dec.i3_7.mxna1 _xdec1.xp[7] _xdec1._dec.ndec[7] vss vpw nch_mac
+  W=0.39U L=0.035U NF=3
m_xdec1._dec.i3_7.mxpa1 _xdec1.xp[7] _xdec1._dec.ndec[7] vddpe vnwp pch_mac
+  W=0.6U L=0.035U NF=2
m_xdec1._iv_nxp_0.mxna1 nxp1_0 _xdec1.xp[0] vss vpw nch_mac W=1.68U L=0.035U
+  NF=4
m_xdec1._iv_nxp_0.mxpa1 nxp1_0 _xdec1.xp[0] vddpe vnwp pch_mac W=2.24U
+  L=0.035U NF=4
m_xdec1._iv_nxp_1.mxna1 nxp1_1 _xdec1.xp[1] vss vpw nch_mac W=1.68U L=0.035U
+  NF=4
m_xdec1._iv_nxp_1.mxpa1 nxp1_1 _xdec1.xp[1] vddpe vnwp pch_mac W=2.24U
+  L=0.035U NF=4
m_xdec1._iv_nxp_2.mxna1 nxp1_2 _xdec1.xp[2] vss vpw nch_mac W=1.68U L=0.035U
+  NF=4
m_xdec1._iv_nxp_2.mxpa1 nxp1_2 _xdec1.xp[2] vddpe vnwp pch_mac W=2.24U
+  L=0.035U NF=4
m_xdec1._iv_nxp_3.mxna1 nxp1_3 _xdec1.xp[3] vss vpw nch_mac W=1.68U L=0.035U
+  NF=4
m_xdec1._iv_nxp_3.mxpa1 nxp1_3 _xdec1.xp[3] vddpe vnwp pch_mac W=2.24U
+  L=0.035U NF=4
m_xdec1._iv_nxp_4.mxna1 nxp1_4 _xdec1.xp[4] vss vpw nch_mac W=1.68U L=0.035U
+  NF=4
m_xdec1._iv_nxp_4.mxpa1 nxp1_4 _xdec1.xp[4] vddpe vnwp pch_mac W=2.24U
+  L=0.035U NF=4
m_xdec1._iv_nxp_5.mxna1 nxp1_5 _xdec1.xp[5] vss vpw nch_mac W=1.68U L=0.035U
+  NF=4
m_xdec1._iv_nxp_5.mxpa1 nxp1_5 _xdec1.xp[5] vddpe vnwp pch_mac W=2.24U
+  L=0.035U NF=4
m_xdec1._iv_nxp_6.mxna1 nxp1_6 _xdec1.xp[6] vss vpw nch_mac W=1.68U L=0.035U
+  NF=4
m_xdec1._iv_nxp_6.mxpa1 nxp1_6 _xdec1.xp[6] vddpe vnwp pch_mac W=2.24U
+  L=0.035U NF=4
m_xdec1._iv_nxp_7.mxna1 nxp1_7 _xdec1.xp[7] vss vpw nch_mac W=1.68U L=0.035U
+  NF=4
m_xdec1._iv_nxp_7.mxpa1 nxp1_7 _xdec1.xp[7] vddpe vnwp pch_mac W=2.24U
+  L=0.035U NF=4
.ends sram128x46wdx64
****
.subckt sram128x46wddrvcol ret niactc vpw vddc_wl dbl_nbl_wa nact_cc niretnvt
+  actp vddce vddp_nor vddpe log1 log0 log0_sa dbl dwl gtpclk1 gtpclk0
+  nla_p2[1] nla_p2[0] la_p2[1] la_p2[0] nra_p2[5] nra_p2[4] nra_p2[3]
+  nra_p2[2] nra_p2[1] nra_p2[0] ra_p2[5] ra_p2[4] ra_p2[3] ra_p2[2] ra_p2[1]
+  ra_p2[0] rawlm1 rawlm0 rawl cen_p2 nret ret1n ema[0] ema[1] ema[2] vddc_r_1
+  vssc_r_2 wl63_r wl62_r wl61_r wl60_r wl59_r wl58_r wl57_r wl56_r wl55_r
+  wl54_r wl53_r wl52_r wl51_r wl50_r wl49_r wl48_r wl47_r wl46_r wl45_r
+  wl44_r wl43_r wl42_r wl41_r wl40_r wl39_r wl38_r wl37_r wl36_r wl35_r
+  wl34_r wl33_r wl32_r wl31_r wl30_r wl29_r wl28_r wl27_r wl26_r wl25_r
+  wl24_r wl23_r vssc_r_1 wl22_r wl21_r wl20_r wl19_r wl18_r wl17_r wl16_r
+  wl15_r wl14_r wl13_r wl12_r wl11_r wl10_r wl9_r wl8_r wl7_r wl6_r wl5_r
+  wl4_r wl3_r wl2_r wl1_r wl0_r vssc_r_0 vddc_r_0 vddc_l_1 vssc_l_2 wl63_l
+  wl62_l wl61_l wl60_l wl59_l wl58_l wl57_l wl56_l wl55_l wl54_l wl53_l
+  wl52_l wl51_l wl50_l wl49_l wl48_l wl47_l wl46_l wl45_l wl44_l wl43_l
+  wl42_l wl41_l wl40_l wl39_l wl38_l wl37_l wl36_l wl35_l wl34_l wl33_l
+  wl32_l wl31_l wl30_l wl29_l wl28_l wl27_l wl26_l wl25_l wl24_l wl23_l
+  wl22_l wl21_l wl20_l wl19_l wl18_l wl17_l wl16_l wl15_l wl14_l wl13_l
+  wl12_l wl11_l wl10_l wl9_l wl8_l wl7_l wl6_l wl5_l wl4_l wl3_l wl2_l wl1_l
+  vssc_l_1 wl0_l vssc_l_0 vddc_l_0
** sram128x46wddrvcol: 1154 flat devices **
xwd_bot log0_sa nact_cc actp dbl dbl_nbl_wa dbl_nbl_wa dwl ema[2] log0 log1
+  nhdr_wl ni0_term ni1_term niactc niretnvt nxp0_0 nxp0_1 nxp0_2 nxp0_3
+  nxp0_4 nxp0_5 nxp0_6 nxp0_7 nxp1_0 nxp1_1 nxp1_2 nxp1_3 nxp1_4 nxp1_5
+  nxp1_6 nxp1_7 rowclk0 rowclk1 rowclk2_term rowclk3_term vddce vddc_wl
+  vddp_nor vddpe vddce vddpe vpw vpw vssc_l_1 vssc_r_1 vpw wl0_l wl0_r wl1_l
+  wl1_r wl2_l wl2_r wl3_l wl3_r wl4_l wl4_r wl5_l wl5_r wl6_l wl6_r wl7_l
+  wl7_r wl8_l wl8_r wl9_l wl9_r wl10_l wl10_r wl11_l wl11_r wl12_l wl12_r
+  wl13_l wl13_r wl14_l wl14_r wl15_l wl15_r wl16_l wl16_r wl17_l wl17_r
+  wl18_l wl18_r wl19_l wl19_r wl20_l wl20_r wl21_l wl21_r wl22_l wl22_r
+  wl23_l wl23_r wl24_l wl24_r wl25_l wl25_r wl26_l wl26_r wl27_l wl27_r
+  wl28_l wl28_r wl29_l wl29_r wl30_l wl30_r wl31_l wl31_r wl32_l wl32_r
+  wl33_l wl33_r wl34_l wl34_r wl35_l wl35_r wl36_l wl36_r wl37_l wl37_r
+  wl38_l wl38_r wl39_l wl39_r wl40_l wl40_r wl41_l wl41_r wl42_l wl42_r
+  wl43_l wl43_r wl44_l wl44_r wl45_l wl45_r wl46_l wl46_r wl47_l wl47_r
+  wl48_l wl48_r wl49_l wl49_r wl50_l wl50_r wl51_l wl51_r wl52_l wl52_r
+  wl53_l wl53_r wl54_l wl54_r wl55_l wl55_r wl56_l wl56_r wl57_l wl57_r
+  wl58_l wl58_r wl59_l wl59_r wl60_l wl60_r wl61_l wl61_r wl62_l wl62_r
+  wl63_l wl63_r ema[0] ema[1] ema[2] gtpclk0 gtpclk1 la_p2[0] la_p2[1]
+  nla_p2[0] nla_p2[1] nra_p2[0] nra_p2[1] nra_p2[2] nra_p2[3] nra_p2[4]
+  nra_p2[5] ra_en0 ra_en0 ra_en1 ra_en1 ra_p2[0] ra_p2[1] ra_p2[2] ra_p2[3]
+  ra_p2[4] ra_p2[5] ret sram128x46wdx64
xwd_cap actp dbl_nbl_wa log0 nhdr_wl ni1_term ni0_term niactc niretnvt nxp0_0
+  nxp0_1 nxp0_2 nxp0_3 nxp0_4 nxp0_5 nxp0_6 nxp0_7 nxp1_0 nxp1_1 nxp1_2
+  nxp1_3 nxp1_4 nxp1_5 nxp1_6 nxp1_7 ra_en0 ra_en0 ra_en1 ra_en1 ret rowclk1
+  rowclk0 rowclk2_term rowclk3_term vddc_l_1 vddc_r_1 vddc_wl vddce vddp_nor
+  vddpe vddce vddpe vpw vpw vssc_l_2 vssc_r_2 vpw sram128x46wdtop
xwdbot nret ret actp dbl dbl_nbl_wa dbl_nbl_wa dbl dwl ema[0] ema[1] ema[2]
+  gtpclk0 gtpclk1 la_p2[0] la_p2[1] log0 log0_sa log1 nact_cc niactc nhdr_wl
+  ni0_term ni1_term nla_p2[0] nla_p2[1] nra_p2[0] nra_p2[1] nra_p2[2]
+  nra_p2[3] nra_p2[4] nra_p2[5] niretnvt ra_en0 ra_en1 ra_p2[0] ra_p2[1]
+  ra_p2[2] ra_p2[3] ra_p2[4] ra_p2[5] rawl rawlm0 rawlm1 vddc_l_0 vddc_r_0
+  vddce vddc_wl vddp_nor vddpe vddce vddpe vpw vpw vssc_l_0 vssc_r_0 vpw
+  cen_p2 ret1n sram128x46wdbot
.ends sram128x46wddrvcol
****
.subckt sram128x46mem_slice bl[2]_22 nbl[2]_21 bl[2]_21 bl[3]_20 bl[2]_20
+  bl[2]_19 bl[1]_19 nbl[3]_18 bl[2]_18 bl[1]_18 bl[2]_17 bl[1]_17 bl[2]_16
+  bl[1]_16 nbl[1]_16 nbl[3]_15 nbl[2]_15 bl[2]_15 vpw bl[1]_15 nbl[1]_15
+  nbl[3]_14 nbl[2]_14 bl[2]_14 bl[1]_14 nbl[1]_14 bl[0]_14 nbl[3]_13
+  nbl[2]_13 bl[2]_13 bl[1]_13 nbl[1]_13 nbl[0]_13 bl[0]_13 nbl[2]_12 bl[2]_12
+  bl[1]_12 nbl[1]_12 nbl[0]_12 bl[0]_12 nbl[2]_11 bl[2]_11 bl[1]_11 nbl[1]_11
+  nbl[0]_11 bl[0]_11 vnwp_2 ret niretnvt niactc vddc_wl vnwp_1 dwl_0
+  nbl[1]_10 bl[1]_10 bl[2]_10 nbl[2]_10 bl[0]_9 nbl[1]_9 bl[1]_9 nbl[2]_9
+  bl[0]_8 nbl[0]_8 nbl[1]_8 bl[1]_8 nbl[2]_8 bl[0]_7 nbl[0]_7 nbl[1]_7
+  bl[1]_7 bl[2]_7 nbl[2]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 bl[2]_6 nbl[2]_6
+  bl[3]_6 bl[0]_5 nbl[0]_5 nbl[1]_5 bl[1]_5 bl[2]_5 nbl[2]_5 bl[3]_5 bl[0]_4
+  nbl[0]_4 nbl[1]_4 bl[1]_4 vddpe nbl[2]_4 bl[0]_3 nbl[0]_3 nbl[1]_3 bl[1]_3
+  vddc bl[0]_2 nbl[0]_2 nbl[1]_2 bl[1]_2 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1
+  bl[2]_1 nbl[2]_1 bl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 nbl[2]_0 bl[3]_0
+  vnwp_0 vnwp_3 bl[3]_22 nbl[3]_22 nbl[2]_22 bl[1]_22 nbl[1]_22 nbl[0]_22
+  bl[0]_22 bl[3]_21 nbl[3]_21 bl[1]_21 nbl[1]_21 nbl[0]_21 bl[0]_21 nbl[3]_20
+  nbl[2]_20 bl[1]_20 nbl[1]_20 nbl[0]_20 bl[0]_20 bl[3]_19 nbl[3]_19
+  nbl[2]_19 nbl[1]_19 nbl[0]_19 bl[0]_19 bl[3]_18 nbl[2]_18 nbl[1]_18
+  nbl[0]_18 bl[0]_18 bl[3]_17 nbl[3]_17 nbl[2]_17 nbl[1]_17 nbl[0]_17
+  bl[0]_17 bl[3]_16 nbl[3]_16 nbl[2]_16 nbl[0]_16 bl[0]_16 bl[3]_15 nbl[0]_15
+  bl[0]_15 bl[3]_14 nbl[0]_14 bl[3]_13 bl[3]_12 nbl[3]_12 bl[3]_11 nbl[3]_11
+  dbl_nbl_wa nact_cc actp vddp_nor log1 log0 log0_sa dbl_1 dwl_1 gtpclk1
+  gtpclk0 nla_p2[1] nla_p2[0] la_p2[1] la_p2[0] nra_p2[5] nra_p2[4] nra_p2[3]
+  nra_p2[2] nra_p2[1] nra_p2[0] ra_p2[5] ra_p2[4] ra_p2[3] ra_p2[2] ra_p2[1]
+  ra_p2[0] rawlm1 rawlm0 rawl cen_p2 nret ret1n ema[0] ema[1] ema[2] dbl_0
+  bl[0]_10 nbl[0]_10 nbl[3]_10 bl[3]_10 nbl[0]_9 bl[2]_9 nbl[3]_9 bl[3]_9
+  bl[2]_8 nbl[3]_8 bl[3]_8 nbl[3]_7 bl[3]_7 nbl[3]_6 nbl[3]_5 bl[2]_4
+  nbl[3]_4 bl[3]_4 bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3 bl[2]_2 nbl[2]_2
+  nbl[3]_2 bl[3]_2 nbl[3]_1 bl[2]_0 nbl[3]_0
** sram128x46mem_slice: 36866 flat devices **
xmemcore_l vnwp_1 bl[1]_10 nbl[2]_10 bl[3]_10 bl[1]_9 nbl[3]_9 bl[0]_8 bl[2]_8
+  nbl[2]_8 bl[0]_7 bl[1]_7 bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[0]_6 nbl[1]_6
+  bl[1]_6 nbl[2]_6 nbl[3]_6 bl[3]_6 bl[0]_5 bl[1]_5 vddc nbl[2]_5 nbl[3]_5
+  nbl[1]_4 bl[1]_4 bl[2]_4 nbl[3]_4 nbl[0]_3 nbl[1]_3 bl[2]_3 bl[3]_3 bl[2]_2
+  nbl[2]_2 bl[3]_2 bl[0]_1 bl[1]_1 nbl[2]_1 nbl[3]_1 bl[0]_0 nbl[0]_0 bl[1]_0
+  nbl[2]_0 nbl[3]_0 dbl_0 dwl_0 bl[0]_10 nbl[0]_10 nbl[1]_10 vpw bl[2]_10
+  nbl[3]_10 bl[0]_9 nbl[0]_9 nbl[1]_9 vpw bl[2]_9 nbl[2]_9 bl[3]_9 nbl[0]_8
+  nbl[1]_8 bl[1]_8 nbl[3]_8 bl[3]_8 nbl[0]_7 nbl[1]_7 nbl[0]_6 vddc bl[2]_6
+  nbl[0]_5 nbl[1]_5 bl[2]_5 bl[3]_5 bl[0]_4 nbl[0]_4 vddpe nbl[2]_4 bl[3]_4
+  bl[0]_3 bl[1]_3 nbl[2]_3 nbl[3]_3 bl[0]_2 nbl[0]_2 nbl[1]_2 bl[1]_2
+  nbl[3]_2 nbl[0]_1 nbl[1]_1 bl[2]_1 bl[3]_1 nbl[1]_0 bl[2]_0 bl[3]_0 vnwp_0
+  wl[1]_31 wl[0]_31 wl[0]_30 wl[1]_30 wl[0]_29 wl[1]_29 wl[1]_28 wl[0]_28
+  wl[0]_27 wl[1]_27 wl[1]_26 wl[0]_26 wl[0]_25 wl[1]_25 wl[1]_24 wl[0]_24
+  wl[0]_23 wl[1]_23 wl[1]_22 wl[0]_22 wl[0]_21 wl[1]_21 wl[1]_20 wl[0]_20
+  wl[0]_19 wl[1]_19 wl[1]_18 wl[0]_18 wl[0]_17 wl[1]_17 wl[1]_16 wl[0]_16
+  wl[0]_15 wl[1]_15 wl[1]_14 wl[0]_14 wl[0]_13 wl[1]_13 wl[1]_12 wl[0]_12
+  wl[0]_11 wl[1]_11 wl[1]_10 wl[0]_10 wl[0]_9 wl[1]_9 wl[1]_8 wl[0]_8 wl[0]_7
+  wl[1]_7 wl[1]_6 wl[0]_6 wl[0]_5 wl[1]_5 wl[1]_4 wl[0]_4 wl[0]_3 wl[1]_3
+  wl[1]_2 wl[0]_2 wl[0]_1 wl[1]_1 wl[1]_0 wl[0]_0 actp vpw
+  sram128x46memcore_l
xmemcore_r nbl[2]_22 bl[1]_22 nbl[0]_22 bl[0]_22 nbl[3]_21 nbl[1]_21 bl[0]_21
+  nbl[0]_20 bl[0]_20 nbl[2]_19 bl[2]_19 bl[1]_19 nbl[1]_19 bl[0]_19 bl[3]_18
+  nbl[3]_18 nbl[2]_18 bl[1]_18 nbl[1]_18 nbl[0]_18 bl[0]_18 nbl[3]_17
+  nbl[2]_17 vddc nbl[1]_17 nbl[0]_17 nbl[3]_16 nbl[1]_16 nbl[0]_16 bl[2]_15
+  vpw bl[3]_14 bl[2]_14 vpw bl[0]_14 bl[3]_13 nbl[3]_13 nbl[2]_13 bl[1]_13
+  nbl[0]_13 bl[0]_13 nbl[3]_12 nbl[2]_12 nbl[1]_12 nbl[0]_12 nbl[1]_11 vnwp_3
+  bl[3]_22 nbl[3]_22 bl[2]_22 nbl[1]_22 bl[3]_21 nbl[2]_21 bl[2]_21 bl[1]_21
+  nbl[0]_21 bl[3]_20 nbl[3]_20 nbl[2]_20 bl[2]_20 bl[1]_20 nbl[1]_20 bl[3]_19
+  nbl[3]_19 vddc nbl[0]_19 bl[2]_18 bl[3]_17 bl[2]_17 bl[1]_17 bl[0]_17
+  bl[3]_16 nbl[2]_16 bl[2]_16 bl[1]_16 bl[0]_16 bl[3]_15 nbl[3]_15 nbl[2]_15
+  bl[1]_15 nbl[1]_15 nbl[0]_15 bl[0]_15 nbl[3]_14 nbl[2]_14 vddpe bl[1]_14
+  nbl[1]_14 nbl[0]_14 bl[2]_13 nbl[1]_13 bl[3]_12 bl[2]_12 bl[1]_12 bl[0]_12
+  bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 bl[1]_11 nbl[0]_11 bl[0]_11 vnwp_2
+  wl[1]_31_64 wl[0]_31_66 wl[1]_30_68 wl[0]_30_70 wl[1]_29_72 wl[0]_29_74
+  wl[1]_28_76 wl[0]_28_78 wl[1]_27_80 wl[0]_27_82 wl[1]_26_84 wl[0]_26_86
+  wl[1]_25_88 wl[0]_25_90 wl[1]_24_92 wl[0]_24_94 wl[1]_23_96 wl[0]_23_98
+  wl[1]_22_100 wl[0]_22_102 wl[1]_21_104 wl[0]_21_106 wl[1]_20_108
+  wl[0]_20_110 wl[1]_19_112 wl[0]_19_114 wl[1]_18_116 wl[0]_18_118
+  wl[1]_17_120 wl[0]_17_122 wl[1]_16_124 wl[0]_16_126 wl[1]_15_128
+  wl[0]_15_130 wl[1]_14_132 wl[0]_14_134 wl[1]_13_136 wl[0]_13_138
+  wl[1]_12_140 wl[0]_12_142 wl[1]_11_144 wl[0]_11_146 wl[1]_10_148
+  wl[0]_10_150 wl[1]_9_152 wl[0]_9_154 wl[1]_8_156 wl[0]_8_158 wl[1]_7_160
+  wl[0]_7_162 wl[1]_6_164 wl[0]_6_166 wl[1]_5_168 wl[0]_5_170 wl[1]_4_172
+  wl[0]_4_174 wl[1]_3_176 wl[0]_3_178 wl[1]_2_180 wl[0]_2_182 wl[1]_1_184
+  wl[0]_1_186 wl[1]_0_188 wl[0]_0_190 actp vpw sram128x46memcore_r
xwddrvcol ret niactc vpw vddc_wl dbl_nbl_wa nact_cc niretnvt actp vddc
+  vddp_nor vddpe log1 log0 log0_sa dbl_1 dwl_1 gtpclk1 gtpclk0 nla_p2[1]
+  nla_p2[0] la_p2[1] la_p2[0] nra_p2[5] nra_p2[4] nra_p2[3] nra_p2[2]
+  nra_p2[1] nra_p2[0] ra_p2[5] ra_p2[4] ra_p2[3] ra_p2[2] ra_p2[1] ra_p2[0]
+  rawlm1 rawlm0 rawl cen_p2 nret ret1n ema[0] ema[1] ema[2] vddc vpw
+  wl[1]_31_64 wl[0]_31_66 wl[1]_30_68 wl[0]_30_70 wl[1]_29_72 wl[0]_29_74
+  wl[1]_28_76 wl[0]_28_78 wl[1]_27_80 wl[0]_27_82 wl[1]_26_84 wl[0]_26_86
+  wl[1]_25_88 wl[0]_25_90 wl[1]_24_92 wl[0]_24_94 wl[1]_23_96 wl[0]_23_98
+  wl[1]_22_100 wl[0]_22_102 wl[1]_21_104 wl[0]_21_106 wl[1]_20_108
+  wl[0]_20_110 wl[1]_19_112 wl[0]_19_114 wl[1]_18_116 wl[0]_18_118
+  wl[1]_17_120 wl[0]_17_122 wl[1]_16_124 wl[0]_16_126 wl[1]_15_128
+  wl[0]_15_130 wl[1]_14_132 wl[0]_14_134 wl[1]_13_136 wl[0]_13_138
+  wl[1]_12_140 wl[0]_12_142 wl[1]_11_144 vpw wl[0]_11_146 wl[1]_10_148
+  wl[0]_10_150 wl[1]_9_152 wl[0]_9_154 wl[1]_8_156 wl[0]_8_158 wl[1]_7_160
+  wl[0]_7_162 wl[1]_6_164 wl[0]_6_166 wl[1]_5_168 wl[0]_5_170 wl[1]_4_172
+  wl[0]_4_174 wl[1]_3_176 wl[0]_3_178 wl[1]_2_180 wl[0]_2_182 wl[1]_1_184
+  wl[0]_1_186 wl[1]_0_188 wl[0]_0_190 vpw vddc vddc vpw wl[1]_31 wl[0]_31
+  wl[0]_30 wl[1]_30 wl[0]_29 wl[1]_29 wl[1]_28 wl[0]_28 wl[0]_27 wl[1]_27
+  wl[1]_26 wl[0]_26 wl[0]_25 wl[1]_25 wl[1]_24 wl[0]_24 wl[0]_23 wl[1]_23
+  wl[1]_22 wl[0]_22 wl[0]_21 wl[1]_21 wl[1]_20 wl[0]_20 wl[0]_19 wl[1]_19
+  wl[1]_18 wl[0]_18 wl[0]_17 wl[1]_17 wl[1]_16 wl[0]_16 wl[0]_15 wl[1]_15
+  wl[1]_14 wl[0]_14 wl[0]_13 wl[1]_13 wl[1]_12 wl[0]_12 wl[0]_11 wl[1]_11
+  wl[1]_10 wl[0]_10 wl[0]_9 wl[1]_9 wl[1]_8 wl[0]_8 wl[0]_7 wl[1]_7 wl[1]_6
+  wl[0]_6 wl[0]_5 wl[1]_5 wl[1]_4 wl[0]_4 wl[0]_3 wl[1]_3 wl[1]_2 wl[0]_2
+  wl[0]_1 wl[1]_1 wl[1]_0 vpw wl[0]_0 vpw vddc sram128x46wddrvcol
.ends sram128x46mem_slice
****
.subckt sram128x46TILE_TOP q1_22 d1_22 weny1_22 weny0_22 d0_22 q0_22 q1_21
+  vddce d1_21 weny1_21 weny0_21 d0_21 q0_21 q1_20 d1_20 weny1_20 weny0_20
+  d0_20 q0_20 q1_19 d1_19 weny1_19 weny0_19 d0_19 q0_19 q1_18 d1_18 weny1_18
+  weny0_18 d0_18 q0_18 q1_17 d1_17 weny1_17 weny0_17 d0_17 q0_17 q1_16 d1_16
+  weny1_16 weny0_16 d0_16 q0_16 q1_15 vddpe d1_15 weny1_15 weny0_15 d0_15
+  q0_15 q1_14 d1_14 weny1_14 weny0_14 d0_14 q0_14 q1_13 d1_13 weny1_13
+  weny0_13 d0_13 q0_13 q1_12 d1_12 weny1_12 weny0_12 d0_12 q0_12 q1_11 d1_11
+  weny1_11 weny0_11 d0_11 q0_11 penso vpw pso1 pso0 wablm1 wablm0 wabl rawlm1
+  rawlm0 rawl emas ema0 ema1 ema2 emaw0 emaw1 ret1n gwen cen clk a0 a3 a4 a5
+  a6 a7 a8 a1 q0_10 d0_10 weny0_10 weny1_10 d1_10 q1_10 q0_9 d0_9 weny0_9
+  weny1_9 d1_9 q1_9 q0_8 d0_8 weny0_8 weny1_8 d1_8 q1_8 q0_7 d0_7 weny0_7
+  weny1_7 d1_7 q1_7 q0_6 d0_6 weny0_6 weny1_6 d1_6 q1_6 q0_5 d0_5 weny0_5
+  weny1_5 d1_5 q1_5 q0_4 d0_4 weny0_4 weny1_4 d1_4 q1_4 q0_3 d0_3 weny0_3
+  weny1_3 d1_3 q1_3 q0_2 d0_2 weny0_2 weny1_2 d1_2 q1_2 q0_1 d0_1 weny0_1
+  weny1_1 d1_1 q1_1 q0_0 d0_0 weny0_0 weny1_0 d1_0 q1_0
** sram128x46TILE_TOP: 41830 flat devices **
xast_slice vddpe vpw vpw a1 a1 vpw cap_ctrl10_term_22_421
+  cap_ctrl11_term_22_423 cap_ctrl12_term_22_425 q1_21 vddpe d1_21 vpw
+  weny1_21 a1 a1 vss_ast0_21 vpw vpw vddpe vpw vddpe cap_ctrl10_term_21_427
+  cap_ctrl11_term_21_429 cap_ctrl12_term_21_431 d1_20 vpw vpw weny1_20 a1 a1
+  vss_ast0_20 weny0_20 vpw vpw d0_20 vddpe vddce vddpe vddpe
+  cap_ctrl10_term_20_433 cap_ctrl11_term_20_435 cap_ctrl12_term_20_437 q1_19
+  d1_19 vpw vpw weny1_19 a1 a1 weny0_19 vpw vpw d0_19 vddpe vddce vddpe
+  cap_ctrl10_term_19_439 cap_ctrl11_term_19_441 cap_ctrl12_term_19_443 q1_18
+  d1_18 vpw weny1_18 a1 a1 vss_ast0_18 weny0_18 vpw vpw vpw d0_18 vddpe vddpe
+  vddpe q0_18 cap_ctrl10_term_18_445 cap_ctrl11_term_18_447
+  cap_ctrl12_term_18_449 d1_17 vpw weny1_17 a1 a1 weny0_17 vpw vpw vpw d0_17
+  vddpe vddce vddpe vpw vddpe q0_17 cap_ctrl10_term_17_451
+  cap_ctrl11_term_17_453 cap_ctrl12_term_17_455 d1_16 vpw weny1_16 a1 a1
+  weny0_16 vpw d0_16 vddpe vddce vddpe cap_ctrl10_term_16_457
+  cap_ctrl11_term_16_459 cap_ctrl12_term_16_461 vpw d1_15 vpw weny1_15 a1 a1
+  weny0_15 vpw vpw vpw d0_15 vddpe vddce vddpe vddpe q0_15
+  cap_ctrl10_term_15_463 cap_ctrl11_term_15_465 cap_ctrl12_term_15_467 vpw
+  d1_14 vpw weny1_14 a1 a1 weny0_14 vpw d0_14 vddpe vddce vpw vddpe
+  cap_ctrl10_term_14_469 cap_ctrl11_term_14_471 cap_ctrl12_term_14_473 vpw
+  vpw vpw vpw a1 a1 weny0_13 vpw d0_13 vddpe vddce vddpe q0_13
+  cap_ctrl10_term_13_475 cap_ctrl11_term_13_477 cap_ctrl12_term_13_479 d1_12
+  vpw weny1_12 a1 a1 weny0_12 vpw d0_12 vddpe vddce vpw vddpe q0_12
+  cap_ctrl10_term_12_481 cap_ctrl11_term_12_483 cap_ctrl12_term_12_485 vpw a1
+  a1 weny0_11 vpw d0_11 vddpe vddce vpw vpw vddpe cap_ctrl10_term_11_487
+  cap_ctrl11_term_11_489 cap_ctrl12_term_11_491 vpw a1 a1 a1 vpw vpw vpw vpw
+  vpw vpw vpw vpw vddce vddpe dft_p2 gwen_p2 gtp dbl_nbl_wa_turn_496
+  dbl_nbl_wa_turn_496 vpw a1 emas ema0 ema1 ema2 emaw0 emaw1 vpw
+  cap_ctrl12_term_10_498 cap_ctrl11_term_10_500 cap_ctrl10_term_10_502 vpw
+  vddce vddpe d0_10 vpw weny0_10 a1 a1 vpw d1_10 vpw vpw vddpe
+  cap_ctrl12_term_9_504 cap_ctrl11_term_9_506 cap_ctrl10_term_9_508 vddpe vpw
+  vddpe d0_9 vpw weny0_9 a1 a1 vpw vpw vpw vpw cap_ctrl12_term_8_510
+  cap_ctrl11_term_8_512 cap_ctrl10_term_8_514 vpw d0_8 vpw weny0_8 a1
+  vss_ast1_8 a1 vpw vpw cap_ctrl12_term_7_516 cap_ctrl11_term_7_518
+  cap_ctrl10_term_7_520 vpw a1 a1 vpw vddpe vpw vpw vpw vddpe vddce
+  cap_ctrl12_term_6_522 cap_ctrl11_term_6_524 cap_ctrl10_term_6_526 vddpe vpw
+  d0_6 vpw weny0_6 a1 vss_ast1_6 a1 vpw vpw vpw cap_ctrl12_term_5_528
+  cap_ctrl11_term_5_530 cap_ctrl10_term_5_532 vpw vpw a1 vss_ast1_5 a1 vpw
+  cap_ctrl12_term_4_534 cap_ctrl11_term_4_536 cap_ctrl10_term_4_538 vddpe vpw
+  vpw weny0_4 vss_ast0_4 a1 a1 vpw vpw vpw vpw vddpe q1_4
+  cap_ctrl12_term_3_540 cap_ctrl11_term_3_542 cap_ctrl10_term_3_544 vpw d0_3
+  vpw weny0_3 a1 vss_ast1_3 a1 vpw vpw q1_3 cap_ctrl12_term_2_546
+  cap_ctrl11_term_2_548 cap_ctrl10_term_2_550 vpw vpw vpw vss_ast0_2 a1
+  vss_ast1_2 a1 vpw q1_2 cap_ctrl12_term_1_552 cap_ctrl11_term_1_554
+  cap_ctrl10_term_1_556 vddpe d0_1 vpw weny0_1 vss_ast0_1 a1 vss_ast1_1 a1
+  vpw vpw vpw q1_1 cap_ctrl12_term_0_558 cap_ctrl11_term_0_560
+  cap_ctrl10_term_0_562 vpw vpw a1 vss_ast1_0 a1 vpw q1_0 vpw vpw vpw vddce
+  vpw q1_22 cap_ctrl00_22 cap_ctrl01_22 cap_ctrl02_22 d1_22 vpw vpw vpw
+  weny1_22 wen_lat1_term_22 vss_ast1_22 wen_lat0_term_22 vss_ast0_22 weny0_22
+  vpw vpw vpw d0_22 vddpe vddce vddpe vpw vpw vddpe q0_22 cap_ctrl10_22
+  cap_ctrl11_22 cap_ctrl12_22 vddce vpw cap_ctrl00_21 cap_ctrl01_21
+  cap_ctrl02_21 vpw vpw wen_lat1_term_21 vss_ast1_21 wen_lat0_term_21
+  weny0_21 vpw d0_21 vpw q0_21 cap_ctrl10_21 cap_ctrl11_21 cap_ctrl12_21
+  q1_20 vpw cap_ctrl00_20 cap_ctrl01_20 cap_ctrl02_20 vpw wen_lat1_term_20
+  vss_ast1_20 wen_lat0_term_20 vpw vpw vpw q0_20 cap_ctrl10_20 cap_ctrl11_20
+  cap_ctrl12_20 cap_ctrl00_19 cap_ctrl01_19 cap_ctrl02_19 vpw
+  wen_lat1_term_19 vss_ast1_19 wen_lat0_term_19 vss_ast0_19 vpw vddpe vpw vpw
+  vpw q0_19 cap_ctrl10_19 cap_ctrl11_19 cap_ctrl12_19 vddce vpw vpw
+  cap_ctrl00_18 cap_ctrl01_18 cap_ctrl02_18 vpw vpw wen_lat1_term_18
+  vss_ast1_18 wen_lat0_term_18 vpw cap_ctrl10_18 cap_ctrl11_18 cap_ctrl12_18
+  q1_17 cap_ctrl00_17 cap_ctrl01_17 cap_ctrl02_17 vpw vpw wen_lat1_term_17
+  vss_ast1_17 wen_lat0_term_17 vss_ast0_17 vpw vpw cap_ctrl10_17
+  cap_ctrl11_17 cap_ctrl12_17 q1_16 cap_ctrl00_16 cap_ctrl01_16 cap_ctrl02_16
+  vpw vpw wen_lat1_term_16 vss_ast1_16 wen_lat0_term_16 vss_ast0_16 vpw vpw
+  vddpe vpw vpw vpw q0_16 cap_ctrl10_16 cap_ctrl11_16 cap_ctrl12_16 q1_15
+  cap_ctrl00_15 cap_ctrl01_15 cap_ctrl02_15 vpw vpw wen_lat1_term_15
+  vss_ast1_15 wen_lat0_term_15 vss_ast0_15 vpw vpw cap_ctrl10_15
+  cap_ctrl11_15 cap_ctrl12_15 q1_14 cap_ctrl00_14 cap_ctrl01_14 cap_ctrl02_14
+  vpw vpw wen_lat1_term_14 vss_ast1_14 wen_lat0_term_14 vss_ast0_14 vpw vpw
+  vddpe vpw q0_14 cap_ctrl10_14 cap_ctrl11_14 cap_ctrl12_14 q1_13
+  cap_ctrl00_13 cap_ctrl01_13 cap_ctrl02_13 d1_13 vpw vpw weny1_13
+  wen_lat1_term_13 vss_ast1_13 wen_lat0_term_13 vss_ast0_13 vpw vpw vddpe
+  cap_ctrl10_13 cap_ctrl11_13 cap_ctrl12_13 q1_12 cap_ctrl00_12 cap_ctrl01_12
+  cap_ctrl02_12 vpw vpw wen_lat1_term_12 vss_ast1_12 wen_lat0_term_12
+  vss_ast0_12 vpw vpw vddpe vpw vpw cap_ctrl10_12 cap_ctrl11_12 cap_ctrl12_12
+  q1_11 cap_ctrl00_11 cap_ctrl01_11 cap_ctrl02_11 d1_11 vpw vpw weny1_11
+  wen_lat1_term_11 vss_ast1_11 wen_lat0_term_11 vss_ast0_11 vpw vpw vddpe vpw
+  q0_11 cap_ctrl10_11 cap_ctrl11_11 cap_ctrl12_11 vpw vpw vpw vpw vpw vpw vpw
+  vpw vpw vddpe vddce vpw dft_p2_term gwen_p2_term gtp_term dbl_nbl_wa_turn
+  dbl_nbl_wa_term penso vpw vpw vpw pso1 pso0 vpw vpw vpw log1 a1 wablm1
+  wablm0 wabl rawlm1 rawlm0 rawl ret1n vpw a1 gwen cen clk a0 a1 a1 a3 a4 a5
+  a6 a7 a8 a1 a1 vpw vpw vpw vpw vpw vpw vpw vpw vpw vpw vpw vpw vpw vpw vpw
+  vpw vpw vpw vpw vpw vpw vpw vpw vpw vpw vpw cap_ctrl12_10 cap_ctrl11_10
+  cap_ctrl10_10 q0_10 vddpe vpw vpw vss_ast0_10 wen_lat0_term_10 vss_ast1_10
+  wen_lat1_term_10 weny1_10 vpw vpw cap_ctrl02_10 cap_ctrl01_10 cap_ctrl00_10
+  q1_10 cap_ctrl12_9 cap_ctrl11_9 cap_ctrl10_9 q0_9 vddpe vpw vpw vss_ast0_9
+  wen_lat0_term_9 vss_ast1_9 wen_lat1_term_9 weny1_9 vpw d1_9 cap_ctrl02_9
+  cap_ctrl01_9 cap_ctrl00_9 vddce q1_9 cap_ctrl12_8 cap_ctrl11_8 cap_ctrl10_8
+  q0_8 vddpe vpw vpw vss_ast0_8 wen_lat0_term_8 wen_lat1_term_8 weny1_8 vpw
+  d1_8 vddpe cap_ctrl02_8 cap_ctrl01_8 cap_ctrl00_8 vpw vpw vddpe vddce q1_8
+  cap_ctrl12_7 cap_ctrl11_7 cap_ctrl10_7 q0_7 vddpe d0_7 vpw vpw weny0_7
+  vss_ast0_7 wen_lat0_term_7 vss_ast1_7 wen_lat1_term_7 weny1_7 vpw vpw d1_7
+  cap_ctrl02_7 cap_ctrl01_7 cap_ctrl00_7 q1_7 cap_ctrl12_6 cap_ctrl11_6
+  cap_ctrl10_6 q0_6 vddpe vpw vpw vss_ast0_6 wen_lat0_term_6 wen_lat1_term_6
+  weny1_6 vpw d1_6 vddpe cap_ctrl02_6 cap_ctrl01_6 cap_ctrl00_6 vpw vddce
+  q1_6 cap_ctrl12_5 cap_ctrl11_5 cap_ctrl10_5 q0_5 vddpe d0_5 vpw vpw weny0_5
+  vss_ast0_5 wen_lat0_term_5 wen_lat1_term_5 weny1_5 vpw vpw d1_5 vddpe
+  cap_ctrl02_5 cap_ctrl01_5 cap_ctrl00_5 vpw vpw vddpe vddce q1_5
+  cap_ctrl12_4 cap_ctrl11_4 cap_ctrl10_4 q0_4 vpw vddpe d0_4 vpw
+  wen_lat0_term_4 vss_ast1_4 wen_lat1_term_4 weny1_4 vpw d1_4 cap_ctrl02_4
+  cap_ctrl01_4 cap_ctrl00_4 vddce cap_ctrl12_3 cap_ctrl11_3 cap_ctrl10_3 q0_3
+  vddpe vpw vpw vss_ast0_3 wen_lat0_term_3 wen_lat1_term_3 weny1_3 vpw d1_3
+  vddpe cap_ctrl02_3 cap_ctrl01_3 cap_ctrl00_3 vpw vpw vddpe vddce
+  cap_ctrl12_2 cap_ctrl11_2 cap_ctrl10_2 q0_2 vddpe d0_2 vpw weny0_2
+  wen_lat0_term_2 wen_lat1_term_2 weny1_2 vpw vpw d1_2 vddpe cap_ctrl02_2
+  cap_ctrl01_2 cap_ctrl00_2 vpw vpw vddpe vddce cap_ctrl12_1 cap_ctrl11_1
+  cap_ctrl10_1 q0_1 vpw vpw wen_lat0_term_1 wen_lat1_term_1 weny1_1 vpw d1_1
+  vddpe cap_ctrl02_1 cap_ctrl01_1 cap_ctrl00_1 vpw vpw vddpe vddce
+  cap_ctrl12_0 cap_ctrl11_0 cap_ctrl10_0 q0_0 vddpe d0_0 vpw vpw weny0_0
+  vss_ast0_0 wen_lat0_term_0 wen_lat1_term_0 weny1_0 vpw vpw d1_0 vddpe
+  cap_ctrl02_0 cap_ctrl01_0 cap_ctrl00_0 vpw vpw vddpe vddce vpw vpw vddce
+  vddpe sram128x46ast_slice
xbotcap vpw vpw vpw q1_22 cap_ctrl00_term_22 cap_ctrl01_term_22
+  cap_ctrl02_term_22 vddpe weny1_22 wen_lat1_term_22 vss_ast1_term_22
+  wen_lat0_term_22 vss_ast0_term_22 cap_ctrl10_term_22 cap_ctrl11_term_22
+  cap_ctrl12_term_22 q1_21 cap_ctrl00_term_21 cap_ctrl01_term_21
+  cap_ctrl02_term_21 d1_21 vpw weny1_21 wen_lat1_term_21 vss_ast1_term_21
+  wen_lat0_term_21 vss_ast0_term_21 vpw vpw vddce vddpe cap_ctrl10_term_21
+  cap_ctrl11_term_21 cap_ctrl12_term_21 q1_20 cap_ctrl00_term_20
+  cap_ctrl01_term_20 cap_ctrl02_term_20 d1_20 vpw vpw weny1_20
+  wen_lat1_term_20 vss_ast1_term_20 wen_lat0_term_20 vss_ast0_term_20
+  weny0_20 vpw d0_20 vddpe cap_ctrl10_term_20 cap_ctrl11_term_20
+  cap_ctrl12_term_20 cap_ctrl00_term_19 cap_ctrl01_term_19 cap_ctrl02_term_19
+  d1_19 vpw vpw weny1_19 wen_lat1_term_19 vss_ast1_term_19 wen_lat0_term_19
+  vss_ast0_term_19 weny0_19 vpw vpw d0_19 vddpe cap_ctrl10_term_19
+  cap_ctrl11_term_19 cap_ctrl12_term_19 q1_18 cap_ctrl00_term_18
+  cap_ctrl01_term_18 cap_ctrl02_term_18 d1_18 vpw weny1_18 wen_lat1_term_18
+  vss_ast1_term_18 wen_lat0_term_18 vss_ast0_term_18 weny0_18 vpw vpw d0_18
+  vddpe vddce q0_18 cap_ctrl10_term_18 cap_ctrl11_term_18 cap_ctrl12_term_18
+  q1_17 cap_ctrl00_term_17 cap_ctrl01_term_17 cap_ctrl02_term_17 vddpe d1_17
+  weny1_17 wen_lat1_term_17 vss_ast1_term_17 wen_lat0_term_17
+  vss_ast0_term_17 weny0_17 vpw vpw vpw d0_17 vddce vddpe cap_ctrl10_term_17
+  cap_ctrl11_term_17 cap_ctrl12_term_17 cap_ctrl00_term_16 cap_ctrl01_term_16
+  cap_ctrl02_term_16 d1_16 vpw wen_lat1_term_16 vss_ast1_term_16
+  wen_lat0_term_16 vss_ast0_term_16 weny0_16 vpw vpw vpw d0_16 vddce q0_16
+  cap_ctrl10_term_16 cap_ctrl11_term_16 cap_ctrl12_term_16 q1_15
+  cap_ctrl00_term_15 cap_ctrl01_term_15 cap_ctrl02_term_15 vddpe d1_15 vpw
+  wen_lat1_term_15 vss_ast1_term_15 wen_lat0_term_15 vss_ast0_term_15
+  weny0_15 vpw d0_15 vddce q0_15 cap_ctrl10_term_15 cap_ctrl11_term_15
+  cap_ctrl12_term_15 q1_14 cap_ctrl00_term_14 cap_ctrl01_term_14
+  cap_ctrl02_term_14 vddpe d1_14 vpw vpw wen_lat1_term_14 vss_ast1_term_14
+  wen_lat0_term_14 vss_ast0_term_14 weny0_14 vpw d0_14 vddce
+  cap_ctrl10_term_14 cap_ctrl11_term_14 cap_ctrl12_term_14 q1_13
+  cap_ctrl00_term_13 cap_ctrl01_term_13 cap_ctrl02_term_13 vpw
+  wen_lat1_term_13 vss_ast1_term_13 wen_lat0_term_13 vss_ast0_term_13
+  weny0_13 vpw d0_13 vddpe vddce q0_13 cap_ctrl10_term_13 cap_ctrl11_term_13
+  cap_ctrl12_term_13 q1_12 cap_ctrl00_term_12 cap_ctrl01_term_12
+  cap_ctrl02_term_12 vddpe d1_12 weny1_12 wen_lat1_term_12 vss_ast1_term_12
+  wen_lat0_term_12 vss_ast0_term_12 weny0_12 vpw vpw d0_12 q0_12
+  cap_ctrl10_term_12 cap_ctrl11_term_12 cap_ctrl12_term_12 cap_ctrl00_term_11
+  cap_ctrl01_term_11 cap_ctrl02_term_11 d1_11 vpw wen_lat1_term_11
+  vss_ast1_term_11 wen_lat0_term_11 vss_ast0_term_11 weny0_11 vpw vpw vpw
+  d0_11 vddce q0_11 cap_ctrl10_term_11 cap_ctrl11_term_11 cap_ctrl12_term_11
+  vpw vpw vpw vpw vpw vpw vpw vpw vpw vddce vddpe dft_p2_term gwen_p2_term
+  gtp_term dbl_nbl_wa_turn_term dbl_nbl_wa_term vpw pso1 pso0 vpw vpw log1 a1
+  ret1n gwen clk a6 a7 a8 vpw vpw vpw vpw vpw vpw vpw vpw vpw vpw vpw vpw vpw
+  vpw vpw vpw cap_ctrl12_term_10 cap_ctrl11_term_10 cap_ctrl10_term_10 q0_10
+  vddce d0_10 vpw weny0_10 vss_ast0_term_10 wen_lat0_term_10 vss_ast1_term_10
+  wen_lat1_term_10 vpw vpw d1_10 cap_ctrl02_term_10 cap_ctrl01_term_10
+  cap_ctrl00_term_10 q1_10 cap_ctrl12_term_9 cap_ctrl11_term_9
+  cap_ctrl10_term_9 d0_9 weny0_9 vss_ast0_term_9 wen_lat0_term_9
+  vss_ast1_term_9 wen_lat1_term_9 vpw vpw cap_ctrl02_term_9 cap_ctrl01_term_9
+  cap_ctrl00_term_9 q1_9 cap_ctrl12_term_8 cap_ctrl11_term_8
+  cap_ctrl10_term_8 vddce d0_8 vpw weny0_8 vss_ast0_term_8 wen_lat0_term_8
+  vss_ast1_term_8 wen_lat1_term_8 vpw vddpe cap_ctrl02_term_8
+  cap_ctrl01_term_8 cap_ctrl00_term_8 q1_8 cap_ctrl12_term_7
+  cap_ctrl11_term_7 cap_ctrl10_term_7 d0_7 vpw weny0_7 vss_ast0_term_7
+  wen_lat0_term_7 vss_ast1_term_7 wen_lat1_term_7 vpw vpw vddpe
+  cap_ctrl02_term_7 cap_ctrl01_term_7 cap_ctrl00_term_7 cap_ctrl12_term_6
+  cap_ctrl11_term_6 cap_ctrl10_term_6 q0_6 vpw d0_6 vpw weny0_6
+  vss_ast0_term_6 wen_lat0_term_6 vss_ast1_term_6 wen_lat1_term_6 vpw d1_6
+  cap_ctrl02_term_6 cap_ctrl01_term_6 cap_ctrl00_term_6 q1_6
+  cap_ctrl12_term_5 cap_ctrl11_term_5 cap_ctrl10_term_5 vddce d0_5 vpw
+  weny0_5 vss_ast0_term_5 wen_lat0_term_5 vss_ast1_term_5 wen_lat1_term_5 vpw
+  vpw cap_ctrl02_term_5 cap_ctrl01_term_5 cap_ctrl00_term_5 q1_5
+  cap_ctrl12_term_4 cap_ctrl11_term_4 cap_ctrl10_term_4 d0_4 weny0_4
+  vss_ast0_term_4 wen_lat0_term_4 vss_ast1_term_4 wen_lat1_term_4 vpw
+  cap_ctrl02_term_4 cap_ctrl01_term_4 cap_ctrl00_term_4 vddce q1_4
+  cap_ctrl12_term_3 cap_ctrl11_term_3 cap_ctrl10_term_3 d0_3 vpw weny0_3
+  vss_ast0_term_3 wen_lat0_term_3 vss_ast1_term_3 wen_lat1_term_3 vpw
+  cap_ctrl02_term_3 cap_ctrl01_term_3 cap_ctrl00_term_3 q1_3
+  cap_ctrl12_term_2 cap_ctrl11_term_2 cap_ctrl10_term_2 d0_2 vpw weny0_2
+  vss_ast0_term_2 wen_lat0_term_2 vss_ast1_term_2 wen_lat1_term_2 vpw vpw
+  cap_ctrl02_term_2 cap_ctrl01_term_2 cap_ctrl00_term_2 q1_2
+  cap_ctrl12_term_1 cap_ctrl11_term_1 cap_ctrl10_term_1 d0_1 vpw vpw weny0_1
+  vss_ast0_term_1 wen_lat0_term_1 vss_ast1_term_1 wen_lat1_term_1 vpw d1_1
+  cap_ctrl02_term_1 cap_ctrl01_term_1 cap_ctrl00_term_1 vddce
+  cap_ctrl12_term_0 cap_ctrl11_term_0 cap_ctrl10_term_0 d0_0 weny0_0
+  vss_ast0_term_0 wen_lat0_term_0 vss_ast1_term_0 wen_lat1_term_0 vpw vpw
+  cap_ctrl02_term_0 cap_ctrl01_term_0 cap_ctrl00_term_0 q1_0 vpw vddce vpw
+  vddce vddce d1_22 vpw vpw vpw weny0_22 vpw vpw vpw d0_22 q0_22 vpw vpw
+  weny0_21 vpw d0_21 q0_21 vpw vpw vpw vddce q0_20 q1_19 vpw vpw vddce q0_19
+  vpw vpw vpw vpw vpw vpw q0_17 q1_16 vpw vpw weny1_16 vddpe vpw vpw weny1_15
+  vpw vpw vpw weny1_14 vpw vpw q0_14 d1_13 vpw vpw weny1_13 vpw vpw vddce vpw
+  vpw vpw vpw q1_11 vpw vpw weny1_11 vddpe vpw vpw vpw vpw vpw vpw vpw vpw
+  vpw vddce penso vpw vpw vpw wablm1 wablm0 wabl rawlm1 rawlm0 rawl vpw emas
+  ema0 ema1 ema2 emaw0 emaw1 vpw vpw cen a0 a3 a4 a5 a1 vpw vpw vpw vpw vpw
+  vpw vpw vpw vpw vpw vddpe vpw vpw weny1_10 vpw q0_9 vddpe vpw vpw vpw
+  weny1_9 vpw d1_9 vddce q0_8 vpw vpw weny1_8 vpw vpw d1_8 q0_7 vddce vpw vpw
+  weny1_7 vpw d1_7 q1_7 vddpe vpw vpw weny1_6 vpw vpw vddce q0_5 vddpe vpw
+  vpw weny1_5 vpw d1_5 q0_4 vddpe vpw vpw vpw weny1_4 vpw vpw d1_4 q0_3 vddpe
+  vpw vpw weny1_3 vpw vpw d1_3 vddce q0_2 vddce vpw vpw weny1_2 vpw d1_2
+  vddpe q0_1 vddpe vpw weny1_1 vpw vpw q1_1 q0_0 vddpe vpw vpw vpw weny1_0
+  vpw d1_0 vddce vpw vpw sram128x46botcaprow
xcap_slice vddpe vpw vpw q1_22 vpw cap_ctrl00_22 cap_ctrl01_22 cap_ctrl02_22
+  vddpe vss_ast1_22 vss_ast0_22 vpw vpw vpw vddpe vpw q0_22 cap_ctrl10_22
+  cap_ctrl11_22 cap_ctrl12_22 q1_21 vddce vpw cap_ctrl00_21 cap_ctrl01_21
+  cap_ctrl02_21 d1_21 vpw weny1_21 wen_lat1_term_21 vss_ast1_21 vss_ast0_21
+  vpw vpw vddpe vddpe vpw vpw q0_21 cap_ctrl10_21 cap_ctrl11_21 cap_ctrl12_21
+  q1_20 cap_ctrl00_20 cap_ctrl01_20 cap_ctrl02_20 d1_20 weny1_20
+  wen_lat1_term_20 vss_ast1_20 wen_lat0_term_20 vss_ast0_20 weny0_20 vpw
+  d0_20 vddce vddpe vpw q0_20 cap_ctrl10_20 cap_ctrl11_20 cap_ctrl12_20 vddce
+  cap_ctrl00_19 cap_ctrl01_19 cap_ctrl02_19 vddpe d1_19 vpw weny1_19
+  wen_lat1_term_19 vss_ast1_19 wen_lat0_term_19 vss_ast0_19 weny0_19 vpw vpw
+  d0_19 vpw cap_ctrl10_19 cap_ctrl11_19 cap_ctrl12_19 q1_18 vddce vpw
+  cap_ctrl00_18 cap_ctrl01_18 cap_ctrl02_18 vddpe d1_18 vpw weny1_18
+  vss_ast1_18 wen_lat0_term_18 vss_ast0_18 weny0_18 vpw vpw d0_18
+  cap_ctrl10_18 cap_ctrl11_18 cap_ctrl12_18 q1_17 vpw vpw cap_ctrl00_17
+  cap_ctrl01_17 cap_ctrl02_17 d1_17 vpw weny1_17 wen_lat1_term_17 vss_ast1_17
+  wen_lat0_term_17 vss_ast0_17 weny0_17 vpw vpw d0_17 cap_ctrl10_17
+  cap_ctrl11_17 cap_ctrl12_17 vddce vpw cap_ctrl00_16 cap_ctrl01_16
+  cap_ctrl02_16 vddpe d1_16 vpw weny1_16 wen_lat1_term_16 vss_ast1_16
+  wen_lat0_term_16 vss_ast0_16 weny0_16 vpw vpw d0_16 cap_ctrl10_16
+  cap_ctrl11_16 cap_ctrl12_16 q1_15 vddce vpw cap_ctrl00_15 cap_ctrl01_15
+  cap_ctrl02_15 vddpe vpw vss_ast1_15 wen_lat0_term_15 vss_ast0_15 weny0_15
+  vpw vpw d0_15 q0_15 cap_ctrl10_15 cap_ctrl11_15 cap_ctrl12_15 q1_14 vpw vpw
+  cap_ctrl00_14 cap_ctrl01_14 cap_ctrl02_14 d1_14 vpw vpw weny1_14
+  wen_lat1_term_14 vss_ast1_14 wen_lat0_term_14 vss_ast0_14 weny0_14 vpw vpw
+  d0_14 vpw cap_ctrl10_14 cap_ctrl11_14 cap_ctrl12_14 q1_13 vddce vpw
+  cap_ctrl00_13 cap_ctrl01_13 cap_ctrl02_13 vddpe d1_13 vpw vss_ast1_13
+  wen_lat0_term_13 vss_ast0_13 weny0_13 vpw vpw d0_13 cap_ctrl10_13
+  cap_ctrl11_13 cap_ctrl12_13 q1_12 vddce vpw cap_ctrl00_12 cap_ctrl01_12
+  cap_ctrl02_12 vddpe vpw vss_ast1_12 wen_lat0_term_12 vss_ast0_12 weny0_12
+  vpw vpw d0_12 vddpe q0_12 cap_ctrl10_12 cap_ctrl11_12 cap_ctrl12_12 q1_11
+  vpw vpw cap_ctrl00_11 cap_ctrl01_11 cap_ctrl02_11 vddpe d1_11 vpw weny1_11
+  vss_ast1_11 wen_lat0_term_11 vss_ast0_11 weny0_11 vpw vpw d0_11
+  cap_ctrl10_11 cap_ctrl11_11 cap_ctrl12_11 vpw a1 a1 a1 vpw vpw vpw vpw vpw
+  vpw vpw vpw vpw vddce dbl_nbl_wa_turn vpw a1 emas ema0 ema1 ema2 emaw0
+  emaw1 cap_ctrl12_10 cap_ctrl11_10 cap_ctrl10_10 q0_10 vpw d0_10 vpw vpw
+  weny0_10 vss_ast0_10 wen_lat0_term_10 vss_ast1_10 vpw vpw vddpe
+  cap_ctrl02_10 cap_ctrl01_10 cap_ctrl00_10 vpw vddce q1_10 cap_ctrl12_9
+  cap_ctrl11_9 cap_ctrl10_9 q0_9 vpw vpw vss_ast0_9 wen_lat0_term_9
+  vss_ast1_9 vpw vpw cap_ctrl02_9 cap_ctrl01_9 cap_ctrl00_9 vpw vpw vddpe
+  q1_9 cap_ctrl12_8 cap_ctrl11_8 cap_ctrl10_8 q0_8 vpw d0_8 vpw vpw weny0_8
+  vss_ast0_8 wen_lat0_term_8 vss_ast1_8 vpw vddpe cap_ctrl02_8 cap_ctrl01_8
+  cap_ctrl00_8 vpw vddce q1_8 cap_ctrl12_7 cap_ctrl11_7 cap_ctrl10_7 q0_7
+  vddpe vpw vpw vss_ast0_7 wen_lat0_term_7 vss_ast1_7 vpw vddpe cap_ctrl02_7
+  cap_ctrl01_7 cap_ctrl00_7 vpw vpw vddce q1_7 cap_ctrl12_6 cap_ctrl11_6
+  cap_ctrl10_6 q0_6 vpw vpw weny0_6 vss_ast0_6 wen_lat0_term_6 vss_ast1_6 vpw
+  cap_ctrl02_6 cap_ctrl01_6 cap_ctrl00_6 vpw vpw vddpe vddce q1_6
+  cap_ctrl12_5 cap_ctrl11_5 cap_ctrl10_5 q0_5 d0_5 vpw vpw weny0_5 vss_ast0_5
+  wen_lat0_term_5 vss_ast1_5 vpw vpw vddpe cap_ctrl02_5 cap_ctrl01_5
+  cap_ctrl00_5 vpw vpw vddce q1_5 cap_ctrl12_4 cap_ctrl11_4 cap_ctrl10_4 q0_4
+  vpw vpw vpw vss_ast0_4 vss_ast1_4 vpw vddpe cap_ctrl02_4 cap_ctrl01_4
+  cap_ctrl00_4 vpw vpw vddpe vddce q1_4 cap_ctrl12_3 cap_ctrl11_3
+  cap_ctrl10_3 q0_3 vddpe vpw d0_3 vpw weny0_3 vss_ast0_3 wen_lat0_term_3
+  vss_ast1_3 vpw vpw cap_ctrl02_3 cap_ctrl01_3 cap_ctrl00_3 vddce q1_3
+  cap_ctrl12_2 cap_ctrl11_2 cap_ctrl10_2 q0_2 vpw vpw vss_ast0_2
+  wen_lat0_term_2 vss_ast1_2 vpw vddpe cap_ctrl02_2 cap_ctrl01_2 cap_ctrl00_2
+  vpw vpw vddpe vddce q1_2 cap_ctrl12_1 cap_ctrl11_1 cap_ctrl10_1 q0_1 vpw
+  vpw vss_ast0_1 vss_ast1_1 vpw vddpe cap_ctrl02_1 cap_ctrl01_1 cap_ctrl00_1
+  vpw vddpe vddce q1_1 cap_ctrl12_0 cap_ctrl11_0 cap_ctrl10_0 q0_0 vpw vddpe
+  vpw vpw vss_ast0_0 wen_lat0_term_0 vss_ast1_0 wen_lat1_term_0 vpw vpw vddpe
+  cap_ctrl02_0 cap_ctrl01_0 cap_ctrl00_0 vpw vpw vddpe vddce q1_0 vpw vpw vpw
+  vddce vpw vddce vddpe vpw cap_ctrl00_term_22 cap_ctrl01_term_22
+  cap_ctrl02_term_22 d1_22 vpw vpw vpw weny1_22 wen_lat1_term_22
+  vss_ast1_term_22 wen_lat0_term_22 vss_ast0_term_22 weny0_22 d0_22
+  cap_ctrl10_term_22 cap_ctrl11_term_22 cap_ctrl12_term_22 vddpe
+  cap_ctrl00_term_21 cap_ctrl01_term_21 cap_ctrl02_term_21 vpw vpw
+  vss_ast1_term_21 wen_lat0_term_21 vss_ast0_term_21 weny0_21 vpw d0_21
+  cap_ctrl10_term_21 cap_ctrl11_term_21 cap_ctrl12_term_21 vddpe
+  cap_ctrl00_term_20 cap_ctrl01_term_20 cap_ctrl02_term_20 vddpe vpw vpw vpw
+  vss_ast1_term_20 vss_ast0_term_20 vpw vpw vpw vpw cap_ctrl10_term_20
+  cap_ctrl11_term_20 cap_ctrl12_term_20 q1_19 vpw cap_ctrl00_term_19
+  cap_ctrl01_term_19 cap_ctrl02_term_19 vpw vpw vss_ast1_term_19
+  vss_ast0_term_19 vpw vddpe vpw vddpe q0_19 cap_ctrl10_term_19
+  cap_ctrl11_term_19 cap_ctrl12_term_19 vddpe vpw vpw cap_ctrl00_term_18
+  cap_ctrl01_term_18 cap_ctrl02_term_18 vpw vpw wen_lat1_term_18
+  vss_ast1_term_18 vss_ast0_term_18 vpw vddpe q0_18 cap_ctrl10_term_18
+  cap_ctrl11_term_18 cap_ctrl12_term_18 vddce cap_ctrl00_term_17
+  cap_ctrl01_term_17 cap_ctrl02_term_17 vddpe vpw vpw vss_ast1_term_17
+  vss_ast0_term_17 vpw vddpe vpw vddpe q0_17 cap_ctrl10_term_17
+  cap_ctrl11_term_17 cap_ctrl12_term_17 q1_16 vddpe vpw vpw
+  cap_ctrl00_term_16 cap_ctrl01_term_16 cap_ctrl02_term_16 vpw vpw
+  vss_ast1_term_16 vss_ast0_term_16 vpw vddpe q0_16 cap_ctrl10_term_16
+  cap_ctrl11_term_16 cap_ctrl12_term_16 vddpe vpw vpw cap_ctrl00_term_15
+  cap_ctrl01_term_15 cap_ctrl02_term_15 d1_15 vpw vpw weny1_15
+  wen_lat1_term_15 vss_ast1_term_15 vss_ast0_term_15 vpw vddpe
+  cap_ctrl10_term_15 cap_ctrl11_term_15 cap_ctrl12_term_15 vddce
+  cap_ctrl00_term_14 cap_ctrl01_term_14 cap_ctrl02_term_14 vddpe vpw
+  vss_ast1_term_14 vss_ast0_term_14 vpw vddpe vddpe q0_14 cap_ctrl10_term_14
+  cap_ctrl11_term_14 cap_ctrl12_term_14 vddpe vpw vpw cap_ctrl00_term_13
+  cap_ctrl01_term_13 cap_ctrl02_term_13 vpw vpw weny1_13 wen_lat1_term_13
+  vss_ast1_term_13 vss_ast0_term_13 vpw vddpe q0_13 cap_ctrl10_term_13
+  cap_ctrl11_term_13 cap_ctrl12_term_13 vpw cap_ctrl00_term_12
+  cap_ctrl01_term_12 cap_ctrl02_term_12 d1_12 vpw vpw weny1_12
+  wen_lat1_term_12 vss_ast1_term_12 vss_ast0_term_12 vpw vddpe vpw
+  cap_ctrl10_term_12 cap_ctrl11_term_12 cap_ctrl12_term_12 vddce vddpe vpw
+  cap_ctrl00_term_11 cap_ctrl01_term_11 cap_ctrl02_term_11 vpw vpw
+  wen_lat1_term_11 vss_ast1_term_11 vss_ast0_term_11 vpw vddpe q0_11
+  cap_ctrl10_term_11 cap_ctrl11_term_11 cap_ctrl12_term_11 vpw vpw vpw vpw
+  vpw vpw vpw vpw vddpe vddce vddpe vpw dft_p2_term gwen_p2_term gtp_term
+  dbl_nbl_wa_turn_term dbl_nbl_wa_term penso vpw vpw vpw pso1 pso0 vpw vpw
+  vpw log1 a1 wablm1 wablm0 wabl rawlm1 rawlm0 rawl ret1n vpw vpw a1 gwen cen
+  clk a0 a1 a1 a3 a4 a5 a6 a7 a8 a1 a1 vpw vpw vpw vpw vpw vpw vpw vpw vpw
+  vpw vpw vpw vpw vpw vpw vpw vpw vpw vpw vpw vpw vpw vpw vpw vpw vpw
+  cap_ctrl12_term_10 cap_ctrl11_term_10 cap_ctrl10_term_10 vddpe vpw
+  vss_ast0_term_10 vss_ast1_term_10 wen_lat1_term_10 weny1_10 vpw d1_10
+  cap_ctrl02_term_10 cap_ctrl01_term_10 cap_ctrl00_term_10 vpw vddpe
+  cap_ctrl12_term_9 cap_ctrl11_term_9 cap_ctrl10_term_9 vddpe d0_9 vpw
+  weny0_9 vss_ast0_term_9 vss_ast1_term_9 wen_lat1_term_9 weny1_9 vpw d1_9
+  vddpe cap_ctrl02_term_9 cap_ctrl01_term_9 cap_ctrl00_term_9 vpw vddce
+  cap_ctrl12_term_8 cap_ctrl11_term_8 cap_ctrl10_term_8 vddpe vpw
+  vss_ast0_term_8 vss_ast1_term_8 wen_lat1_term_8 weny1_8 vpw vpw d1_8
+  cap_ctrl02_term_8 cap_ctrl01_term_8 cap_ctrl00_term_8 vpw vddpe
+  cap_ctrl12_term_7 cap_ctrl11_term_7 cap_ctrl10_term_7 vddpe d0_7 vpw
+  weny0_7 vss_ast0_term_7 vss_ast1_term_7 wen_lat1_term_7 weny1_7 vpw vpw
+  d1_7 cap_ctrl02_term_7 cap_ctrl01_term_7 cap_ctrl00_term_7 vpw
+  cap_ctrl12_term_6 cap_ctrl11_term_6 cap_ctrl10_term_6 vddpe d0_6 vpw vpw
+  vss_ast0_term_6 vss_ast1_term_6 wen_lat1_term_6 weny1_6 vpw vpw d1_6 vddpe
+  cap_ctrl02_term_6 cap_ctrl01_term_6 cap_ctrl00_term_6 cap_ctrl12_term_5
+  cap_ctrl11_term_5 cap_ctrl10_term_5 vddpe vpw vss_ast0_term_5
+  vss_ast1_term_5 wen_lat1_term_5 weny1_5 vpw d1_5 cap_ctrl02_term_5
+  cap_ctrl01_term_5 cap_ctrl00_term_5 vpw vddpe cap_ctrl12_term_4
+  cap_ctrl11_term_4 cap_ctrl10_term_4 vddpe d0_4 vpw weny0_4 vss_ast0_term_4
+  wen_lat0_term_4 vss_ast1_term_4 wen_lat1_term_4 weny1_4 vpw vpw d1_4
+  cap_ctrl02_term_4 cap_ctrl01_term_4 cap_ctrl00_term_4 cap_ctrl12_term_3
+  cap_ctrl11_term_3 cap_ctrl10_term_3 vpw vddpe vpw vpw vss_ast0_term_3
+  vss_ast1_term_3 wen_lat1_term_3 weny1_3 vpw d1_3 vddpe cap_ctrl02_term_3
+  cap_ctrl01_term_3 cap_ctrl00_term_3 vpw cap_ctrl12_term_2 cap_ctrl11_term_2
+  cap_ctrl10_term_2 vddpe d0_2 vpw weny0_2 vss_ast0_term_2 vss_ast1_term_2
+  wen_lat1_term_2 weny1_2 vpw vpw d1_2 cap_ctrl02_term_2 cap_ctrl01_term_2
+  cap_ctrl00_term_2 vpw cap_ctrl12_term_1 cap_ctrl11_term_1 cap_ctrl10_term_1
+  vpw vddpe d0_1 vpw vpw weny0_1 vss_ast0_term_1 wen_lat0_term_1
+  vss_ast1_term_1 wen_lat1_term_1 weny1_1 vpw vpw d1_1 cap_ctrl02_term_1
+  cap_ctrl01_term_1 cap_ctrl00_term_1 cap_ctrl12_term_0 cap_ctrl11_term_0
+  cap_ctrl10_term_0 d0_0 vpw weny0_0 vss_ast0_term_0 vss_ast1_term_0 weny1_0
+  vpw d1_0 cap_ctrl02_term_0 cap_ctrl01_term_0 cap_ctrl00_term_0 vpw vpw
+  vddce vddpe sram128x46cap_slice
xio_slice bl_term[3]_22 nbl_term[3]_22 nbl_term[2]_22 bl_term[2]_22 vddce
+  bl_term[1]_22 nbl_term[1]_22 nbl_term[0]_22 bl_term[0]_22 bl_term[3]_21
+  nbl_term[3]_21 nbl_term[2]_21 bl_term[2]_21 vddce bl_term[1]_21
+  nbl_term[1]_21 nbl_term[0]_21 bl_term[0]_21 bl_term[3]_20 nbl_term[3]_20
+  nbl_term[2]_20 bl_term[2]_20 vddce bl_term[1]_20 nbl_term[1]_20
+  nbl_term[0]_20 bl_term[0]_20 bl_term[3]_19 nbl_term[3]_19 nbl_term[2]_19
+  bl_term[2]_19 vddce bl_term[1]_19 nbl_term[1]_19 nbl_term[0]_19
+  bl_term[0]_19 bl_term[3]_18 nbl_term[3]_18 nbl_term[2]_18 bl_term[2]_18
+  vddce bl_term[1]_18 nbl_term[1]_18 nbl_term[0]_18 bl_term[0]_18
+  bl_term[3]_17 nbl_term[3]_17 nbl_term[2]_17 bl_term[2]_17 vddce
+  bl_term[1]_17 nbl_term[1]_17 nbl_term[0]_17 bl_term[0]_17 bl_term[3]_16
+  nbl_term[3]_16 nbl_term[2]_16 bl_term[2]_16 vddce bl_term[1]_16
+  nbl_term[1]_16 nbl_term[0]_16 bl_term[0]_16 bl_term[3]_15 nbl_term[3]_15
+  nbl_term[2]_15 bl_term[2]_15 vddce bl_term[1]_15 nbl_term[1]_15
+  nbl_term[0]_15 bl_term[0]_15 bl_term[3]_14 nbl_term[3]_14 nbl_term[2]_14
+  bl_term[2]_14 vddce bl_term[1]_14 nbl_term[1]_14 nbl_term[0]_14
+  bl_term[0]_14 bl_term[3]_13 nbl_term[3]_13 nbl_term[2]_13 bl_term[2]_13
+  vddce bl_term[1]_13 nbl_term[1]_13 nbl_term[0]_13 bl_term[0]_13
+  bl_term[3]_12 nbl_term[3]_12 nbl_term[2]_12 bl_term[2]_12 vddce
+  bl_term[1]_12 nbl_term[1]_12 nbl_term[0]_12 bl_term[0]_12 bl_term[3]_11
+  nbl_term[3]_11 nbl_term[2]_11 bl_term[2]_11 vddce bl_term[1]_11
+  nbl_term[1]_11 nbl_term[0]_11 bl_term[0]_11 nact_cc a1 a1 vddp_nor log1
+  log0_sa dbl dwl gtp nla_p2[1] nla_p2[0] la_p2[1] la_p2[0] nra_p2[5]
+  nra_p2[4] nra_p2[3] nra_p2[2] nra_p2[1] nra_p2[0] ra_p2[5] ra_p2[4]
+  ra_p2[3] ra_p2[2] ra_p2[1] ra_p2[0] cen_p2 nret vddce bl_term[0]_10
+  nbl_term[0]_10 nbl_term[1]_10 bl_term[1]_10 vddce bl_term[2]_10
+  nbl_term[2]_10 nbl_term[3]_10 bl_term[3]_10 bl_term[0]_9 nbl_term[0]_9
+  nbl_term[1]_9 bl_term[1]_9 vddce bl_term[2]_9 nbl_term[2]_9 nbl_term[3]_9
+  bl_term[3]_9 bl_term[0]_8 nbl_term[0]_8 nbl_term[1]_8 bl_term[1]_8 vddce
+  bl_term[2]_8 nbl_term[2]_8 nbl_term[3]_8 bl_term[3]_8 bl_term[0]_7
+  nbl_term[0]_7 nbl_term[1]_7 bl_term[1]_7 vddce bl_term[2]_7 nbl_term[2]_7
+  nbl_term[3]_7 bl_term[3]_7 bl_term[0]_6 nbl_term[0]_6 nbl_term[1]_6
+  bl_term[1]_6 vddce bl_term[2]_6 nbl_term[2]_6 nbl_term[3]_6 bl_term[3]_6
+  bl_term[0]_5 nbl_term[0]_5 nbl_term[1]_5 bl_term[1]_5 vddce bl_term[2]_5
+  nbl_term[2]_5 nbl_term[3]_5 bl_term[3]_5 bl_term[0]_4 nbl_term[0]_4
+  nbl_term[1]_4 bl_term[1]_4 vddce vddce bl_term[2]_4 nbl_term[2]_4
+  nbl_term[3]_4 bl_term[3]_4 bl_term[0]_3 nbl_term[0]_3 nbl_term[1]_3
+  bl_term[1]_3 vddce bl_term[2]_3 nbl_term[2]_3 nbl_term[3]_3 bl_term[3]_3
+  bl_term[0]_2 nbl_term[0]_2 nbl_term[1]_2 bl_term[1]_2 vddce bl_term[2]_2
+  nbl_term[2]_2 nbl_term[3]_2 bl_term[3]_2 bl_term[0]_1 nbl_term[0]_1
+  nbl_term[1]_1 bl_term[1]_1 vddce bl_term[2]_1 nbl_term[2]_1 nbl_term[3]_1
+  bl_term[3]_1 bl_term[0]_0 nbl_term[0]_0 nbl_term[1]_0 bl_term[1]_0 vddce
+  bl_term[2]_0 nbl_term[2]_0 nbl_term[3]_0 bl_term[3]_0 q1_22 d1_22 weny1_22
+  vss_ast1_22 vss_ast0_22 weny0_22 d0_22 q0_22 cap_ctrl10_term_22_421
+  cap_ctrl11_term_22_423 cap_ctrl12_term_22_425 q1_21 d1_21 weny1_21
+  vss_ast1_21 vss_ast0_21 weny0_21 d0_21 q0_21 cap_ctrl10_term_21_427
+  cap_ctrl11_term_21_429 cap_ctrl12_term_21_431 q1_20 d1_20 weny1_20
+  vss_ast1_20 vss_ast0_20 weny0_20 d0_20 q0_20 cap_ctrl10_term_20_433
+  cap_ctrl11_term_20_435 cap_ctrl12_term_20_437 q1_19 d1_19 weny1_19
+  vss_ast1_19 vss_ast0_19 weny0_19 d0_19 vddpe q0_19 cap_ctrl10_term_19_439
+  cap_ctrl11_term_19_441 cap_ctrl12_term_19_443 q1_18 d1_18 weny1_18
+  vss_ast1_18 a1 vss_ast0_18 weny0_18 d0_18 q0_18 cap_ctrl10_term_18_445
+  cap_ctrl11_term_18_447 cap_ctrl12_term_18_449 q1_17 d1_17 weny1_17
+  vss_ast1_17 vss_ast0_17 weny0_17 d0_17 q0_17 cap_ctrl10_term_17_451
+  cap_ctrl11_term_17_453 cap_ctrl12_term_17_455 q1_16 d1_16 weny1_16
+  vss_ast1_16 vss_ast0_16 weny0_16 d0_16 q0_16 cap_ctrl10_term_16_457
+  cap_ctrl11_term_16_459 cap_ctrl12_term_16_461 q1_15 d1_15 weny1_15
+  vss_ast1_15 vss_ast0_15 weny0_15 vpw d0_15 q0_15 cap_ctrl10_term_15_463
+  cap_ctrl11_term_15_465 cap_ctrl12_term_15_467 q1_14 d1_14 weny1_14
+  vss_ast1_14 vss_ast0_14 weny0_14 d0_14 q0_14 cap_ctrl10_term_14_469
+  cap_ctrl11_term_14_471 cap_ctrl12_term_14_473 q1_13 d1_13 weny1_13
+  vss_ast1_13 vss_ast0_13 weny0_13 d0_13 q0_13 cap_ctrl10_term_13_475
+  cap_ctrl11_term_13_477 cap_ctrl12_term_13_479 q1_12 d1_12 weny1_12
+  vss_ast1_12 vss_ast0_12 weny0_12 d0_12 q0_12 cap_ctrl10_term_12_481
+  cap_ctrl11_term_12_483 cap_ctrl12_term_12_485 q1_11 d1_11 weny1_11
+  vss_ast1_11 vss_ast0_11 weny0_11 d0_11 q0_11 cap_ctrl10_term_11_487
+  cap_ctrl11_term_11_489 cap_ctrl12_term_11_491 a1 dft_p2 gwen_p2
+  dbl_nbl_wa_turn_496 dbl_nbl_wa_turn_496 penso pso1 pso0 wablm1 wablm0 wabl
+  rawlm1 rawlm0 rawl emas ema0 ema1 ema2 emaw0 emaw1 ret1n a1 gwen cen clk a0
+  a1 a1 a3 a4 a5 a6 a7 a8 a1 a1 cap_ctrl12_term_10_498 cap_ctrl11_term_10_500
+  cap_ctrl10_term_10_502 q0_10 d0_10 weny0_10 vss_ast0_10 vss_ast1_10
+  weny1_10 d1_10 q1_10 cap_ctrl12_term_9_504 cap_ctrl11_term_9_506
+  cap_ctrl10_term_9_508 q0_9 d0_9 weny0_9 vss_ast0_9 vss_ast1_9 weny1_9 d1_9
+  q1_9 cap_ctrl12_term_8_510 cap_ctrl11_term_8_512 cap_ctrl10_term_8_514 q0_8
+  d0_8 weny0_8 vss_ast0_8 vss_ast1_8 weny1_8 d1_8 q1_8 cap_ctrl12_term_7_516
+  cap_ctrl11_term_7_518 cap_ctrl10_term_7_520 q0_7 d0_7 weny0_7 vss_ast0_7
+  vss_ast1_7 weny1_7 d1_7 q1_7 cap_ctrl12_term_6_522 cap_ctrl11_term_6_524
+  cap_ctrl10_term_6_526 q0_6 d0_6 weny0_6 vss_ast0_6 vss_ast1_6 weny1_6 d1_6
+  q1_6 cap_ctrl12_term_5_528 cap_ctrl11_term_5_530 cap_ctrl10_term_5_532 q0_5
+  d0_5 weny0_5 vss_ast0_5 vss_ast1_5 weny1_5 d1_5 q1_5 cap_ctrl12_term_4_534
+  cap_ctrl11_term_4_536 cap_ctrl10_term_4_538 q0_4 d0_4 weny0_4 vss_ast0_4
+  vss_ast1_4 weny1_4 d1_4 q1_4 cap_ctrl12_term_3_540 cap_ctrl11_term_3_542
+  cap_ctrl10_term_3_544 q0_3 d0_3 weny0_3 vss_ast0_3 vss_ast1_3 weny1_3 d1_3
+  q1_3 cap_ctrl12_term_2_546 cap_ctrl11_term_2_548 cap_ctrl10_term_2_550 q0_2
+  d0_2 weny0_2 vss_ast0_2 vss_ast1_2 weny1_2 d1_2 q1_2 cap_ctrl12_term_1_552
+  cap_ctrl11_term_1_554 cap_ctrl10_term_1_556 q0_1 d0_1 weny0_1 vss_ast0_1
+  vss_ast1_1 weny1_1 d1_1 q1_1 cap_ctrl12_term_0_558 cap_ctrl11_term_0_560
+  cap_ctrl10_term_0_562 q0_0 d0_0 weny0_0 vss_ast0_0 vss_ast1_0 weny1_0 d1_0
+  q1_0 sram128x46io_slice
xmemslice bl_term[2]_22 nbl_term[2]_21 bl_term[2]_21 bl_term[3]_20
+  bl_term[2]_20 bl_term[2]_19 bl_term[1]_19 nbl_term[3]_18 bl_term[2]_18
+  bl_term[1]_18 bl_term[2]_17 bl_term[1]_17 bl_term[2]_16 bl_term[1]_16
+  nbl_term[1]_16 nbl_term[3]_15 nbl_term[2]_15 bl_term[2]_15 vpw
+  bl_term[1]_15 nbl_term[1]_15 nbl_term[3]_14 nbl_term[2]_14 bl_term[2]_14
+  bl_term[1]_14 nbl_term[1]_14 bl_term[0]_14 nbl_term[3]_13 nbl_term[2]_13
+  bl_term[2]_13 bl_term[1]_13 nbl_term[1]_13 nbl_term[0]_13 bl_term[0]_13
+  nbl_term[2]_12 bl_term[2]_12 bl_term[1]_12 nbl_term[1]_12 nbl_term[0]_12
+  bl_term[0]_12 nbl_term[2]_11 bl_term[2]_11 bl_term[1]_11 nbl_term[1]_11
+  nbl_term[0]_11 bl_term[0]_11 vddpe ret a1 a1 vddc_wl vddpe dwl
+  nbl_term[1]_10 bl_term[1]_10 bl_term[2]_10 nbl_term[2]_10 bl_term[0]_9
+  nbl_term[1]_9 bl_term[1]_9 nbl_term[2]_9 bl_term[0]_8 nbl_term[0]_8
+  nbl_term[1]_8 bl_term[1]_8 nbl_term[2]_8 bl_term[0]_7 nbl_term[0]_7
+  nbl_term[1]_7 bl_term[1]_7 bl_term[2]_7 nbl_term[2]_7 bl_term[0]_6
+  nbl_term[0]_6 nbl_term[1]_6 bl_term[1]_6 bl_term[2]_6 nbl_term[2]_6
+  bl_term[3]_6 bl_term[0]_5 nbl_term[0]_5 nbl_term[1]_5 bl_term[1]_5
+  bl_term[2]_5 nbl_term[2]_5 bl_term[3]_5 bl_term[0]_4 nbl_term[0]_4
+  nbl_term[1]_4 bl_term[1]_4 vddpe nbl_term[2]_4 bl_term[0]_3 nbl_term[0]_3
+  nbl_term[1]_3 bl_term[1]_3 vddce bl_term[0]_2 nbl_term[0]_2 nbl_term[1]_2
+  bl_term[1]_2 bl_term[0]_1 nbl_term[0]_1 nbl_term[1]_1 bl_term[1]_1
+  bl_term[2]_1 nbl_term[2]_1 bl_term[3]_1 bl_term[0]_0 nbl_term[0]_0
+  nbl_term[1]_0 bl_term[1]_0 nbl_term[2]_0 bl_term[3]_0 vddpe vddpe
+  bl_term[3]_22 nbl_term[3]_22 nbl_term[2]_22 bl_term[1]_22 nbl_term[1]_22
+  nbl_term[0]_22 bl_term[0]_22 bl_term[3]_21 nbl_term[3]_21 bl_term[1]_21
+  nbl_term[1]_21 nbl_term[0]_21 bl_term[0]_21 nbl_term[3]_20 nbl_term[2]_20
+  bl_term[1]_20 nbl_term[1]_20 nbl_term[0]_20 bl_term[0]_20 bl_term[3]_19
+  nbl_term[3]_19 nbl_term[2]_19 nbl_term[1]_19 nbl_term[0]_19 bl_term[0]_19
+  bl_term[3]_18 nbl_term[2]_18 nbl_term[1]_18 nbl_term[0]_18 bl_term[0]_18
+  bl_term[3]_17 nbl_term[3]_17 nbl_term[2]_17 nbl_term[1]_17 nbl_term[0]_17
+  bl_term[0]_17 bl_term[3]_16 nbl_term[3]_16 nbl_term[2]_16 nbl_term[0]_16
+  bl_term[0]_16 bl_term[3]_15 nbl_term[0]_15 bl_term[0]_15 bl_term[3]_14
+  nbl_term[0]_14 bl_term[3]_13 bl_term[3]_12 nbl_term[3]_12 bl_term[3]_11
+  nbl_term[3]_11 dbl_nbl_wa_turn_496 nact_cc a1 vddp_nor log1 a1 log0_sa dbl
+  dwl gtp gtp nla_p2[1] nla_p2[0] la_p2[1] la_p2[0] nra_p2[5] nra_p2[4]
+  nra_p2[3] nra_p2[2] nra_p2[1] nra_p2[0] ra_p2[5] ra_p2[4] ra_p2[3] ra_p2[2]
+  ra_p2[1] ra_p2[0] rawlm1 rawlm0 rawl cen_p2 nret ret1n ema0 ema1 ema2 dbl
+  bl_term[0]_10 nbl_term[0]_10 nbl_term[3]_10 bl_term[3]_10 nbl_term[0]_9
+  bl_term[2]_9 nbl_term[3]_9 bl_term[3]_9 bl_term[2]_8 nbl_term[3]_8
+  bl_term[3]_8 nbl_term[3]_7 bl_term[3]_7 nbl_term[3]_6 nbl_term[3]_5
+  bl_term[2]_4 nbl_term[3]_4 bl_term[3]_4 bl_term[2]_3 nbl_term[2]_3
+  nbl_term[3]_3 bl_term[3]_3 bl_term[2]_2 nbl_term[2]_2 nbl_term[3]_2
+  bl_term[3]_2 nbl_term[3]_1 bl_term[2]_0 nbl_term[3]_0 sram128x46mem_slice
.ends sram128x46TILE_TOP
****
.subckt sram128x46 VDDCE VDDPE VSSE q[45] q[44] q[43] q[42] q[41] q[40] q[39]
+  q[38] q[37] q[36] q[35] q[34] q[33] q[32] q[31] q[30] q[29] q[28] q[27]
+  q[26] q[25] q[24] q[23] q[22] q[21] q[20] q[19] q[18] q[17] q[16] q[15]
+  q[14] q[13] q[12] q[11] q[10] q[9] q[8] q[7] q[6] q[5] q[4] q[3] q[2] q[1]
+  q[0] clk cen wen a[6] a[5] a[4] a[3] a[2] a[1] a[0] d[45] d[44] d[43] d[42]
+  d[41] d[40] d[39] d[38] d[37] d[36] d[35] d[34] d[33] d[32] d[31] d[30]
+  d[29] d[28] d[27] d[26] d[25] d[24] d[23] d[22] d[21] d[20] d[19] d[18]
+  d[17] d[16] d[15] d[14] d[13] d[12] d[11] d[10] d[9] d[8] d[7] d[6] d[5]
+  d[4] d[3] d[2] d[1] d[0] ema[2] ema[1] ema[0] emaw[1] emaw[0] emas ret1n
+  wabl wablm[1] wablm[0] rawl rawlm[1] rawlm[0]
** sram128x46: 41830 flat devices **
xi0 q[45] d[45] weny1_22 weny0_22 d[44] q[44] q[43] VDDCE d[43] weny1_21
+  weny0_21 d[42] q[42] q[41] d[41] weny1_20 weny0_20 d[40] q[40] q[39] d[39]
+  weny1_19 weny0_19 d[38] q[38] q[37] d[37] weny1_18 weny0_18 d[36] q[36]
+  q[35] d[35] weny1_17 weny0_17 d[34] q[34] q[33] d[33] weny1_16 weny0_16
+  d[32] q[32] q[31] VDDPE d[31] weny1_15 weny0_15 d[30] q[30] q[29] d[29]
+  weny1_14 weny0_14 d[28] q[28] q[27] d[27] weny1_13 weny0_13 d[26] q[26]
+  q[25] d[25] weny1_12 weny0_12 d[24] q[24] q[23] d[23] weny1_11 weny0_11
+  d[22] q[22] penso VSSE pso1 pso0 wablm[1] wablm[0] wabl rawlm[1] rawlm[0]
+  rawl emas ema[0] ema[1] ema[2] emaw[0] emaw[1] ret1n wen cen clk a[0] a[1]
+  a[2] a[3] a[4] a[5] a[6] a1 q[21] d[21] weny0_10 weny1_10 d[20] q[20] q[19]
+  d[19] weny0_9 weny1_9 d[18] q[18] q[17] d[17] weny0_8 weny1_8 d[16] q[16]
+  q[15] d[15] weny0_7 weny1_7 d[14] q[14] q[13] d[13] weny0_6 weny1_6 d[12]
+  q[12] q[11] d[11] weny0_5 weny1_5 d[10] q[10] q[9] d[9] weny0_4 weny1_4
+  d[8] q[8] q[7] d[7] weny0_3 weny1_3 d[6] q[6] q[5] d[5] weny0_2 weny1_2
+  d[4] q[4] q[3] d[3] weny0_1 weny1_1 d[2] q[2] q[1] d[1] weny0_0 weny1_0
+  d[0] q[0] sram128x46TILE_TOP
.ends sram128x46

+  ncored10_196 ncored11_198 ncored20_200 ncored21_202 ncored30_204
+  ncored31_206 vddc_26 vddce_26 vddpe_26 vnwc_27 vpw_27 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_27 bl[0]_27 bl[1]_27 bl[2]_27 bl[3]_27 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_27 nbl[1]_27 nbl[2]_27 nbl[3]_27 ncored00_224 ncored01_226
+  ncored10_228 ncored11_230 ncored20_232 ncored21_234 ncored30_236
+  ncored31_238 vddc_27 vddce_27 vddpe_27 vnwc_28 vpw_28 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_28 bl[0]_28 bl[1]_28 bl[2]_28 bl[3]_28 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_28 nbl[1]_28 nbl[2]_28 nbl[3]_28 ncored00_256 ncored01_258
+  ncored10_260 ncored11_262 ncored20_264 ncored21_266 ncored30_268
+  ncored31_270 vddc_28 vddce_28 vddpe_28 vnwc_29 vpw_29 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_29 bl[0]_29 bl[1]_29 bl[2]_29 bl[3]_29 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_29 nbl[1]_29 nbl[2]_29 nbl[3]_29 ncored00_288 ncored01_290
+  ncored10_292 ncored11_294 ncored20_296 ncored21_298 ncored30_300
+  ncored31_302 vddc_29 vddce_29 vddpe_29 vnwc_30 vpw_30 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_400 cored01_402
+  cored10_404 cored11_406 cored20_408 cored21_410 cored30_412 cored31_414
+  nbl[0]_3 nbl[1]_3 nbl[2]_3 nbl[3]_3 ncored00_416 ncored01_418 ncored10_420
+  ncored11_422 ncored20_424 ncored21_426 ncored30_428 ncored31_430 vddc_3
+  vddce_3 vddpe_3 vnwc_4 vpw_4 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_30 bl[0]_30 bl[1]_30 bl[2]_30 bl[3]_30 cored00_720 cored01_722
+  cored10_724 cored11_726 cored20_728 cored21_730 cored30_732 cored31_734
+  nbl[0]_30 nbl[1]_30 nbl[2]_30 nbl[3]_30 ncored00_736 ncored01_738
+  ncored10_740 ncored11_742 ncored20_744 ncored21_746 ncored30_748
+  ncored31_750 vddc_30 vddce_30 vddpe_30 vnwc_31 vpw_31 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_31 bl[0]_31 bl[1]_31 bl[2]_31 bl[3]_31 cored00_784 cored01_786
+  cored10_788 cored11_790 cored20_792 cored21_794 cored30_796 cored31_798
+  nbl[0]_31 nbl[1]_31 nbl[2]_31 nbl[3]_31 ncored00_800 ncored01_802
+  ncored10_804 ncored11_806 ncored20_808 ncored21_810 ncored30_812
+  ncored31_814 vddc_31 vddce_31 vddpe_31 vnwc_32 vpw_32 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_432 cored01_434
+  cored10_436 cored11_438 cored20_440 cored21_442 cored30_444 cored31_446
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_448 ncored01_450 ncored10_452
+  ncored11_454 ncored20_456 ncored21_458 ncored30_460 ncored31_462 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_464 cored01_466
+  cored10_468 cored11_470 cored20_472 cored21_474 cored30_476 cored31_478
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_480 ncored01_482 ncored10_484
+  ncored11_486 ncored20_488 ncored21_490 ncored30_492 ncored31_494 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_496 cored01_498
+  cored10_500 cored11_502 cored20_504 cored21_506 cored30_508 cored31_510
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_512 ncored01_514 ncored10_516
+  ncored11_518 ncored20_520 ncored21_522 ncored30_524 ncored31_526 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_528 cored01_530
+  cored10_532 cored11_534 cored20_536 cored21_538 cored30_540 cored31_542
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_544 ncored01_546 ncored10_548
+  ncored11_550 ncored20_552 ncored21_554 ncored30_556 ncored31_558 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_560 cored01_562
+  cored10_564 cored11_566 cored20_568 cored21_570 cored30_572 cored31_574
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_576 ncored01_578 ncored10_580
+  ncored11_582 ncored20_584 ncored21_586 ncored30_588 ncored31_590 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_592 cored01_594
+  cored10_596 cored11_598 cored20_600 cored21_602 cored30_604 cored31_606
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_608 ncored01_610 ncored10_612
+  ncored11_614 ncored20_616 ncored21_618 ncored30_620 ncored31_622 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_edger dbl dwl vddc_32 vnwc_33 vnwp_1 vpw_33 vssc wl[0] wl[1]
+  rf64x128cchs4wd_edgbl_dummy
.ends rf64x128mem_l_test3row
****
.subckt rf64x128mem_l_test4row vddc_32 vnwc_33 dbl dwl vnwc_32 bl[2]_31
+  nbl[2]_31 nbl[3]_31 bl[3]_31 bl[1]_30 vddpe_30 bl[2]_30 nbl[2]_30 nbl[3]_30
+  bl[1]_29 vddpe_29 bl[2]_29 nbl[2]_29 bl[1]_28 vddpe_28 bl[2]_28 nbl[2]_28
+  bl[1]_27 vddpe_27 bl[2]_27 nbl[2]_27 bl[0]_26 bl[1]_26 vddpe_26 nbl[2]_26
+  nbl[3]_26 bl[0]_25 bl[1]_25 vddpe_25 vddce_25 vnwc_26 vssc nbl[2]_25
+  nbl[3]_25 bl[0]_24 nbl[0]_24 nbl[1]_24 bl[1]_24 vddpe_24 vddce_24 vnwc_25
+  vpw_25 bl[2]_24 nbl[2]_24 nbl[3]_24 bl[0]_23 nbl[0]_23 nbl[1]_23 bl[1]_23
+  vddpe_23 vddce_23 vnwc_24 vpw_24 bl[2]_23 nbl[2]_23 bl[0]_22 nbl[0]_22
+  nbl[1]_22 bl[1]_22 vddpe_22 vddce_22 vnwc_23 vpw_23 bl[2]_22 nbl[2]_22
+  bl[0]_21 nbl[0]_21 nbl[1]_21 bl[1]_21 vddpe_21 vddce_21 vddc_21 vnwc_22
+  vpw_22 bl[2]_21 nbl[2]_21 bl[0]_20 nbl[0]_20 nbl[1]_20 bl[1]_20 vddpe_20
+  vddce_20 vddc_20 vnwc_21 vpw_21 nbl[2]_20 bl[0]_19 nbl[0]_19 nbl[1]_19
+  bl[1]_19 vddpe_19 vddce_19 vddc_19 vnwc_20 vpw_20 bl[0]_18 nbl[0]_18
+  nbl[1]_18 bl[1]_18 vddpe_18 vddce_18 vnwc_19 vpw_19 bl[2]_18 nbl[2]_18
+  bl[0]_17 nbl[0]_17 nbl[1]_17 bl[1]_17 vddpe_17 vddce_17 vnwc_18 vpw_18
+  bl[2]_17 nbl[2]_17 bl[0]_16 nbl[0]_16 nbl[1]_16 bl[1]_16 vddpe_16 vddce_16
+  vddc_16 vnwc_17 vpw_17 bl[2]_16 nbl[2]_16 bl[0]_15 nbl[0]_15 nbl[1]_15
+  bl[1]_15 vddpe_15 vddce_15 vddc_15 vnwc_16 vpw_16 nbl[2]_15 bl[0]_14
+  nbl[0]_14 nbl[1]_14 bl[1]_14 vddpe_14 vddce_14 vddc_14 vnwc_15 vpw_15
+  nbl[2]_14 bl[0]_13 nbl[0]_13 nbl[1]_13 bl[1]_13 vddpe_13 vddce_13 vddc_13
+  vnwc_14 vpw_14 bl[0]_12 nbl[0]_12 nbl[1]_12 bl[1]_12 vddpe_12 vddce_12
+  vddc_12 vnwc_13 vpw_13 bl[0]_11 nbl[0]_11 nbl[1]_11 bl[1]_11 vddpe_11
+  vddce_11 vddc_11 vnwc_12 vpw_12 bl[2]_11 nbl[2]_11 bl[0]_10 nbl[0]_10
+  nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vddc_10 vnwc_11 vpw_11 nbl[2]_10
+  bl[0]_9 nbl[0]_9 nbl[1]_9 bl[1]_9 vddpe_9 vddce_9 vddc_9 vnwc_10 vpw_10
+  nbl[2]_9 bl[0]_8 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 vddce_8 vddc_8 vnwc_9
+  vpw_9 bl[0]_7 nbl[0]_7 nbl[1]_7 bl[1]_7 vddpe_7 vddce_7 vddc_7 vnwc_8 vpw_8
+  bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddpe_6 vddce_6 vddc_6 vnwc_7 vpw_7
+  bl[3]_6 bl[0]_5 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe_5 vddce_5 vddc_5 vnwc_6
+  vpw_6 nbl[2]_5 bl[0]_4 nbl[0]_4 nbl[1]_4 bl[1]_4 vddpe_4 vddce_4 vddc_4
+  vnwc_5 vpw_5 nbl[2]_4 bl[0]_3 nbl[0]_3 nbl[1]_3 bl[1]_3 vddpe_3 vddce_3
+  vddc_3 vnwc_4 vpw_4 bl[0]_2 nbl[0]_2 nbl[1]_2 bl[1]_2 vddpe_2 vddce_2
+  vddc_2 vnwc_3 vpw_3 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddpe_1 vddce_1
+  vddc_1 vnwc_2 vpw_2 bl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe_0
+  vddce_0 vddc_0 vnwc_1 vpw_1 bl[3]_0 vnwp_0 vnwc_0 vpw_0 vpw_33 vnwp_1
+  bl[0]_31 nbl[0]_31 nbl[1]_31 bl[1]_31 vddpe_31 vddce_31 vddc_31 vpw_32
+  bl[0]_30 nbl[0]_30 nbl[1]_30 vddce_30 vddc_30 vnwc_31 vpw_31 bl[3]_30
+  bl[0]_29 nbl[0]_29 nbl[1]_29 vddce_29 vddc_29 vnwc_30 vpw_30 nbl[3]_29
+  bl[3]_29 bl[0]_28 nbl[0]_28 nbl[1]_28 vddce_28 vddc_28 vnwc_29 vpw_29
+  nbl[3]_28 bl[3]_28 bl[0]_27 nbl[0]_27 nbl[1]_27 vddce_27 vddc_27 vnwc_28
+  vpw_28 nbl[3]_27 bl[3]_27 nbl[0]_26 nbl[1]_26 vddce_26 vddc_26 vnwc_27
+  vpw_27 bl[2]_26 bl[3]_26 nbl[0]_25 nbl[1]_25 vddc_25 vpw_26 bl[2]_25
+  bl[3]_25 vddc_24 bl[3]_24 vddc_23 nbl[3]_23 bl[3]_23 vddc_22 nbl[3]_22
+  bl[3]_22 nbl[3]_21 bl[3]_21 bl[2]_20 nbl[3]_20 bl[3]_20 bl[2]_19 nbl[2]_19
+  nbl[3]_19 bl[3]_19 vddc_18 nbl[3]_18 bl[3]_18 vddc_17 nbl[3]_17 bl[3]_17
+  nbl[3]_16 bl[3]_16 bl[2]_15 nbl[3]_15 bl[3]_15 bl[2]_14 nbl[3]_14 bl[3]_14
+  bl[2]_13 nbl[2]_13 nbl[3]_13 bl[3]_13 bl[2]_12 nbl[2]_12 nbl[3]_12 bl[3]_12
+  nbl[3]_11 bl[3]_11 bl[2]_10 nbl[3]_10 bl[3]_10 bl[2]_9 nbl[3]_9 bl[3]_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[2]_6
+  nbl[2]_6 nbl[3]_6 bl[2]_5 nbl[3]_5 bl[3]_5 bl[2]_4 nbl[3]_4 bl[3]_4 bl[2]_3
+  nbl[2]_3 nbl[3]_3 bl[3]_3 bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[2]_1
+  nbl[2]_1 nbl[3]_1 bl[2]_0 nbl[2]_0 nbl[3]_0 wl[1] wl[0]
** rf64x128mem_l_test4row: 1548 flat devices **
xmem_l_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0 ncored00_320 ncored01_322 ncored10_324
+  ncored11_326 ncored20_328 ncored21_330 ncored30_332 ncored31_334 vddc_0
+  vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_1 nbl[1]_1 nbl[2]_1 nbl[3]_1 ncored00_352 ncored01_354 ncored10_356
+  ncored11_358 ncored20_360 ncored21_362 ncored30_364 ncored31_366 vddc_1
+  vddce_1 vddpe_1 vnwc_2 vpw_2 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_624 cored01_626
+  cored10_628 cored11_630 cored20_632 cored21_634 cored30_636 cored31_638
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_640 ncored01_642
+  ncored10_644 ncored11_646 ncored20_648 ncored21_650 ncored30_652
+  ncored31_654 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_656 cored01_658
+  cored10_660 cored11_662 cored20_664 cored21_666 cored30_668 cored31_670
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_672 ncored01_674
+  ncored10_676 ncored11_678 ncored20_680 ncored21_682 ncored30_684
+  ncored31_686 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_12 bl[0]_12 bl[1]_12 bl[2]_12 bl[3]_12 cored00_688 cored01_690
+  cored10_692 cored11_694 cored20_696 cored21_698 cored30_700 cored31_702
+  nbl[0]_12 nbl[1]_12 nbl[2]_12 nbl[3]_12 ncored00_704 ncored01_706
+  ncored10_708 ncored11_710 ncored20_712 ncored21_714 ncored30_716
+  ncored31_718 vddc_12 vddce_12 vddpe_12 vnwc_13 vpw_13 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_13 bl[0]_13 bl[1]_13 bl[2]_13 bl[3]_13 cored00_752 cored01_754
+  cored10_756 cored11_758 cored20_760 cored21_762 cored30_764 cored31_766
+  nbl[0]_13 nbl[1]_13 nbl[2]_13 nbl[3]_13 ncored00_768 ncored01_770
+  ncored10_772 ncored11_774 ncored20_776 ncored21_778 ncored30_780
+  ncored31_782 vddc_13 vddce_13 vddpe_13 vnwc_14 vpw_14 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_14 bl[0]_14 bl[1]_14 bl[2]_14 bl[3]_14 cored00_816 cored01_818
+  cored10_820 cored11_822 cored20_824 cored21_826 cored30_828 cored31_830
+  nbl[0]_14 nbl[1]_14 nbl[2]_14 nbl[3]_14 ncored00_832 ncored01_834
+  ncored10_836 ncored11_838 ncored20_840 ncored21_842 ncored30_844
+  ncored31_846 vddc_14 vddce_14 vddpe_14 vnwc_15 vpw_15 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_15 bl[0]_15 bl[1]_15 bl[2]_15 bl[3]_15 cored00_848 cored01_850
+  cored10_852 cored11_854 cored20_856 cored21_858 cored30_860 cored31_862
+  nbl[0]_15 nbl[1]_15 nbl[2]_15 nbl[3]_15 ncored00_864 ncored01_866
+  ncored10_868 ncored11_870 ncored20_872 ncored21_874 ncored30_876
+  ncored31_878 vddc_15 vddce_15 vddpe_15 vnwc_16 vpw_16 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_16 bl[0]_16 bl[1]_16 bl[2]_16 bl[3]_16 cored00_880 cored01_882
+  cored10_884 cored11_886 cored20_888 cored21_890 cored30_892 cored31_894
+  nbl[0]_16 nbl[1]_16 nbl[2]_16 nbl[3]_16 ncored00_896 ncored01_898
+  ncored10_900 ncored11_902 ncored20_904 ncored21_906 ncored30_908
+  ncored31_910 vddc_16 vddce_16 vddpe_16 vnwc_17 vpw_17 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_17 bl[0]_17 bl[1]_17 bl[2]_17 bl[3]_17 cored00_912 cored01_914
+  cored10_916 cored11_918 cored20_920 cored21_922 cored30_924 cored31_926
+  nbl[0]_17 nbl[1]_17 nbl[2]_17 nbl[3]_17 ncored00_928 ncored01_930
+  ncored10_932 ncored11_934 ncored20_936 ncored21_938 ncored30_940
+  ncored31_942 vddc_17 vddce_17 vddpe_17 vnwc_18 vpw_18 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_18 bl[0]_18 bl[1]_18 bl[2]_18 bl[3]_18 cored00_944 cored01_946
+  cored10_948 cored11_950 cored20_952 cored21_954 cored30_956 cored31_958
+  nbl[0]_18 nbl[1]_18 nbl[2]_18 nbl[3]_18 ncored00_960 ncored01_962
+  ncored10_964 ncored11_966 ncored20_968 ncored21_970 ncored30_972
+  ncored31_974 vddc_18 vddce_18 vddpe_18 vnwc_19 vpw_19 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_19 bl[0]_19 bl[1]_19 bl[2]_19 bl[3]_19 cored00_976 cored01_978
+  cored10_980 cored11_982 cored20_984 cored21_986 cored30_988 cored31_990
+  nbl[0]_19 nbl[1]_19 nbl[2]_19 nbl[3]_19 ncored00_992 ncored01_994
+  ncored10_996 ncored11_998 ncored20_1000 ncored21_1002 ncored30_1004
+  ncored31_1006 vddc_19 vddce_19 vddpe_19 vnwc_20 vpw_20 vssc vssc wl[0]
+  wl[1] rf64x128cchs4
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_368 cored01_370
+  cored10_372 cored11_374 cored20_376 cored21_378 cored30_380 cored31_382
+  nbl[0]_2 nbl[1]_2 nbl[2]_2 nbl[3]_2 ncored00_384 ncored01_386 ncored10_388
+  ncored11_390 ncored20_392 ncored21_394 ncored30_396 ncored31_398 vddc_2
+  vddce_2 vddpe_2 vnwc_3 vpw_3 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_20 bl[0]_20 bl[1]_20 bl[2]_20 bl[3]_20 cored00 cored01 cored10
+  cored11 cored20 cored21 cored30 cored31 nbl[0]_20 nbl[1]_20 nbl[2]_20
+  nbl[3]_20 ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30
+  ncored31 vddc_20 vddce_20 vddpe_20 vnwc_21 vpw_21 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_21 bl[0]_21 bl[1]_21 bl[2]_21 bl[3]_21 cored00_16 cored01_18
+  cored10_20 cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_21
+  nbl[1]_21 nbl[2]_21 nbl[3]_21 ncored00_32 ncored01_34 ncored10_36
+  ncored11_38 ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_21
+  vddce_21 vddpe_21 vnwc_22 vpw_22 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_22 bl[0]_22 bl[1]_22 bl[2]_22 bl[3]_22 cored00_48 cored01_50
+  cored10_52 cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_22
+  nbl[1]_22 nbl[2]_22 nbl[3]_22 ncored00_64 ncored01_66 ncored10_68
+  ncored11_70 ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_22
+  vddce_22 vddpe_22 vnwc_23 vpw_23 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_23 bl[0]_23 bl[1]_23 bl[2]_23 bl[3]_23 cored00_80 cored01_82
+  cored10_84 cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_23
+  nbl[1]_23 nbl[2]_23 nbl[3]_23 ncored00_96 ncored01_98 ncored10_100
+  ncored11_102 ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_23
+  vddce_23 vddpe_23 vnwc_24 vpw_24 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_24 bl[0]_24 bl[1]_24 bl[2]_24 bl[3]_24 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_24 nbl[1]_24 nbl[2]_24 nbl[3]_24 ncored00_128 ncored01_130
+  ncored10_132 ncored11_134 ncored20_136 ncored21_138 ncored30_140
+  ncored31_142 vddc_24 vddce_24 vddpe_24 vnwc_25 vpw_25 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_25 bl[0]_25 bl[1]_25 bl[2]_25 bl[3]_25 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_25 nbl[1]_25 nbl[2]_25 nbl[3]_25 ncored00_160 ncored01_162
+  ncored10_164 ncored11_166 ncored20_168 ncored21_170 ncored30_172
+  ncored31_174 vddc_25 vddce_25 vddpe_25 vnwc_26 vpw_26 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_26 bl[0]_26 bl[1]_26 bl[2]_26 bl[3]_26 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_26 nbl[1]_26 nbl[2]_26 nbl[3]_26 ncored00_192 ncored01_194
+  ncored10_196 ncored11_198 ncored20_200 ncored21_202 ncored30_204
+  ncored31_206 vddc_26 vddce_26 vddpe_26 vnwc_27 vpw_27 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_27 bl[0]_27 bl[1]_27 bl[2]_27 bl[3]_27 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_27 nbl[1]_27 nbl[2]_27 nbl[3]_27 ncored00_224 ncored01_226
+  ncored10_228 ncored11_230 ncored20_232 ncored21_234 ncored30_236
+  ncored31_238 vddc_27 vddce_27 vddpe_27 vnwc_28 vpw_28 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_28 bl[0]_28 bl[1]_28 bl[2]_28 bl[3]_28 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_28 nbl[1]_28 nbl[2]_28 nbl[3]_28 ncored00_256 ncored01_258
+  ncored10_260 ncored11_262 ncored20_264 ncored21_266 ncored30_268
+  ncored31_270 vddc_28 vddce_28 vddpe_28 vnwc_29 vpw_29 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_29 bl[0]_29 bl[1]_29 bl[2]_29 bl[3]_29 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_29 nbl[1]_29 nbl[2]_29 nbl[3]_29 ncored00_288 ncored01_290
+  ncored10_292 ncored11_294 ncored20_296 ncored21_298 ncored30_300
+  ncored31_302 vddc_29 vddce_29 vddpe_29 vnwc_30 vpw_30 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_400 cored01_402
+  cored10_404 cored11_406 cored20_408 cored21_410 cored30_412 cored31_414
+  nbl[0]_3 nbl[1]_3 nbl[2]_3 nbl[3]_3 ncored00_416 ncored01_418 ncored10_420
+  ncored11_422 ncored20_424 ncored21_426 ncored30_428 ncored31_430 vddc_3
+  vddce_3 vddpe_3 vnwc_4 vpw_4 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_30 bl[0]_30 bl[1]_30 bl[2]_30 bl[3]_30 cored00_720 cored01_722
+  cored10_724 cored11_726 cored20_728 cored21_730 cored30_732 cored31_734
+  nbl[0]_30 nbl[1]_30 nbl[2]_30 nbl[3]_30 ncored00_736 ncored01_738
+  ncored10_740 ncored11_742 ncored20_744 ncored21_746 ncored30_748
+  ncored31_750 vddc_30 vddce_30 vddpe_30 vnwc_31 vpw_31 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_31 bl[0]_31 bl[1]_31 bl[2]_31 bl[3]_31 cored00_784 cored01_786
+  cored10_788 cored11_790 cored20_792 cored21_794 cored30_796 cored31_798
+  nbl[0]_31 nbl[1]_31 nbl[2]_31 nbl[3]_31 ncored00_800 ncored01_802
+  ncored10_804 ncored11_806 ncored20_808 ncored21_810 ncored30_812
+  ncored31_814 vddc_31 vddce_31 vddpe_31 vnwc_32 vpw_32 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_432 cored01_434
+  cored10_436 cored11_438 cored20_440 cored21_442 cored30_444 cored31_446
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_448 ncored01_450 ncored10_452
+  ncored11_454 ncored20_456 ncored21_458 ncored30_460 ncored31_462 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_464 cored01_466
+  cored10_468 cored11_470 cored20_472 cored21_474 cored30_476 cored31_478
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_480 ncored01_482 ncored10_484
+  ncored11_486 ncored20_488 ncored21_490 ncored30_492 ncored31_494 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_496 cored01_498
+  cored10_500 cored11_502 cored20_504 cored21_506 cored30_508 cored31_510
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_512 ncored01_514 ncored10_516
+  ncored11_518 ncored20_520 ncored21_522 ncored30_524 ncored31_526 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_528 cored01_530
+  cored10_532 cored11_534 cored20_536 cored21_538 cored30_540 cored31_542
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_544 ncored01_546 ncored10_548
+  ncored11_550 ncored20_552 ncored21_554 ncored30_556 ncored31_558 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_560 cored01_562
+  cored10_564 cored11_566 cored20_568 cored21_570 cored30_572 cored31_574
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_576 ncored01_578 ncored10_580
+  ncored11_582 ncored20_584 ncored21_586 ncored30_588 ncored31_590 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_592 cored01_594
+  cored10_596 cored11_598 cored20_600 cored21_602 cored30_604 cored31_606
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_608 ncored01_610 ncored10_612
+  ncored11_614 ncored20_616 ncored21_618 ncored30_620 ncored31_622 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_edger dbl dwl vddc_32 vnwc_33 vnwp_1 vpw_33 vssc wl[0] wl[1]
+  rf64x128cchs4wd_edgbl_dummy
.ends rf64x128mem_l_test4row
****
.subckt rf64x128mem_l_test5row vddc_32 vpw_33 vddc_31 vnwc_32 bl[2]_31
+  nbl[2]_31 nbl[3]_31 bl[3]_31 bl[1]_30 vddpe_30 bl[2]_30 nbl[2]_30 nbl[3]_30
+  bl[1]_29 vddpe_29 bl[2]_29 nbl[2]_29 bl[1]_28 vddpe_28 bl[2]_28 nbl[2]_28
+  bl[1]_27 vddpe_27 bl[2]_27 nbl[2]_27 bl[0]_26 bl[1]_26 vddpe_26 nbl[2]_26
+  nbl[3]_26 bl[0]_25 bl[1]_25 vddpe_25 vddce_25 vnwc_26 vssc nbl[2]_25
+  nbl[3]_25 bl[0]_24 nbl[0]_24 nbl[1]_24 bl[1]_24 vddpe_24 vddce_24 vnwc_25
+  vpw_25 bl[2]_24 nbl[2]_24 nbl[3]_24 bl[0]_23 nbl[0]_23 nbl[1]_23 bl[1]_23
+  vddpe_23 vddce_23 vnwc_24 vpw_24 bl[2]_23 nbl[2]_23 bl[0]_22 nbl[0]_22
+  nbl[1]_22 bl[1]_22 vddpe_22 vddce_22 vnwc_23 vpw_23 bl[2]_22 nbl[2]_22
+  bl[0]_21 nbl[0]_21 nbl[1]_21 bl[1]_21 vddpe_21 vddce_21 vddc_21 vnwc_22
+  vpw_22 bl[2]_21 nbl[2]_21 bl[0]_20 nbl[0]_20 nbl[1]_20 bl[1]_20 vddpe_20
+  vddce_20 vddc_20 vnwc_21 vpw_21 nbl[2]_20 bl[0]_19 nbl[0]_19 nbl[1]_19
+  bl[1]_19 vddpe_19 vddce_19 vddc_19 vnwc_20 vpw_20 bl[0]_18 nbl[0]_18
+  nbl[1]_18 bl[1]_18 vddpe_18 vddce_18 vnwc_19 vpw_19 bl[2]_18 nbl[2]_18
+  bl[0]_17 nbl[0]_17 nbl[1]_17 bl[1]_17 vddpe_17 vddce_17 vnwc_18 vpw_18
+  bl[2]_17 nbl[2]_17 bl[0]_16 nbl[0]_16 nbl[1]_16 bl[1]_16 vddpe_16 vddce_16
+  vddc_16 vnwc_17 vpw_17 bl[2]_16 nbl[2]_16 bl[0]_15 nbl[0]_15 nbl[1]_15
+  bl[1]_15 vddpe_15 vddce_15 vddc_15 vnwc_16 vpw_16 nbl[2]_15 bl[0]_14
+  nbl[0]_14 nbl[1]_14 bl[1]_14 vddpe_14 vddce_14 vddc_14 vnwc_15 vpw_15
+  nbl[2]_14 bl[0]_13 nbl[0]_13 nbl[1]_13 bl[1]_13 vddpe_13 vddce_13 vddc_13
+  vnwc_14 vpw_14 bl[0]_12 nbl[0]_12 nbl[1]_12 bl[1]_12 vddpe_12 vddce_12
+  vddc_12 vnwc_13 vpw_13 bl[0]_11 nbl[0]_11 nbl[1]_11 bl[1]_11 vddpe_11
+  vddce_11 vddc_11 vnwc_12 vpw_12 bl[2]_11 nbl[2]_11 bl[0]_10 nbl[0]_10
+  nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vddc_10 vnwc_11 vpw_11 nbl[2]_10
+  bl[0]_9 nbl[0]_9 nbl[1]_9 bl[1]_9 vddpe_9 vddce_9 vddc_9 vnwc_10 vpw_10
+  nbl[2]_9 bl[0]_8 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 vddce_8 vddc_8 vnwc_9
+  vpw_9 bl[0]_7 nbl[0]_7 nbl[1]_7 bl[1]_7 vddpe_7 vddce_7 vddc_7 vnwc_8 vpw_8
+  bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddpe_6 vddce_6 vddc_6 vnwc_7 vpw_7
+  bl[3]_6 bl[0]_5 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe_5 vddce_5 vddc_5 vnwc_6
+  vpw_6 nbl[2]_5 bl[0]_4 nbl[0]_4 nbl[1]_4 bl[1]_4 vddpe_4 vddce_4 vddc_4
+  vnwc_5 vpw_5 nbl[2]_4 bl[0]_3 nbl[0]_3 nbl[1]_3 bl[1]_3 vddpe_3 vddce_3
+  vddc_3 vnwc_4 vpw_4 bl[0]_2 nbl[0]_2 nbl[1]_2 bl[1]_2 vddpe_2 vddce_2
+  vddc_2 vnwc_3 vpw_3 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddpe_1 vddce_1
+  vddc_1 vnwc_2 vpw_2 bl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe_0
+  vddce_0 vddc_0 vnwc_1 vpw_1 bl[3]_0 vnwc_0 vpw_0 vnwc_33 vnwp_1 dbl dwl
+  bl[0]_31 nbl[0]_31 nbl[1]_31 bl[1]_31 vddpe_31 vddce_31 vpw_32 bl[0]_30
+  nbl[0]_30 nbl[1]_30 vddce_30 vddc_30 vnwc_31 vpw_31 bl[3]_30 bl[0]_29
+  nbl[0]_29 nbl[1]_29 vddce_29 vddc_29 vnwc_30 vpw_30 nbl[3]_29 bl[3]_29
+  bl[0]_28 nbl[0]_28 nbl[1]_28 vddce_28 vddc_28 vnwc_29 vpw_29 nbl[3]_28
+  bl[3]_28 bl[0]_27 nbl[0]_27 nbl[1]_27 vddce_27 vddc_27 vnwc_28 vpw_28
+  nbl[3]_27 bl[3]_27 nbl[0]_26 nbl[1]_26 vddce_26 vddc_26 vnwc_27 vpw_27
+  bl[2]_26 bl[3]_26 nbl[0]_25 nbl[1]_25 vddc_25 vpw_26 bl[2]_25 bl[3]_25
+  vddc_24 bl[3]_24 vddc_23 nbl[3]_23 bl[3]_23 vddc_22 nbl[3]_22 bl[3]_22
+  nbl[3]_21 bl[3]_21 bl[2]_20 nbl[3]_20 bl[3]_20 bl[2]_19 nbl[2]_19 nbl[3]_19
+  bl[3]_19 vddc_18 nbl[3]_18 bl[3]_18 vddc_17 nbl[3]_17 bl[3]_17 nbl[3]_16
+  bl[3]_16 bl[2]_15 nbl[3]_15 bl[3]_15 bl[2]_14 nbl[3]_14 bl[3]_14 bl[2]_13
+  nbl[2]_13 nbl[3]_13 bl[3]_13 bl[2]_12 nbl[2]_12 nbl[3]_12 bl[3]_12
+  nbl[3]_11 bl[3]_11 bl[2]_10 nbl[3]_10 bl[3]_10 bl[2]_9 nbl[3]_9 bl[3]_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[2]_6
+  nbl[2]_6 nbl[3]_6 bl[2]_5 nbl[3]_5 bl[3]_5 bl[2]_4 nbl[3]_4 bl[3]_4 bl[2]_3
+  nbl[2]_3 nbl[3]_3 bl[3]_3 bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[2]_1
+  nbl[2]_1 nbl[3]_1 bl[2]_0 nbl[2]_0 nbl[3]_0 vnwp_0 wl[0] wl[1]
** rf64x128mem_l_test5row: 1548 flat devices **
xmem_l_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0 ncored00_320 ncored01_322 ncored10_324
+  ncored11_326 ncored20_328 ncored21_330 ncored30_332 ncored31_334 vddc_0
+  vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_1 nbl[1]_1 nbl[2]_1 nbl[3]_1 ncored00_352 ncored01_354 ncored10_356
+  ncored11_358 ncored20_360 ncored21_362 ncored30_364 ncored31_366 vddc_1
+  vddce_1 vddpe_1 vnwc_2 vpw_2 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_624 cored01_626
+  cored10_628 cored11_630 cored20_632 cored21_634 cored30_636 cored31_638
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_640 ncored01_642
+  ncored10_644 ncored11_646 ncored20_648 ncored21_650 ncored30_652
+  ncored31_654 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_656 cored01_658
+  cored10_660 cored11_662 cored20_664 cored21_666 cored30_668 cored31_670
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_672 ncored01_674
+  ncored10_676 ncored11_678 ncored20_680 ncored21_682 ncored30_684
+  ncored31_686 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_12 bl[0]_12 bl[1]_12 bl[2]_12 bl[3]_12 cored00_688 cored01_690
+  cored10_692 cored11_694 cored20_696 cored21_698 cored30_700 cored31_702
+  nbl[0]_12 nbl[1]_12 nbl[2]_12 nbl[3]_12 ncored00_704 ncored01_706
+  ncored10_708 ncored11_710 ncored20_712 ncored21_714 ncored30_716
+  ncored31_718 vddc_12 vddce_12 vddpe_12 vnwc_13 vpw_13 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_13 bl[0]_13 bl[1]_13 bl[2]_13 bl[3]_13 cored00_752 cored01_754
+  cored10_756 cored11_758 cored20_760 cored21_762 cored30_764 cored31_766
+  nbl[0]_13 nbl[1]_13 nbl[2]_13 nbl[3]_13 ncored00_768 ncored01_770
+  ncored10_772 ncored11_774 ncored20_776 ncored21_778 ncored30_780
+  ncored31_782 vddc_13 vddce_13 vddpe_13 vnwc_14 vpw_14 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_14 bl[0]_14 bl[1]_14 bl[2]_14 bl[3]_14 cored00_816 cored01_818
+  cored10_820 cored11_822 cored20_824 cored21_826 cored30_828 cored31_830
+  nbl[0]_14 nbl[1]_14 nbl[2]_14 nbl[3]_14 ncored00_832 ncored01_834
+  ncored10_836 ncored11_838 ncored20_840 ncored21_842 ncored30_844
+  ncored31_846 vddc_14 vddce_14 vddpe_14 vnwc_15 vpw_15 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_15 bl[0]_15 bl[1]_15 bl[2]_15 bl[3]_15 cored00_848 cored01_850
+  cored10_852 cored11_854 cored20_856 cored21_858 cored30_860 cored31_862
+  nbl[0]_15 nbl[1]_15 nbl[2]_15 nbl[3]_15 ncored00_864 ncored01_866
+  ncored10_868 ncored11_870 ncored20_872 ncored21_874 ncored30_876
+  ncored31_878 vddc_15 vddce_15 vddpe_15 vnwc_16 vpw_16 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_16 bl[0]_16 bl[1]_16 bl[2]_16 bl[3]_16 cored00_880 cored01_882
+  cored10_884 cored11_886 cored20_888 cored21_890 cored30_892 cored31_894
+  nbl[0]_16 nbl[1]_16 nbl[2]_16 nbl[3]_16 ncored00_896 ncored01_898
+  ncored10_900 ncored11_902 ncored20_904 ncored21_906 ncored30_908
+  ncored31_910 vddc_16 vddce_16 vddpe_16 vnwc_17 vpw_17 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_17 bl[0]_17 bl[1]_17 bl[2]_17 bl[3]_17 cored00_912 cored01_914
+  cored10_916 cored11_918 cored20_920 cored21_922 cored30_924 cored31_926
+  nbl[0]_17 nbl[1]_17 nbl[2]_17 nbl[3]_17 ncored00_928 ncored01_930
+  ncored10_932 ncored11_934 ncored20_936 ncored21_938 ncored30_940
+  ncored31_942 vddc_17 vddce_17 vddpe_17 vnwc_18 vpw_18 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_18 bl[0]_18 bl[1]_18 bl[2]_18 bl[3]_18 cored00_944 cored01_946
+  cored10_948 cored11_950 cored20_952 cored21_954 cored30_956 cored31_958
+  nbl[0]_18 nbl[1]_18 nbl[2]_18 nbl[3]_18 ncored00_960 ncored01_962
+  ncored10_964 ncored11_966 ncored20_968 ncored21_970 ncored30_972
+  ncored31_974 vddc_18 vddce_18 vddpe_18 vnwc_19 vpw_19 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_19 bl[0]_19 bl[1]_19 bl[2]_19 bl[3]_19 cored00_976 cored01_978
+  cored10_980 cored11_982 cored20_984 cored21_986 cored30_988 cored31_990
+  nbl[0]_19 nbl[1]_19 nbl[2]_19 nbl[3]_19 ncored00_992 ncored01_994
+  ncored10_996 ncored11_998 ncored20_1000 ncored21_1002 ncored30_1004
+  ncored31_1006 vddc_19 vddce_19 vddpe_19 vnwc_20 vpw_20 vssc vssc wl[1]
+  wl[0] rf64x128cchs4
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_368 cored01_370
+  cored10_372 cored11_374 cored20_376 cored21_378 cored30_380 cored31_382
+  nbl[0]_2 nbl[1]_2 nbl[2]_2 nbl[3]_2 ncored00_384 ncored01_386 ncored10_388
+  ncored11_390 ncored20_392 ncored21_394 ncored30_396 ncored31_398 vddc_2
+  vddce_2 vddpe_2 vnwc_3 vpw_3 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_20 bl[0]_20 bl[1]_20 bl[2]_20 bl[3]_20 cored00 cored01 cored10
+  cored11 cored20 cored21 cored30 cored31 nbl[0]_20 nbl[1]_20 nbl[2]_20
+  nbl[3]_20 ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30
+  ncored31 vddc_20 vddce_20 vddpe_20 vnwc_21 vpw_21 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_21 bl[0]_21 bl[1]_21 bl[2]_21 bl[3]_21 cored00_16 cored01_18
+  cored10_20 cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_21
+  nbl[1]_21 nbl[2]_21 nbl[3]_21 ncored00_32 ncored01_34 ncored10_36
+  ncored11_38 ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_21
+  vddce_21 vddpe_21 vnwc_22 vpw_22 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_22 bl[0]_22 bl[1]_22 bl[2]_22 bl[3]_22 cored00_48 cored01_50
+  cored10_52 cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_22
+  nbl[1]_22 nbl[2]_22 nbl[3]_22 ncored00_64 ncored01_66 ncored10_68
+  ncored11_70 ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_22
+  vddce_22 vddpe_22 vnwc_23 vpw_23 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_23 bl[0]_23 bl[1]_23 bl[2]_23 bl[3]_23 cored00_80 cored01_82
+  cored10_84 cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_23
+  nbl[1]_23 nbl[2]_23 nbl[3]_23 ncored00_96 ncored01_98 ncored10_100
+  ncored11_102 ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_23
+  vddce_23 vddpe_23 vnwc_24 vpw_24 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_24 bl[0]_24 bl[1]_24 bl[2]_24 bl[3]_24 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_24 nbl[1]_24 nbl[2]_24 nbl[3]_24 ncored00_128 ncored01_130
+  ncored10_132 ncored11_134 ncored20_136 ncored21_138 ncored30_140
+  ncored31_142 vddc_24 vddce_24 vddpe_24 vnwc_25 vpw_25 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_25 bl[0]_25 bl[1]_25 bl[2]_25 bl[3]_25 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_25 nbl[1]_25 nbl[2]_25 nbl[3]_25 ncored00_160 ncored01_162
+  ncored10_164 ncored11_166 ncored20_168 ncored21_170 ncored30_172
+  ncored31_174 vddc_25 vddce_25 vddpe_25 vnwc_26 vpw_26 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_26 bl[0]_26 bl[1]_26 bl[2]_26 bl[3]_26 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_26 nbl[1]_26 nbl[2]_26 nbl[3]_26 ncored00_192 ncored01_194
+  ncored10_196 ncored11_198 ncored20_200 ncored21_202 ncored30_204
+  ncored31_206 vddc_26 vddce_26 vddpe_26 vnwc_27 vpw_27 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_27 bl[0]_27 bl[1]_27 bl[2]_27 bl[3]_27 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_27 nbl[1]_27 nbl[2]_27 nbl[3]_27 ncored00_224 ncored01_226
+  ncored10_228 ncored11_230 ncored20_232 ncored21_234 ncored30_236
+  ncored31_238 vddc_27 vddce_27 vddpe_27 vnwc_28 vpw_28 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_28 bl[0]_28 bl[1]_28 bl[2]_28 bl[3]_28 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_28 nbl[1]_28 nbl[2]_28 nbl[3]_28 ncored00_256 ncored01_258
+  ncored10_260 ncored11_262 ncored20_264 ncored21_266 ncored30_268
+  ncored31_270 vddc_28 vddce_28 vddpe_28 vnwc_29 vpw_29 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_29 bl[0]_29 bl[1]_29 bl[2]_29 bl[3]_29 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_29 nbl[1]_29 nbl[2]_29 nbl[3]_29 ncored00_288 ncored01_290
+  ncored10_292 ncored11_294 ncored20_296 ncored21_298 ncored30_300
+  ncored31_302 vddc_29 vddce_29 vddpe_29 vnwc_30 vpw_30 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_400 cored01_402
+  cored10_404 cored11_406 cored20_408 cored21_410 cored30_412 cored31_414
+  nbl[0]_3 nbl[1]_3 nbl[2]_3 nbl[3]_3 ncored00_416 ncored01_418 ncored10_420
+  ncored11_422 ncored20_424 ncored21_426 ncored30_428 ncored31_430 vddc_3
+  vddce_3 vddpe_3 vnwc_4 vpw_4 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_30 bl[0]_30 bl[1]_30 bl[2]_30 bl[3]_30 cored00_720 cored01_722
+  cored10_724 cored11_726 cored20_728 cored21_730 cored30_732 cored31_734
+  nbl[0]_30 nbl[1]_30 nbl[2]_30 nbl[3]_30 ncored00_736 ncored01_738
+  ncored10_740 ncored11_742 ncored20_744 ncored21_746 ncored30_748
+  ncored31_750 vddc_30 vddce_30 vddpe_30 vnwc_31 vpw_31 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_31 bl[0]_31 bl[1]_31 bl[2]_31 bl[3]_31 cored00_784 cored01_786
+  cored10_788 cored11_790 cored20_792 cored21_794 cored30_796 cored31_798
+  nbl[0]_31 nbl[1]_31 nbl[2]_31 nbl[3]_31 ncored00_800 ncored01_802
+  ncored10_804 ncored11_806 ncored20_808 ncored21_810 ncored30_812
+  ncored31_814 vddc_31 vddce_31 vddpe_31 vnwc_32 vpw_32 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_432 cored01_434
+  cored10_436 cored11_438 cored20_440 cored21_442 cored30_444 cored31_446
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_448 ncored01_450 ncored10_452
+  ncored11_454 ncored20_456 ncored21_458 ncored30_460 ncored31_462 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_464 cored01_466
+  cored10_468 cored11_470 cored20_472 cored21_474 cored30_476 cored31_478
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_480 ncored01_482 ncored10_484
+  ncored11_486 ncored20_488 ncored21_490 ncored30_492 ncored31_494 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_496 cored01_498
+  cored10_500 cored11_502 cored20_504 cored21_506 cored30_508 cored31_510
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_512 ncored01_514 ncored10_516
+  ncored11_518 ncored20_520 ncored21_522 ncored30_524 ncored31_526 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_528 cored01_530
+  cored10_532 cored11_534 cored20_536 cored21_538 cored30_540 cored31_542
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_544 ncored01_546 ncored10_548
+  ncored11_550 ncored20_552 ncored21_554 ncored30_556 ncored31_558 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_560 cored01_562
+  cored10_564 cored11_566 cored20_568 cored21_570 cored30_572 cored31_574
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_576 ncored01_578 ncored10_580
+  ncored11_582 ncored20_584 ncored21_586 ncored30_588 ncored31_590 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_592 cored01_594
+  cored10_596 cored11_598 cored20_600 cored21_602 cored30_604 cored31_606
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_608 ncored01_610 ncored10_612
+  ncored11_614 ncored20_616 ncored21_618 ncored30_620 ncored31_622 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_edger dbl dwl vddc_32 vnwc_33 vnwp_1 vpw_33 vssc wl[0] wl[1]
+  rf64x128cchs4wd_edgbl_dummy
.ends rf64x128mem_l_test5row
****
.subckt rf64x128mem_l_test9row vddc_32 vpw_33 vddc_31 vnwc_32 bl[2]_31
+  nbl[2]_31 nbl[3]_31 bl[3]_31 bl[1]_30 vddpe_30 bl[2]_30 nbl[2]_30 nbl[3]_30
+  bl[1]_29 vddpe_29 bl[2]_29 nbl[2]_29 bl[1]_28 vddpe_28 bl[2]_28 nbl[2]_28
+  bl[1]_27 vddpe_27 bl[2]_27 nbl[2]_27 bl[0]_26 bl[1]_26 vddpe_26 nbl[2]_26
+  nbl[3]_26 bl[0]_25 bl[1]_25 vddpe_25 vddce_25 vnwc_26 vssc nbl[2]_25
+  nbl[3]_25 bl[0]_24 nbl[0]_24 nbl[1]_24 bl[1]_24 vddpe_24 vddce_24 vnwc_25
+  vpw_25 bl[2]_24 nbl[2]_24 nbl[3]_24 bl[0]_23 nbl[0]_23 nbl[1]_23 bl[1]_23
+  vddpe_23 vddce_23 vnwc_24 vpw_24 bl[2]_23 nbl[2]_23 bl[0]_22 nbl[0]_22
+  nbl[1]_22 bl[1]_22 vddpe_22 vddce_22 vnwc_23 vpw_23 bl[2]_22 nbl[2]_22
+  bl[0]_21 nbl[0]_21 nbl[1]_21 bl[1]_21 vddpe_21 vddce_21 vddc_21 vnwc_22
+  vpw_22 bl[2]_21 nbl[2]_21 bl[0]_20 nbl[0]_20 nbl[1]_20 bl[1]_20 vddpe_20
+  vddce_20 vddc_20 vnwc_21 vpw_21 nbl[2]_20 bl[0]_19 nbl[0]_19 nbl[1]_19
+  bl[1]_19 vddpe_19 vddce_19 vddc_19 vnwc_20 vpw_20 bl[0]_18 nbl[0]_18
+  nbl[1]_18 bl[1]_18 vddpe_18 vddce_18 vnwc_19 vpw_19 bl[2]_18 nbl[2]_18
+  bl[0]_17 nbl[0]_17 nbl[1]_17 bl[1]_17 vddpe_17 vddce_17 vnwc_18 vpw_18
+  bl[2]_17 nbl[2]_17 bl[0]_16 nbl[0]_16 nbl[1]_16 bl[1]_16 vddpe_16 vddce_16
+  vddc_16 vnwc_17 vpw_17 bl[2]_16 nbl[2]_16 bl[0]_15 nbl[0]_15 nbl[1]_15
+  bl[1]_15 vddpe_15 vddce_15 vddc_15 vnwc_16 vpw_16 nbl[2]_15 bl[0]_14
+  nbl[0]_14 nbl[1]_14 bl[1]_14 vddpe_14 vddce_14 vddc_14 vnwc_15 vpw_15
+  nbl[2]_14 bl[0]_13 nbl[0]_13 nbl[1]_13 bl[1]_13 vddpe_13 vddce_13 vddc_13
+  vnwc_14 vpw_14 bl[0]_12 nbl[0]_12 nbl[1]_12 bl[1]_12 vddpe_12 vddce_12
+  vddc_12 vnwc_13 vpw_13 bl[0]_11 nbl[0]_11 nbl[1]_11 bl[1]_11 vddpe_11
+  vddce_11 vddc_11 vnwc_12 vpw_12 bl[2]_11 nbl[2]_11 bl[0]_10 nbl[0]_10
+  nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vddc_10 vnwc_11 vpw_11 nbl[2]_10
+  bl[0]_9 nbl[0]_9 nbl[1]_9 bl[1]_9 vddpe_9 vddce_9 vddc_9 vnwc_10 vpw_10
+  nbl[2]_9 bl[0]_8 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 vddce_8 vddc_8 vnwc_9
+  vpw_9 bl[0]_7 nbl[0]_7 nbl[1]_7 bl[1]_7 vddpe_7 vddce_7 vddc_7 vnwc_8 vpw_8
+  bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddpe_6 vddce_6 vddc_6 vnwc_7 vpw_7
+  bl[3]_6 bl[0]_5 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe_5 vddce_5 vddc_5 vnwc_6
+  vpw_6 nbl[2]_5 bl[0]_4 nbl[0]_4 nbl[1]_4 bl[1]_4 vddpe_4 vddce_4 vddc_4
+  vnwc_5 vpw_5 nbl[2]_4 bl[0]_3 nbl[0]_3 nbl[1]_3 bl[1]_3 vddpe_3 vddce_3
+  vddc_3 vnwc_4 vpw_4 bl[0]_2 nbl[0]_2 nbl[1]_2 bl[1]_2 vddpe_2 vddce_2
+  vddc_2 vnwc_3 vpw_3 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddpe_1 vddce_1
+  vddc_1 vnwc_2 vpw_2 bl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe_0
+  vddce_0 vddc_0 vnwc_1 vpw_1 bl[3]_0 vnwc_0 vpw_0 vnwc_33 vnwp_1 dbl dwl
+  bl[0]_31 nbl[0]_31 nbl[1]_31 bl[1]_31 vddpe_31 vddce_31 vpw_32 bl[0]_30
+  nbl[0]_30 nbl[1]_30 vddce_30 vddc_30 vnwc_31 vpw_31 bl[3]_30 bl[0]_29
+  nbl[0]_29 nbl[1]_29 vddce_29 vddc_29 vnwc_30 vpw_30 nbl[3]_29 bl[3]_29
+  bl[0]_28 nbl[0]_28 nbl[1]_28 vddce_28 vddc_28 vnwc_29 vpw_29 nbl[3]_28
+  bl[3]_28 bl[0]_27 nbl[0]_27 nbl[1]_27 vddce_27 vddc_27 vnwc_28 vpw_28
+  nbl[3]_27 bl[3]_27 nbl[0]_26 nbl[1]_26 vddce_26 vddc_26 vnwc_27 vpw_27
+  bl[2]_26 bl[3]_26 nbl[0]_25 nbl[1]_25 vddc_25 vpw_26 bl[2]_25 bl[3]_25
+  vddc_24 bl[3]_24 vddc_23 nbl[3]_23 bl[3]_23 vddc_22 nbl[3]_22 bl[3]_22
+  nbl[3]_21 bl[3]_21 bl[2]_20 nbl[3]_20 bl[3]_20 bl[2]_19 nbl[2]_19 nbl[3]_19
+  bl[3]_19 vddc_18 nbl[3]_18 bl[3]_18 vddc_17 nbl[3]_17 bl[3]_17 nbl[3]_16
+  bl[3]_16 bl[2]_15 nbl[3]_15 bl[3]_15 bl[2]_14 nbl[3]_14 bl[3]_14 bl[2]_13
+  nbl[2]_13 nbl[3]_13 bl[3]_13 bl[2]_12 nbl[2]_12 nbl[3]_12 bl[3]_12
+  nbl[3]_11 bl[3]_11 bl[2]_10 nbl[3]_10 bl[3]_10 bl[2]_9 nbl[3]_9 bl[3]_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[2]_6
+  nbl[2]_6 nbl[3]_6 bl[2]_5 nbl[3]_5 bl[3]_5 bl[2]_4 nbl[3]_4 bl[3]_4 bl[2]_3
+  nbl[2]_3 nbl[3]_3 bl[3]_3 bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[2]_1
+  nbl[2]_1 nbl[3]_1 bl[2]_0 nbl[2]_0 nbl[3]_0 vnwp_0 wl[0] wl[1]
** rf64x128mem_l_test9row: 1548 flat devices **
xmem_l_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0 ncored00_320 ncored01_322 ncored10_324
+  ncored11_326 ncored20_328 ncored21_330 ncored30_332 ncored31_334 vddc_0
+  vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_1 nbl[1]_1 nbl[2]_1 nbl[3]_1 ncored00_352 ncored01_354 ncored10_356
+  ncored11_358 ncored20_360 ncored21_362 ncored30_364 ncored31_366 vddc_1
+  vddce_1 vddpe_1 vnwc_2 vpw_2 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_624 cored01_626
+  cored10_628 cored11_630 cored20_632 cored21_634 cored30_636 cored31_638
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_640 ncored01_642
+  ncored10_644 ncored11_646 ncored20_648 ncored21_650 ncored30_652
+  ncored31_654 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_656 cored01_658
+  cored10_660 cored11_662 cored20_664 cored21_666 cored30_668 cored31_670
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_672 ncored01_674
+  ncored10_676 ncored11_678 ncored20_680 ncored21_682 ncored30_684
+  ncored31_686 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_12 bl[0]_12 bl[1]_12 bl[2]_12 bl[3]_12 cored00_688 cored01_690
+  cored10_692 cored11_694 cored20_696 cored21_698 cored30_700 cored31_702
+  nbl[0]_12 nbl[1]_12 nbl[2]_12 nbl[3]_12 ncored00_704 ncored01_706
+  ncored10_708 ncored11_710 ncored20_712 ncored21_714 ncored30_716
+  ncored31_718 vddc_12 vddce_12 vddpe_12 vnwc_13 vpw_13 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_13 bl[0]_13 bl[1]_13 bl[2]_13 bl[3]_13 cored00_752 cored01_754
+  cored10_756 cored11_758 cored20_760 cored21_762 cored30_764 cored31_766
+  nbl[0]_13 nbl[1]_13 nbl[2]_13 nbl[3]_13 ncored00_768 ncored01_770
+  ncored10_772 ncored11_774 ncored20_776 ncored21_778 ncored30_780
+  ncored31_782 vddc_13 vddce_13 vddpe_13 vnwc_14 vpw_14 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_14 bl[0]_14 bl[1]_14 bl[2]_14 bl[3]_14 cored00_816 cored01_818
+  cored10_820 cored11_822 cored20_824 cored21_826 cored30_828 cored31_830
+  nbl[0]_14 nbl[1]_14 nbl[2]_14 nbl[3]_14 ncored00_832 ncored01_834
+  ncored10_836 ncored11_838 ncored20_840 ncored21_842 ncored30_844
+  ncored31_846 vddc_14 vddce_14 vddpe_14 vnwc_15 vpw_15 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_15 bl[0]_15 bl[1]_15 bl[2]_15 bl[3]_15 cored00_848 cored01_850
+  cored10_852 cored11_854 cored20_856 cored21_858 cored30_860 cored31_862
+  nbl[0]_15 nbl[1]_15 nbl[2]_15 nbl[3]_15 ncored00_864 ncored01_866
+  ncored10_868 ncored11_870 ncored20_872 ncored21_874 ncored30_876
+  ncored31_878 vddc_15 vddce_15 vddpe_15 vnwc_16 vpw_16 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_16 bl[0]_16 bl[1]_16 bl[2]_16 bl[3]_16 cored00_880 cored01_882
+  cored10_884 cored11_886 cored20_888 cored21_890 cored30_892 cored31_894
+  nbl[0]_16 nbl[1]_16 nbl[2]_16 nbl[3]_16 ncored00_896 ncored01_898
+  ncored10_900 ncored11_902 ncored20_904 ncored21_906 ncored30_908
+  ncored31_910 vddc_16 vddce_16 vddpe_16 vnwc_17 vpw_17 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_17 bl[0]_17 bl[1]_17 bl[2]_17 bl[3]_17 cored00_912 cored01_914
+  cored10_916 cored11_918 cored20_920 cored21_922 cored30_924 cored31_926
+  nbl[0]_17 nbl[1]_17 nbl[2]_17 nbl[3]_17 ncored00_928 ncored01_930
+  ncored10_932 ncored11_934 ncored20_936 ncored21_938 ncored30_940
+  ncored31_942 vddc_17 vddce_17 vddpe_17 vnwc_18 vpw_18 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_18 bl[0]_18 bl[1]_18 bl[2]_18 bl[3]_18 cored00_944 cored01_946
+  cored10_948 cored11_950 cored20_952 cored21_954 cored30_956 cored31_958
+  nbl[0]_18 nbl[1]_18 nbl[2]_18 nbl[3]_18 ncored00_960 ncored01_962
+  ncored10_964 ncored11_966 ncored20_968 ncored21_970 ncored30_972
+  ncored31_974 vddc_18 vddce_18 vddpe_18 vnwc_19 vpw_19 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_19 bl[0]_19 bl[1]_19 bl[2]_19 bl[3]_19 cored00_976 cored01_978
+  cored10_980 cored11_982 cored20_984 cored21_986 cored30_988 cored31_990
+  nbl[0]_19 nbl[1]_19 nbl[2]_19 nbl[3]_19 ncored00_992 ncored01_994
+  ncored10_996 ncored11_998 ncored20_1000 ncored21_1002 ncored30_1004
+  ncored31_1006 vddc_19 vddce_19 vddpe_19 vnwc_20 vpw_20 vssc vssc wl[1]
+  wl[0] rf64x128cchs4
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_368 cored01_370
+  cored10_372 cored11_374 cored20_376 cored21_378 cored30_380 cored31_382
+  nbl[0]_2 nbl[1]_2 nbl[2]_2 nbl[3]_2 ncored00_384 ncored01_386 ncored10_388
+  ncored11_390 ncored20_392 ncored21_394 ncored30_396 ncored31_398 vddc_2
+  vddce_2 vddpe_2 vnwc_3 vpw_3 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_20 bl[0]_20 bl[1]_20 bl[2]_20 bl[3]_20 cored00 cored01 cored10
+  cored11 cored20 cored21 cored30 cored31 nbl[0]_20 nbl[1]_20 nbl[2]_20
+  nbl[3]_20 ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30
+  ncored31 vddc_20 vddce_20 vddpe_20 vnwc_21 vpw_21 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_21 bl[0]_21 bl[1]_21 bl[2]_21 bl[3]_21 cored00_16 cored01_18
+  cored10_20 cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_21
+  nbl[1]_21 nbl[2]_21 nbl[3]_21 ncored00_32 ncored01_34 ncored10_36
+  ncored11_38 ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_21
+  vddce_21 vddpe_21 vnwc_22 vpw_22 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_22 bl[0]_22 bl[1]_22 bl[2]_22 bl[3]_22 cored00_48 cored01_50
+  cored10_52 cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_22
+  nbl[1]_22 nbl[2]_22 nbl[3]_22 ncored00_64 ncored01_66 ncored10_68
+  ncored11_70 ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_22
+  vddce_22 vddpe_22 vnwc_23 vpw_23 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_23 bl[0]_23 bl[1]_23 bl[2]_23 bl[3]_23 cored00_80 cored01_82
+  cored10_84 cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_23
+  nbl[1]_23 nbl[2]_23 nbl[3]_23 ncored00_96 ncored01_98 ncored10_100
+  ncored11_102 ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_23
+  vddce_23 vddpe_23 vnwc_24 vpw_24 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_24 bl[0]_24 bl[1]_24 bl[2]_24 bl[3]_24 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_24 nbl[1]_24 nbl[2]_24 nbl[3]_24 ncored00_128 ncored01_130
+  ncored10_132 ncored11_134 ncored20_136 ncored21_138 ncored30_140
+  ncored31_142 vddc_24 vddce_24 vddpe_24 vnwc_25 vpw_25 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_25 bl[0]_25 bl[1]_25 bl[2]_25 bl[3]_25 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_25 nbl[1]_25 nbl[2]_25 nbl[3]_25 ncored00_160 ncored01_162
+  ncored10_164 ncored11_166 ncored20_168 ncored21_170 ncored30_172
+  ncored31_174 vddc_25 vddce_25 vddpe_25 vnwc_26 vpw_26 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_26 bl[0]_26 bl[1]_26 bl[2]_26 bl[3]_26 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_26 nbl[1]_26 nbl[2]_26 nbl[3]_26 ncored00_192 ncored01_194
+  ncored10_196 ncored11_198 ncored20_200 ncored21_202 ncored30_204
+  ncored31_206 vddc_26 vddce_26 vddpe_26 vnwc_27 vpw_27 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_27 bl[0]_27 bl[1]_27 bl[2]_27 bl[3]_27 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_27 nbl[1]_27 nbl[2]_27 nbl[3]_27 ncored00_224 ncored01_226
+  ncored10_228 ncored11_230 ncored20_232 ncored21_234 ncored30_236
+  ncored31_238 vddc_27 vddce_27 vddpe_27 vnwc_28 vpw_28 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_28 bl[0]_28 bl[1]_28 bl[2]_28 bl[3]_28 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_28 nbl[1]_28 nbl[2]_28 nbl[3]_28 ncored00_256 ncored01_258
+  ncored10_260 ncored11_262 ncored20_264 ncored21_266 ncored30_268
+  ncored31_270 vddc_28 vddce_28 vddpe_28 vnwc_29 vpw_29 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_29 bl[0]_29 bl[1]_29 bl[2]_29 bl[3]_29 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_29 nbl[1]_29 nbl[2]_29 nbl[3]_29 ncored00_288 ncored01_290
+  ncored10_292 ncored11_294 ncored20_296 ncored21_298 ncored30_300
+  ncored31_302 vddc_29 vddce_29 vddpe_29 vnwc_30 vpw_30 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_400 cored01_402
+  cored10_404 cored11_406 cored20_408 cored21_410 cored30_412 cored31_414
+  nbl[0]_3 nbl[1]_3 nbl[2]_3 nbl[3]_3 ncored00_416 ncored01_418 ncored10_420
+  ncored11_422 ncored20_424 ncored21_426 ncored30_428 ncored31_430 vddc_3
+  vddce_3 vddpe_3 vnwc_4 vpw_4 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_30 bl[0]_30 bl[1]_30 bl[2]_30 bl[3]_30 cored00_720 cored01_722
+  cored10_724 cored11_726 cored20_728 cored21_730 cored30_732 cored31_734
+  nbl[0]_30 nbl[1]_30 nbl[2]_30 nbl[3]_30 ncored00_736 ncored01_738
+  ncored10_740 ncored11_742 ncored20_744 ncored21_746 ncored30_748
+  ncored31_750 vddc_30 vddce_30 vddpe_30 vnwc_31 vpw_31 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_31 bl[0]_31 bl[1]_31 bl[2]_31 bl[3]_31 cored00_784 cored01_786
+  cored10_788 cored11_790 cored20_792 cored21_794 cored30_796 cored31_798
+  nbl[0]_31 nbl[1]_31 nbl[2]_31 nbl[3]_31 ncored00_800 ncored01_802
+  ncored10_804 ncored11_806 ncored20_808 ncored21_810 ncored30_812
+  ncored31_814 vddc_31 vddce_31 vddpe_31 vnwc_32 vpw_32 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_432 cored01_434
+  cored10_436 cored11_438 cored20_440 cored21_442 cored30_444 cored31_446
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_448 ncored01_450 ncored10_452
+  ncored11_454 ncored20_456 ncored21_458 ncored30_460 ncored31_462 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_464 cored01_466
+  cored10_468 cored11_470 cored20_472 cored21_474 cored30_476 cored31_478
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_480 ncored01_482 ncored10_484
+  ncored11_486 ncored20_488 ncored21_490 ncored30_492 ncored31_494 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_496 cored01_498
+  cored10_500 cored11_502 cored20_504 cored21_506 cored30_508 cored31_510
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_512 ncored01_514 ncored10_516
+  ncored11_518 ncored20_520 ncored21_522 ncored30_524 ncored31_526 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_528 cored01_530
+  cored10_532 cored11_534 cored20_536 cored21_538 cored30_540 cored31_542
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_544 ncored01_546 ncored10_548
+  ncored11_550 ncored20_552 ncored21_554 ncored30_556 ncored31_558 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_560 cored01_562
+  cored10_564 cored11_566 cored20_568 cored21_570 cored30_572 cored31_574
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_576 ncored01_578 ncored10_580
+  ncored11_582 ncored20_584 ncored21_586 ncored30_588 ncored31_590 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_592 cored01_594
+  cored10_596 cored11_598 cored20_600 cored21_602 cored30_604 cored31_606
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_608 ncored01_610 ncored10_612
+  ncored11_614 ncored20_616 ncored21_618 ncored30_620 ncored31_622 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_edger dbl dwl vddc_32 vnwc_33 vnwp_1 vpw_33 vssc wl[0] wl[1]
+  rf64x128cchs4wd_edgbl_dummy
.ends rf64x128mem_l_test9row
****
.subckt rf64x128mem_l_midb_row vddc_32 vnwc_33 dbl dwl vnwc_32 bl[2]_31
+  nbl[2]_31 nbl[3]_31 bl[3]_31 bl[1]_30 vddpe_30 bl[2]_30 nbl[2]_30 nbl[3]_30
+  bl[1]_29 vddpe_29 bl[2]_29 nbl[2]_29 bl[1]_28 vddpe_28 bl[2]_28 nbl[2]_28
+  bl[1]_27 vddpe_27 bl[2]_27 nbl[2]_27 bl[0]_26 bl[1]_26 vddpe_26 nbl[2]_26
+  nbl[3]_26 bl[0]_25 bl[1]_25 vddpe_25 vddce_25 vnwc_26 vssc nbl[2]_25
+  nbl[3]_25 bl[0]_24 nbl[0]_24 nbl[1]_24 bl[1]_24 vddpe_24 vddce_24 vnwc_25
+  vpw_25 bl[2]_24 nbl[2]_24 nbl[3]_24 bl[0]_23 nbl[0]_23 nbl[1]_23 bl[1]_23
+  vddpe_23 vddce_23 vnwc_24 vpw_24 bl[2]_23 nbl[2]_23 bl[0]_22 nbl[0]_22
+  nbl[1]_22 bl[1]_22 vddpe_22 vddce_22 vnwc_23 vpw_23 bl[2]_22 nbl[2]_22
+  bl[0]_21 nbl[0]_21 nbl[1]_21 bl[1]_21 vddpe_21 vddce_21 vddc_21 vnwc_22
+  vpw_22 bl[2]_21 nbl[2]_21 bl[0]_20 nbl[0]_20 nbl[1]_20 bl[1]_20 vddpe_20
+  vddce_20 vddc_20 vnwc_21 vpw_21 nbl[2]_20 bl[0]_19 nbl[0]_19 nbl[1]_19
+  bl[1]_19 vddpe_19 vddce_19 vddc_19 vnwc_20 vpw_20 bl[0]_18 nbl[0]_18
+  nbl[1]_18 bl[1]_18 vddpe_18 vddce_18 vnwc_19 vpw_19 bl[2]_18 nbl[2]_18
+  bl[0]_17 nbl[0]_17 nbl[1]_17 bl[1]_17 vddpe_17 vddce_17 vnwc_18 vpw_18
+  bl[2]_17 nbl[2]_17 bl[0]_16 nbl[0]_16 nbl[1]_16 bl[1]_16 vddpe_16 vddce_16
+  vddc_16 vnwc_17 vpw_17 bl[2]_16 nbl[2]_16 bl[0]_15 nbl[0]_15 nbl[1]_15
+  bl[1]_15 vddpe_15 vddce_15 vddc_15 vnwc_16 vpw_16 nbl[2]_15 bl[0]_14
+  nbl[0]_14 nbl[1]_14 bl[1]_14 vddpe_14 vddce_14 vddc_14 vnwc_15 vpw_15
+  nbl[2]_14 bl[0]_13 nbl[0]_13 nbl[1]_13 bl[1]_13 vddpe_13 vddce_13 vddc_13
+  vnwc_14 vpw_14 bl[0]_12 nbl[0]_12 nbl[1]_12 bl[1]_12 vddpe_12 vddce_12
+  vddc_12 vnwc_13 vpw_13 bl[0]_11 nbl[0]_11 nbl[1]_11 bl[1]_11 vddpe_11
+  vddce_11 vddc_11 vnwc_12 vpw_12 bl[2]_11 nbl[2]_11 bl[0]_10 nbl[0]_10
+  nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vddc_10 vnwc_11 vpw_11 nbl[2]_10
+  bl[0]_9 nbl[0]_9 nbl[1]_9 bl[1]_9 vddpe_9 vddce_9 vddc_9 vnwc_10 vpw_10
+  nbl[2]_9 bl[0]_8 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 vddce_8 vddc_8 vnwc_9
+  vpw_9 bl[0]_7 nbl[0]_7 nbl[1]_7 bl[1]_7 vddpe_7 vddce_7 vddc_7 vnwc_8 vpw_8
+  bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddpe_6 vddce_6 vddc_6 vnwc_7 vpw_7
+  bl[3]_6 bl[0]_5 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe_5 vddce_5 vddc_5 vnwc_6
+  vpw_6 nbl[2]_5 bl[0]_4 nbl[0]_4 nbl[1]_4 bl[1]_4 vddpe_4 vddce_4 vddc_4
+  vnwc_5 vpw_5 nbl[2]_4 bl[0]_3 nbl[0]_3 nbl[1]_3 bl[1]_3 vddpe_3 vddce_3
+  vddc_3 vnwc_4 vpw_4 bl[0]_2 nbl[0]_2 nbl[1]_2 bl[1]_2 vddpe_2 vddce_2
+  vddc_2 vnwc_3 vpw_3 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddpe_1 vddce_1
+  vddc_1 vnwc_2 vpw_2 bl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe_0
+  vddce_0 vddc_0 vnwc_1 vpw_1 bl[3]_0 vnwp_0 vnwc_0 vpw_0 vpw_33 vnwp_1
+  bl[0]_31 nbl[0]_31 nbl[1]_31 bl[1]_31 vddpe_31 vddce_31 vddc_31 vpw_32
+  bl[0]_30 nbl[0]_30 nbl[1]_30 vddce_30 vddc_30 vnwc_31 vpw_31 bl[3]_30
+  bl[0]_29 nbl[0]_29 nbl[1]_29 vddce_29 vddc_29 vnwc_30 vpw_30 nbl[3]_29
+  bl[3]_29 bl[0]_28 nbl[0]_28 nbl[1]_28 vddce_28 vddc_28 vnwc_29 vpw_29
+  nbl[3]_28 bl[3]_28 bl[0]_27 nbl[0]_27 nbl[1]_27 vddce_27 vddc_27 vnwc_28
+  vpw_28 nbl[3]_27 bl[3]_27 nbl[0]_26 nbl[1]_26 vddce_26 vddc_26 vnwc_27
+  vpw_27 bl[2]_26 bl[3]_26 nbl[0]_25 nbl[1]_25 vddc_25 vpw_26 bl[2]_25
+  bl[3]_25 vddc_24 bl[3]_24 vddc_23 nbl[3]_23 bl[3]_23 vddc_22 nbl[3]_22
+  bl[3]_22 nbl[3]_21 bl[3]_21 bl[2]_20 nbl[3]_20 bl[3]_20 bl[2]_19 nbl[2]_19
+  nbl[3]_19 bl[3]_19 vddc_18 nbl[3]_18 bl[3]_18 vddc_17 nbl[3]_17 bl[3]_17
+  nbl[3]_16 bl[3]_16 bl[2]_15 nbl[3]_15 bl[3]_15 bl[2]_14 nbl[3]_14 bl[3]_14
+  bl[2]_13 nbl[2]_13 nbl[3]_13 bl[3]_13 bl[2]_12 nbl[2]_12 nbl[3]_12 bl[3]_12
+  nbl[3]_11 bl[3]_11 bl[2]_10 nbl[3]_10 bl[3]_10 bl[2]_9 nbl[3]_9 bl[3]_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[2]_6
+  nbl[2]_6 nbl[3]_6 bl[2]_5 nbl[3]_5 bl[3]_5 bl[2]_4 nbl[3]_4 bl[3]_4 bl[2]_3
+  nbl[2]_3 nbl[3]_3 bl[3]_3 bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[2]_1
+  nbl[2]_1 nbl[3]_1 bl[2]_0 nbl[2]_0 nbl[3]_0 wl[1] wl[0]
** rf64x128mem_l_midb_row: 1548 flat devices **
xmem_l_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0 ncored00_320 ncored01_322 ncored10_324
+  ncored11_326 ncored20_328 ncored21_330 ncored30_332 ncored31_334 vddc_0
+  vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_1 nbl[1]_1 nbl[2]_1 nbl[3]_1 ncored00_352 ncored01_354 ncored10_356
+  ncored11_358 ncored20_360 ncored21_362 ncored30_364 ncored31_366 vddc_1
+  vddce_1 vddpe_1 vnwc_2 vpw_2 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_624 cored01_626
+  cored10_628 cored11_630 cored20_632 cored21_634 cored30_636 cored31_638
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_640 ncored01_642
+  ncored10_644 ncored11_646 ncored20_648 ncored21_650 ncored30_652
+  ncored31_654 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_656 cored01_658
+  cored10_660 cored11_662 cored20_664 cored21_666 cored30_668 cored31_670
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_672 ncored01_674
+  ncored10_676 ncored11_678 ncored20_680 ncored21_682 ncored30_684
+  ncored31_686 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_12 bl[0]_12 bl[1]_12 bl[2]_12 bl[3]_12 cored00_688 cored01_690
+  cored10_692 cored11_694 cored20_696 cored21_698 cored30_700 cored31_702
+  nbl[0]_12 nbl[1]_12 nbl[2]_12 nbl[3]_12 ncored00_704 ncored01_706
+  ncored10_708 ncored11_710 ncored20_712 ncored21_714 ncored30_716
+  ncored31_718 vddc_12 vddce_12 vddpe_12 vnwc_13 vpw_13 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_13 bl[0]_13 bl[1]_13 bl[2]_13 bl[3]_13 cored00_752 cored01_754
+  cored10_756 cored11_758 cored20_760 cored21_762 cored30_764 cored31_766
+  nbl[0]_13 nbl[1]_13 nbl[2]_13 nbl[3]_13 ncored00_768 ncored01_770
+  ncored10_772 ncored11_774 ncored20_776 ncored21_778 ncored30_780
+  ncored31_782 vddc_13 vddce_13 vddpe_13 vnwc_14 vpw_14 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_14 bl[0]_14 bl[1]_14 bl[2]_14 bl[3]_14 cored00_816 cored01_818
+  cored10_820 cored11_822 cored20_824 cored21_826 cored30_828 cored31_830
+  nbl[0]_14 nbl[1]_14 nbl[2]_14 nbl[3]_14 ncored00_832 ncored01_834
+  ncored10_836 ncored11_838 ncored20_840 ncored21_842 ncored30_844
+  ncored31_846 vddc_14 vddce_14 vddpe_14 vnwc_15 vpw_15 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_15 bl[0]_15 bl[1]_15 bl[2]_15 bl[3]_15 cored00_848 cored01_850
+  cored10_852 cored11_854 cored20_856 cored21_858 cored30_860 cored31_862
+  nbl[0]_15 nbl[1]_15 nbl[2]_15 nbl[3]_15 ncored00_864 ncored01_866
+  ncored10_868 ncored11_870 ncored20_872 ncored21_874 ncored30_876
+  ncored31_878 vddc_15 vddce_15 vddpe_15 vnwc_16 vpw_16 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_16 bl[0]_16 bl[1]_16 bl[2]_16 bl[3]_16 cored00_880 cored01_882
+  cored10_884 cored11_886 cored20_888 cored21_890 cored30_892 cored31_894
+  nbl[0]_16 nbl[1]_16 nbl[2]_16 nbl[3]_16 ncored00_896 ncored01_898
+  ncored10_900 ncored11_902 ncored20_904 ncored21_906 ncored30_908
+  ncored31_910 vddc_16 vddce_16 vddpe_16 vnwc_17 vpw_17 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_17 bl[0]_17 bl[1]_17 bl[2]_17 bl[3]_17 cored00_912 cored01_914
+  cored10_916 cored11_918 cored20_920 cored21_922 cored30_924 cored31_926
+  nbl[0]_17 nbl[1]_17 nbl[2]_17 nbl[3]_17 ncored00_928 ncored01_930
+  ncored10_932 ncored11_934 ncored20_936 ncored21_938 ncored30_940
+  ncored31_942 vddc_17 vddce_17 vddpe_17 vnwc_18 vpw_18 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_18 bl[0]_18 bl[1]_18 bl[2]_18 bl[3]_18 cored00_944 cored01_946
+  cored10_948 cored11_950 cored20_952 cored21_954 cored30_956 cored31_958
+  nbl[0]_18 nbl[1]_18 nbl[2]_18 nbl[3]_18 ncored00_960 ncored01_962
+  ncored10_964 ncored11_966 ncored20_968 ncored21_970 ncored30_972
+  ncored31_974 vddc_18 vddce_18 vddpe_18 vnwc_19 vpw_19 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_19 bl[0]_19 bl[1]_19 bl[2]_19 bl[3]_19 cored00_976 cored01_978
+  cored10_980 cored11_982 cored20_984 cored21_986 cored30_988 cored31_990
+  nbl[0]_19 nbl[1]_19 nbl[2]_19 nbl[3]_19 ncored00_992 ncored01_994
+  ncored10_996 ncored11_998 ncored20_1000 ncored21_1002 ncored30_1004
+  ncored31_1006 vddc_19 vddce_19 vddpe_19 vnwc_20 vpw_20 vssc vssc wl[0]
+  wl[1] rf64x128cchs4
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_368 cored01_370
+  cored10_372 cored11_374 cored20_376 cored21_378 cored30_380 cored31_382
+  nbl[0]_2 nbl[1]_2 nbl[2]_2 nbl[3]_2 ncored00_384 ncored01_386 ncored10_388
+  ncored11_390 ncored20_392 ncored21_394 ncored30_396 ncored31_398 vddc_2
+  vddce_2 vddpe_2 vnwc_3 vpw_3 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_20 bl[0]_20 bl[1]_20 bl[2]_20 bl[3]_20 cored00 cored01 cored10
+  cored11 cored20 cored21 cored30 cored31 nbl[0]_20 nbl[1]_20 nbl[2]_20
+  nbl[3]_20 ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30
+  ncored31 vddc_20 vddce_20 vddpe_20 vnwc_21 vpw_21 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_21 bl[0]_21 bl[1]_21 bl[2]_21 bl[3]_21 cored00_16 cored01_18
+  cored10_20 cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_21
+  nbl[1]_21 nbl[2]_21 nbl[3]_21 ncored00_32 ncored01_34 ncored10_36
+  ncored11_38 ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_21
+  vddce_21 vddpe_21 vnwc_22 vpw_22 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_22 bl[0]_22 bl[1]_22 bl[2]_22 bl[3]_22 cored00_48 cored01_50
+  cored10_52 cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_22
+  nbl[1]_22 nbl[2]_22 nbl[3]_22 ncored00_64 ncored01_66 ncored10_68
+  ncored11_70 ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_22
+  vddce_22 vddpe_22 vnwc_23 vpw_23 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_23 bl[0]_23 bl[1]_23 bl[2]_23 bl[3]_23 cored00_80 cored01_82
+  cored10_84 cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_23
+  nbl[1]_23 nbl[2]_23 nbl[3]_23 ncored00_96 ncored01_98 ncored10_100
+  ncored11_102 ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_23
+  vddce_23 vddpe_23 vnwc_24 vpw_24 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_24 bl[0]_24 bl[1]_24 bl[2]_24 bl[3]_24 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_24 nbl[1]_24 nbl[2]_24 nbl[3]_24 ncored00_128 ncored01_130
+  ncored10_132 ncored11_134 ncored20_136 ncored21_138 ncored30_140
+  ncored31_142 vddc_24 vddce_24 vddpe_24 vnwc_25 vpw_25 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_25 bl[0]_25 bl[1]_25 bl[2]_25 bl[3]_25 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_25 nbl[1]_25 nbl[2]_25 nbl[3]_25 ncored00_160 ncored01_162
+  ncored10_164 ncored11_166 ncored20_168 ncored21_170 ncored30_172
+  ncored31_174 vddc_25 vddce_25 vddpe_25 vnwc_26 vpw_26 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_26 bl[0]_26 bl[1]_26 bl[2]_26 bl[3]_26 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_26 nbl[1]_26 nbl[2]_26 nbl[3]_26 ncored00_192 ncored01_194
+  ncored10_196 ncored11_198 ncored20_200 ncored21_202 ncored30_204
+  ncored31_206 vddc_26 vddce_26 vddpe_26 vnwc_27 vpw_27 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_27 bl[0]_27 bl[1]_27 bl[2]_27 bl[3]_27 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_27 nbl[1]_27 nbl[2]_27 nbl[3]_27 ncored00_224 ncored01_226
+  ncored10_228 ncored11_230 ncored20_232 ncored21_234 ncored30_236
+  ncored31_238 vddc_27 vddce_27 vddpe_27 vnwc_28 vpw_28 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_28 bl[0]_28 bl[1]_28 bl[2]_28 bl[3]_28 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_28 nbl[1]_28 nbl[2]_28 nbl[3]_28 ncored00_256 ncored01_258
+  ncored10_260 ncored11_262 ncored20_264 ncored21_266 ncored30_268
+  ncored31_270 vddc_28 vddce_28 vddpe_28 vnwc_29 vpw_29 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_29 bl[0]_29 bl[1]_29 bl[2]_29 bl[3]_29 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_29 nbl[1]_29 nbl[2]_29 nbl[3]_29 ncored00_288 ncored01_290
+  ncored10_292 ncored11_294 ncored20_296 ncored21_298 ncored30_300
+  ncored31_302 vddc_29 vddce_29 vddpe_29 vnwc_30 vpw_30 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_400 cored01_402
+  cored10_404 cored11_406 cored20_408 cored21_410 cored30_412 cored31_414
+  nbl[0]_3 nbl[1]_3 nbl[2]_3 nbl[3]_3 ncored00_416 ncored01_418 ncored10_420
+  ncored11_422 ncored20_424 ncored21_426 ncored30_428 ncored31_430 vddc_3
+  vddce_3 vddpe_3 vnwc_4 vpw_4 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_30 bl[0]_30 bl[1]_30 bl[2]_30 bl[3]_30 cored00_720 cored01_722
+  cored10_724 cored11_726 cored20_728 cored21_730 cored30_732 cored31_734
+  nbl[0]_30 nbl[1]_30 nbl[2]_30 nbl[3]_30 ncored00_736 ncored01_738
+  ncored10_740 ncored11_742 ncored20_744 ncored21_746 ncored30_748
+  ncored31_750 vddc_30 vddce_30 vddpe_30 vnwc_31 vpw_31 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_31 bl[0]_31 bl[1]_31 bl[2]_31 bl[3]_31 cored00_784 cored01_786
+  cored10_788 cored11_790 cored20_792 cored21_794 cored30_796 cored31_798
+  nbl[0]_31 nbl[1]_31 nbl[2]_31 nbl[3]_31 ncored00_800 ncored01_802
+  ncored10_804 ncored11_806 ncored20_808 ncored21_810 ncored30_812
+  ncored31_814 vddc_31 vddce_31 vddpe_31 vnwc_32 vpw_32 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_432 cored01_434
+  cored10_436 cored11_438 cored20_440 cored21_442 cored30_444 cored31_446
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_448 ncored01_450 ncored10_452
+  ncored11_454 ncored20_456 ncored21_458 ncored30_460 ncored31_462 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_464 cored01_466
+  cored10_468 cored11_470 cored20_472 cored21_474 cored30_476 cored31_478
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_480 ncored01_482 ncored10_484
+  ncored11_486 ncored20_488 ncored21_490 ncored30_492 ncored31_494 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_496 cored01_498
+  cored10_500 cored11_502 cored20_504 cored21_506 cored30_508 cored31_510
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_512 ncored01_514 ncored10_516
+  ncored11_518 ncored20_520 ncored21_522 ncored30_524 ncored31_526 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_528 cored01_530
+  cored10_532 cored11_534 cored20_536 cored21_538 cored30_540 cored31_542
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_544 ncored01_546 ncored10_548
+  ncored11_550 ncored20_552 ncored21_554 ncored30_556 ncored31_558 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_560 cored01_562
+  cored10_564 cored11_566 cored20_568 cored21_570 cored30_572 cored31_574
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_576 ncored01_578 ncored10_580
+  ncored11_582 ncored20_584 ncored21_586 ncored30_588 ncored31_590 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_592 cored01_594
+  cored10_596 cored11_598 cored20_600 cored21_602 cored30_604 cored31_606
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_608 ncored01_610 ncored10_612
+  ncored11_614 ncored20_616 ncored21_618 ncored30_620 ncored31_622 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_edger dbl dwl vddc_32 vnwc_33 vnwp_1 vpw_33 vssc wl[0] wl[1]
+  rf64x128cchs4wd_edgbl_dummy
.ends rf64x128mem_l_midb_row
****
.subckt rf64x128memcore_l vnwc bl[2]_31 bl[2]_30 nbl[2]_30 nbl[3]_30 bl[2]_29
+  nbl[2]_29 bl[1]_28 bl[2]_28 nbl[2]_28 nbl[3]_28 bl[1]_27 bl[2]_27 nbl[2]_27
+  nbl[3]_27 bl[1]_26 nbl[2]_26 nbl[3]_26 bl[1]_25 bl[2]_25 nbl[2]_25
+  nbl[3]_25 nbl[1]_24 bl[1]_24 bl[2]_24 nbl[2]_24 nbl[1]_23 bl[1]_23 vssc
+  bl[2]_23 nbl[2]_23 bl[0]_22 nbl[1]_22 bl[1]_22 nbl[2]_22 bl[0]_21 nbl[0]_21
+  nbl[1]_21 bl[1]_21 nbl[2]_21 bl[0]_20 nbl[0]_20 nbl[1]_20 bl[1]_20 bl[0]_19
+  nbl[0]_19 nbl[1]_19 bl[1]_19 bl[2]_19 nbl[2]_19 nbl[1]_18 bl[1]_18 bl[2]_18
+  nbl[2]_18 bl[0]_17 nbl[1]_17 bl[1]_17 nbl[2]_17 bl[0]_16 nbl[0]_16
+  nbl[1]_16 bl[1]_16 nbl[2]_16 bl[0]_15 nbl[0]_15 nbl[1]_15 bl[1]_15 bl[0]_14
+  nbl[0]_14 nbl[1]_14 bl[1]_14 nbl[2]_14 bl[3]_14 bl[0]_13 nbl[0]_13
+  nbl[1]_13 bl[1]_13 bl[2]_13 nbl[2]_13 bl[3]_13 bl[0]_12 nbl[0]_12 nbl[1]_12
+  bl[1]_12 nbl[2]_12 bl[0]_11 nbl[1]_11 bl[1]_11 vddc bl[0]_10 nbl[0]_10
+  nbl[1]_10 bl[1]_10 bl[0]_9 nbl[0]_9 nbl[1]_9 bl[1]_9 bl[3]_9 bl[0]_8
+  nbl[0]_8 nbl[1]_8 bl[1]_8 nbl[2]_8 bl[3]_8 bl[0]_7 nbl[0]_7 nbl[1]_7
+  bl[1]_7 nbl[2]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 nbl[3]_6 bl[3]_6
+  bl[0]_5 nbl[0]_5 nbl[1]_5 bl[1]_5 bl[0]_4 nbl[0]_4 nbl[1]_4 bl[1]_4 bl[0]_3
+  nbl[0]_3 nbl[1]_3 bl[1]_3 bl[3]_3 bl[0]_2 nbl[0]_2 nbl[1]_2 bl[1]_2 bl[3]_2
+  bl[0]_1 bl[1]_1 nbl[3]_1 bl[3]_1 bl[0]_0 bl[1]_0 bl[3]_0 vnwp_0 vnwp_1 dbl
+  dwl bl[0]_31 nbl[0]_31 nbl[1]_31 bl[1]_31 nbl[2]_31 nbl[3]_31 bl[3]_31
+  bl[0]_30 nbl[0]_30 nbl[1]_30 bl[1]_30 bl[3]_30 bl[0]_29 nbl[0]_29 nbl[1]_29
+  bl[1]_29 nbl[3]_29 bl[3]_29 bl[0]_28 nbl[0]_28 nbl[1]_28 bl[3]_28 bl[0]_27
+  nbl[0]_27 nbl[1]_27 bl[3]_27 bl[0]_26 nbl[0]_26 nbl[1]_26 bl[2]_26 bl[3]_26
+  bl[0]_25 nbl[0]_25 nbl[1]_25 bl[3]_25 bl[0]_24 nbl[0]_24 nbl[3]_24 bl[3]_24
+  bl[0]_23 nbl[0]_23 nbl[3]_23 bl[3]_23 nbl[0]_22 bl[2]_22 nbl[3]_22 bl[3]_22
+  bl[2]_21 nbl[3]_21 bl[3]_21 bl[2]_20 nbl[2]_20 nbl[3]_20 bl[3]_20 nbl[3]_19
+  bl[3]_19 bl[0]_18 nbl[0]_18 nbl[3]_18 bl[3]_18 nbl[0]_17 bl[2]_17 nbl[3]_17
+  bl[3]_17 bl[2]_16 nbl[3]_16 bl[3]_16 bl[2]_15 nbl[2]_15 nbl[3]_15 bl[3]_15
+  vpw bl[2]_14 nbl[3]_14 nbl[3]_13 bl[2]_12 nbl[3]_12 bl[3]_12 nbl[0]_11
+  bl[2]_11 nbl[2]_11 nbl[3]_11 bl[3]_11 bl[2]_10 nbl[2]_10 nbl[3]_10 bl[3]_10
+  bl[2]_9 nbl[2]_9 nbl[3]_9 vddpe bl[2]_8 nbl[3]_8 bl[2]_7 nbl[3]_7 bl[2]_6
+  nbl[2]_6 bl[2]_5 nbl[2]_5 nbl[3]_5 bl[3]_5 bl[2]_4 nbl[2]_4 nbl[3]_4
+  bl[3]_4 bl[2]_3 nbl[2]_3 nbl[3]_3 bl[2]_2 nbl[2]_2 nbl[3]_2 nbl[0]_1
+  nbl[1]_1 bl[2]_1 nbl[2]_1 nbl[0]_0 nbl[1]_0 bl[2]_0 nbl[2]_0 nbl[3]_0
+  wl[1]_15 wl[0]_15 wl[0]_14 wl[1]_14 wl[1]_13 wl[0]_13 wl[0]_12 wl[1]_12
+  wl[1]_11 wl[0]_11 wl[1]_10 wl[0]_10 wl[0]_9 wl[1]_9 wl[1]_8 wl[0]_8 wl[0]_7
+  wl[1]_7 wl[1]_6 wl[0]_6 wl[0]_5 wl[1]_5 wl[1]_4 wl[0]_4 wl[0]_3 wl[1]_3
+  wl[1]_2 wl[0]_2 wl[0]_1 wl[1]_1 wl[1]_0 wl[0]_0 actp vss
** rf64x128memcore_l: 24768 flat devices **
xmem_l_row_1 vddc vpw vddc vnwc bl[2]_31 nbl[2]_31 nbl[3]_31 bl[3]_31 bl[1]_30
+  vddpe bl[2]_30 nbl[2]_30 nbl[3]_30 bl[1]_29 vddpe bl[2]_29 nbl[2]_29
+  bl[1]_28 vddpe bl[2]_28 nbl[2]_28 bl[1]_27 vddpe bl[2]_27 nbl[2]_27
+  bl[0]_26 bl[1]_26 vddpe nbl[2]_26 nbl[3]_26 bl[0]_25 bl[1]_25 vddpe vddc
+  vnwc vssc nbl[2]_25 nbl[3]_25 bl[0]_24 nbl[0]_24 nbl[1]_24 bl[1]_24 vddpe
+  vddc vnwc vpw bl[2]_24 nbl[2]_24 nbl[3]_24 bl[0]_23 nbl[0]_23 nbl[1]_23
+  bl[1]_23 vddpe vddc vnwc vpw bl[2]_23 nbl[2]_23 bl[0]_22 nbl[0]_22
+  nbl[1]_22 bl[1]_22 vddpe vddc vnwc vpw bl[2]_22 nbl[2]_22 bl[0]_21
+  nbl[0]_21 nbl[1]_21 bl[1]_21 vddpe vddc vddc vnwc vpw bl[2]_21 nbl[2]_21
+  bl[0]_20 nbl[0]_20 nbl[1]_20 bl[1]_20 vddpe vddc vddc vnwc vpw nbl[2]_20
+  bl[0]_19 nbl[0]_19 nbl[1]_19 bl[1]_19 vddpe vddc vddc vnwc vpw bl[0]_18
+  nbl[0]_18 nbl[1]_18 bl[1]_18 vddpe vddc vnwc vpw bl[2]_18 nbl[2]_18
+  bl[0]_17 nbl[0]_17 nbl[1]_17 bl[1]_17 vddpe vddc vnwc vpw bl[2]_17
+  nbl[2]_17 bl[0]_16 nbl[0]_16 nbl[1]_16 bl[1]_16 vddpe vddc vddc vnwc vpw
+  bl[2]_16 nbl[2]_16 bl[0]_15 nbl[0]_15 nbl[1]_15 bl[1]_15 vddpe vddc vddc
+  vnwc vpw nbl[2]_15 bl[0]_14 nbl[0]_14 nbl[1]_14 bl[1]_14 vddpe vddc vddc
+  vnwc vpw nbl[2]_14 bl[0]_13 nbl[0]_13 nbl[1]_13 bl[1]_13 vddpe vddc vddc
+  vnwc vpw bl[0]_12 nbl[0]_12 nbl[1]_12 bl[1]_12 vddpe vddc vddc vnwc vpw
+  bl[0]_11 nbl[0]_11 nbl[1]_11 bl[1]_11 vddpe vddc vddc vnwc vpw bl[2]_11
+  nbl[2]_11 bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe vddc vddc vnwc vpw
+  nbl[2]_10 bl[0]_9 nbl[0]_9 nbl[1]_9 bl[1]_9 vddpe vddc vddc vnwc vpw
+  nbl[2]_9 bl[0]_8 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe vddc vddc vnwc vpw bl[0]_7
+  nbl[0]_7 nbl[1]_7 bl[1]_7 vddpe vddc vddc vnwc vpw bl[0]_6 nbl[0]_6
+  nbl[1]_6 bl[1]_6 vddpe vddc vddc vnwc vpw bl[3]_6 bl[0]_5 nbl[0]_5 nbl[1]_5
+  bl[1]_5 vddpe vddc vddc vnwc vpw nbl[2]_5 bl[0]_4 nbl[0]_4 nbl[1]_4 bl[1]_4
+  vddpe vddc vddc vnwc vpw nbl[2]_4 bl[0]_3 nbl[0]_3 nbl[1]_3 bl[1]_3 vddpe
+  vddc vddc vnwc vpw bl[0]_2 nbl[0]_2 nbl[1]_2 bl[1]_2 vddpe vddc vddc vnwc
+  vpw bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddpe vddc vddc vnwc vpw bl[3]_1
+  bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe vddc vddc vnwc vpw bl[3]_0 vnwc vpw
+  vnwc vnwp_1 dbl dwl bl[0]_31 nbl[0]_31 nbl[1]_31 bl[1]_31 vddpe vddc vpw
+  bl[0]_30 nbl[0]_30 nbl[1]_30 vddc vddc vnwc vpw bl[3]_30 bl[0]_29 nbl[0]_29
+  nbl[1]_29 vddc vddc vnwc vpw nbl[3]_29 bl[3]_29 bl[0]_28 nbl[0]_28
+  nbl[1]_28 vddc vddc vnwc vpw nbl[3]_28 bl[3]_28 bl[0]_27 nbl[0]_27
+  nbl[1]_27 vddc vddc vnwc vpw nbl[3]_27 bl[3]_27 nbl[0]_26 nbl[1]_26 vddc
+  vddc vnwc vpw bl[2]_26 bl[3]_26 nbl[0]_25 nbl[1]_25 vddc vpw bl[2]_25
+  bl[3]_25 vddc bl[3]_24 vddc nbl[3]_23 bl[3]_23 vddc nbl[3]_22 bl[3]_22
+  nbl[3]_21 bl[3]_21 bl[2]_20 nbl[3]_20 bl[3]_20 bl[2]_19 nbl[2]_19 nbl[3]_19
+  bl[3]_19 vddc nbl[3]_18 bl[3]_18 vddc nbl[3]_17 bl[3]_17 nbl[3]_16 bl[3]_16
+  bl[2]_15 nbl[3]_15 bl[3]_15 bl[2]_14 nbl[3]_14 bl[3]_14 bl[2]_13 nbl[2]_13
+  nbl[3]_13 bl[3]_13 bl[2]_12 nbl[2]_12 nbl[3]_12 bl[3]_12 nbl[3]_11 bl[3]_11
+  bl[2]_10 nbl[3]_10 bl[3]_10 bl[2]_9 nbl[3]_9 bl[3]_9 bl[2]_8 nbl[2]_8
+  nbl[3]_8 bl[3]_8 bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[2]_6 nbl[2]_6
+  nbl[3]_6 bl[2]_5 nbl[3]_5 bl[3]_5 bl[2]_4 nbl[3]_4 bl[3]_4 bl[2]_3 nbl[2]_3
+  nbl[3]_3 bl[3]_3 bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[2]_1 nbl[2]_1
+  nbl[3]_1 bl[2]_0 nbl[2]_0 nbl[3]_0 vnwp_0 wl[0]_1 wl[1]_1
+  rf64x128mem_l_test1row
xmem_l_row_10 vddc vnwc dbl dwl vnwc bl[2]_31 nbl[2]_31 nbl[3]_31 bl[3]_31
+  bl[1]_30 vddpe bl[2]_30 nbl[2]_30 nbl[3]_30 bl[1]_29 vddpe bl[2]_29
+  nbl[2]_29 bl[1]_28 vddpe bl[2]_28 nbl[2]_28 bl[1]_27 vddpe bl[2]_27
+  nbl[2]_27 bl[0]_26 bl[1]_26 vddpe nbl[2]_26 nbl[3]_26 bl[0]_25 bl[1]_25
+  vddpe vddc vnwc vssc nbl[2]_25 nbl[3]_25 bl[0]_24 nbl[0]_24 nbl[1]_24
+  bl[1]_24 vddpe vddc vnwc vpw bl[2]_24 nbl[2]_24 nbl[3]_24 bl[0]_23
+  nbl[0]_23 nbl[1]_23 bl[1]_23 vddpe vddc vnwc vpw bl[2]_23 nbl[2]_23
+  bl[0]_22 nbl[0]_22 nbl[1]_22 bl[1]_22 vddpe vddc vnwc vpw bl[2]_22
+  nbl[2]_22 bl[0]_21 nbl[0]_21 nbl[1]_21 bl[1]_21 vddpe vddc vddc vnwc vpw
+  bl[2]_21 nbl[2]_21 bl[0]_20 nbl[0]_20 nbl[1]_20 bl[1]_20 vddpe vddc vddc
+  vnwc vpw nbl[2]_20 bl[0]_19 nbl[0]_19 nbl[1]_19 bl[1]_19 vddpe vddc vddc
+  vnwc vpw bl[0]_18 nbl[0]_18 nbl[1]_18 bl[1]_18 vddpe vddc vnwc vpw bl[2]_18
+  nbl[2]_18 bl[0]_17 nbl[0]_17 nbl[1]_17 bl[1]_17 vddpe vddc vnwc vpw
+  bl[2]_17 nbl[2]_17 bl[0]_16 nbl[0]_16 nbl[1]_16 bl[1]_16 vddpe vddc vddc
+  vnwc vpw bl[2]_16 nbl[2]_16 bl[0]_15 nbl[0]_15 nbl[1]_15 bl[1]_15 vddpe
+  vddc vddc vnwc vpw nbl[2]_15 bl[0]_14 nbl[0]_14 nbl[1]_14 bl[1]_14 vddpe
+  vddc vddc vnwc vpw nbl[2]_14 bl[0]_13 nbl[0]_13 nbl[1]_13 bl[1]_13 vddpe
+  vddc vddc vnwc vpw bl[0]_12 nbl[0]_12 nbl[1]_12 bl[1]_12 vddpe vddc vddc
+  vnwc vpw bl[0]_11 nbl[0]_11 nbl[1]_11 bl[1]_11 vddpe vddc vddc vnwc vpw
+  bl[2]_11 nbl[2]_11 bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe vddc vddc
+  vnwc vpw nbl[2]_10 bl[0]_9 nbl[0]_9 nbl[1]_9 bl[1]_9 vddpe vddc vddc vnwc
+  vpw nbl[2]_9 bl[0]_8 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe vddc vddc vnwc vpw
+  bl[0]_7 nbl[0]_7 nbl[1]_7 bl[1]_7 vddpe vddc vddc vnwc vpw bl[0]_6 nbl[0]_6
+  nbl[1]_6 bl[1]_6 vddpe vddc vddc vnwc vpw bl[3]_6 bl[0]_5 nbl[0]_5 nbl[1]_5
+  bl[1]_5 vddpe vddc vddc vnwc vpw nbl[2]_5 bl[0]_4 nbl[0]_4 nbl[1]_4 bl[1]_4
+  vddpe vddc vddc vnwc vpw nbl[2]_4 bl[0]_3 nbl[0]_3 nbl[1]_3 bl[1]_3 vddpe
+  vddc vddc vnwc vpw bl[0]_2 nbl[0]_2 nbl[1]_2 bl[1]_2 vddpe vddc vddc vnwc
+  vpw bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddpe vddc vddc vnwc vpw bl[3]_1
+  bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe vddc vddc vnwc vpw bl[3]_0 vnwp_0
+  vnwc vpw vpw vnwp_1 bl[0]_31 nbl[0]_31 nbl[1]_31 bl[1]_31 vddpe vddc vddc
+  vpw bl[0]_30 nbl[0]_30 nbl[1]_30 vddc vddc vnwc vpw bl[3]_30 bl[0]_29
+  nbl[0]_29 nbl[1]_29 vddc vddc vnwc vpw nbl[3]_29 bl[3]_29 bl[0]_28
+  nbl[0]_28 nbl[1]_28 vddc vddc vnwc vpw nbl[3]_28 bl[3]_28 bl[0]_27
+  nbl[0]_27 nbl[1]_27 vddc vddc vnwc vpw nbl[3]_27 bl[3]_27 nbl[0]_26
+  nbl[1]_26 vddc vddc vnwc vpw bl[2]_26 bl[3]_26 nbl[0]_25 nbl[1]_25 vddc vpw
+  bl[2]_25 bl[3]_25 vddc bl[3]_24 vddc nbl[3]_23 bl[3]_23 vddc nbl[3]_22
+  bl[3]_22 nbl[3]_21 bl[3]_21 bl[2]_20 nbl[3]_20 bl[3]_20 bl[2]_19 nbl[2]_19
+  nbl[3]_19 bl[3]_19 vddc nbl[3]_18 bl[3]_18 vddc nbl[3]_17 bl[3]_17
+  nbl[3]_16 bl[3]_16 bl[2]_15 nbl[3]_15 bl[3]_15 bl[2]_14 nbl[3]_14 bl[3]_14
+  bl[2]_13 nbl[2]_13 nbl[3]_13 bl[3]_13 bl[2]_12 nbl[2]_12 nbl[3]_12 bl[3]_12
+  nbl[3]_11 bl[3]_11 bl[2]_10 nbl[3]_10 bl[3]_10 bl[2]_9 nbl[3]_9 bl[3]_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[2]_6
+  nbl[2]_6 nbl[3]_6 bl[2]_5 nbl[3]_5 bl[3]_5 bl[2]_4 nbl[3]_4 bl[3]_4 bl[2]_3
+  nbl[2]_3 nbl[3]_3 bl[3]_3 bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[2]_1
+  nbl[2]_1 nbl[3]_1 bl[2]_0 nbl[2]_0 nbl[3]_0 wl[1]_10 wl[0]_10
+  rf64x128mem_l_test10row
xmem_l_row_11 vddc vpw vnwc dbl dwl vddc vnwc bl[2]_31 nbl[2]_31 nbl[3]_31
+  bl[3]_31 bl[1]_30 vddpe bl[2]_30 nbl[2]_30 nbl[3]_30 bl[1]_29 vddpe
+  bl[2]_29 nbl[2]_29 bl[1]_28 vddpe bl[2]_28 nbl[2]_28 bl[1]_27 vddpe
+  bl[2]_27 nbl[2]_27 bl[0]_26 bl[1]_26 vddpe nbl[2]_26 nbl[3]_26 bl[0]_25
+  bl[1]_25 vddpe vddc vnwc vssc nbl[2]_25 nbl[3]_25 bl[0]_24 nbl[0]_24
+  nbl[1]_24 bl[1]_24 vddpe vddc vnwc vpw bl[2]_24 nbl[2]_24 nbl[3]_24
+  bl[0]_23 nbl[0]_23 nbl[1]_23 bl[1]_23 vddpe vddc vnwc vpw bl[2]_23
+  nbl[2]_23 bl[0]_22 nbl[0]_22 nbl[1]_22 bl[1]_22 vddpe vddc vnwc vpw
+  bl[2]_22 nbl[2]_22 bl[0]_21 nbl[0]_21 nbl[1]_21 bl[1]_21 vddpe vddc vddc
+  vnwc vpw bl[2]_21 nbl[2]_21 bl[0]_20 nbl[0]_20 nbl[1]_20 bl[1]_20 vddpe
+  vddc vddc vnwc vpw nbl[2]_20 bl[0]_19 nbl[0]_19 nbl[1]_19 bl[1]_19 vddpe
+  vddc vddc vnwc vpw bl[0]_18 nbl[0]_18 nbl[1]_18 bl[1]_18 vddpe vddc vnwc
+  vpw bl[2]_18 nbl[2]_18 bl[0]_17 nbl[0]_17 nbl[1]_17 bl[1]_17 vddpe vddc
+  vnwc vpw bl[2]_17 nbl[2]_17 bl[0]_16 nbl[0]_16 nbl[1]_16 bl[1]_16 vddpe
+  vddc vddc vnwc vpw bl[2]_16 nbl[2]_16 bl[0]_15 nbl[0]_15 nbl[1]_15 bl[1]_15
+  vddpe vddc vddc vnwc vpw nbl[2]_15 bl[0]_14 nbl[0]_14 nbl[1]_14 bl[1]_14
+  vddpe vddc vddc vnwc vpw nbl[2]_14 bl[0]_13 nbl[0]_13 nbl[1]_13 bl[1]_13
+  vddpe vddc vddc vnwc vpw bl[0]_12 nbl[0]_12 nbl[1]_12 bl[1]_12 vddpe vddc
+  vddc vnwc vpw bl[0]_11 nbl[0]_11 nbl[1]_11 bl[1]_11 vddpe vddc vddc vnwc
+  vpw bl[2]_11 nbl[2]_11 bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe vddc
+  vddc vnwc vpw nbl[2]_10 bl[0]_9 nbl[0]_9 nbl[1]_9 bl[1]_9 vddpe vddc vddc
+  vnwc vpw nbl[2]_9 bl[0]_8 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe vddc vddc vnwc
+  vpw bl[0]_7 nbl[0]_7 nbl[1]_7 bl[1]_7 vddpe vddc vddc vnwc vpw bl[0]_6
+  nbl[0]_6 nbl[1]_6 bl[1]_6 vddpe vddc vddc vnwc vpw bl[3]_6 bl[0]_5 nbl[0]_5
+  nbl[1]_5 bl[1]_5 vddpe vddc vddc vnwc vpw nbl[2]_5 bl[0]_4 nbl[0]_4
+  nbl[1]_4 bl[1]_4 vddpe vddc vddc vnwc vpw nbl[2]_4 bl[0]_3 nbl[0]_3
+  nbl[1]_3 bl[1]_3 vddpe vddc vddc vnwc vpw bl[0]_2 nbl[0]_2 nbl[1]_2 bl[1]_2
+  vddpe vddc vddc vnwc vpw bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddpe vddc vddc
+  vnwc vpw bl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe vddc vddc vnwc vpw
+  bl[3]_0 vnwp_0 vnwc vpw vnwp_1 bl[0]_31 nbl[0]_31 nbl[1]_31 bl[1]_31 vddpe
+  vddc vpw bl[0]_30 nbl[0]_30 nbl[1]_30 vddc vddc vnwc vpw bl[3]_30 bl[0]_29
+  nbl[0]_29 nbl[1]_29 vddc vddc vnwc vpw nbl[3]_29 bl[3]_29 bl[0]_28
+  nbl[0]_28 nbl[1]_28 vddc vddc vnwc vpw nbl[3]_28 bl[3]_28 bl[0]_27
+  nbl[0]_27 nbl[1]_27 vddc vddc vnwc vpw nbl[3]_27 bl[3]_27 nbl[0]_26
+  nbl[1]_26 vddc vddc vnwc vpw bl[2]_26 bl[3]_26 nbl[0]_25 nbl[1]_25 vddc vpw
+  bl[2]_25 bl[3]_25 vddc bl[3]_24 vddc nbl[3]_23 bl[3]_23 vddc nbl[3]_22
+  bl[3]_22 nbl[3]_21 bl[3]_21 bl[2]_20 nbl[3]_20 bl[3]_20 bl[2]_19 nbl[2]_19
+  nbl[3]_19 bl[3]_19 vddc nbl[3]_18 bl[3]_18 vddc nbl[3]_17 bl[3]_17
+  nbl[3]_16 bl[3]_16 bl[2]_15 nbl[3]_15 bl[3]_15 bl[2]_14 nbl[3]_14 bl[3]_14
+  bl[2]_13 nbl[2]_13 nbl[3]_13 bl[3]_13 bl[2]_12 nbl[2]_12 nbl[3]_12 bl[3]_12
+  nbl[3]_11 bl[3]_11 bl[2]_10 nbl[3]_10 bl[3]_10 bl[2]_9 nbl[3]_9 bl[3]_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[2]_6
+  nbl[2]_6 nbl[3]_6 bl[2]_5 nbl[3]_5 bl[3]_5 bl[2]_4 nbl[3]_4 bl[3]_4 bl[2]_3
+  nbl[2]_3 nbl[3]_3 bl[3]_3 bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[2]_1
+  nbl[2]_1 nbl[3]_1 bl[2]_0 nbl[2]_0 nbl[3]_0 wl[1]_11 wl[0]_11
+  rf64x128mem_l_test11row
xmem_l_row_12 vddc vpw vnwc vnwc bl[2]_31 nbl[2]_31 nbl[3]_31 bl[3]_31
+  bl[1]_30 vddpe bl[2]_30 nbl[2]_30 nbl[3]_30 bl[1]_29 vddpe bl[2]_29
+  nbl[2]_29 bl[1]_28 vddpe bl[2]_28 nbl[2]_28 bl[1]_27 vddpe bl[2]_27
+  nbl[2]_27 bl[0]_26 bl[1]_26 vddpe nbl[2]_26 nbl[3]_26 bl[0]_25 bl[1]_25
+  vddpe vddc vnwc vssc nbl[2]_25 nbl[3]_25 bl[0]_24 nbl[0]_24 nbl[1]_24
+  bl[1]_24 vddpe vddc vnwc vpw bl[2]_24 nbl[2]_24 nbl[3]_24 bl[0]_23
+  nbl[0]_23 nbl[1]_23 bl[1]_23 vddpe vddc vnwc vpw bl[2]_23 nbl[2]_23
+  bl[0]_22 nbl[0]_22 nbl[1]_22 bl[1]_22 vddpe vddc vnwc vpw bl[2]_22
+  nbl[2]_22 bl[0]_21 nbl[0]_21 nbl[1]_21 bl[1]_21 vddpe vddc vddc vnwc vpw
+  bl[2]_21 nbl[2]_21 bl[0]_20 nbl[0]_20 nbl[1]_20 bl[1]_20 vddpe vddc vddc
+  vnwc vpw nbl[2]_20 bl[0]_19 nbl[0]_19 nbl[1]_19 bl[1]_19 vddpe vddc vddc
+  vnwc vpw bl[0]_18 nbl[0]_18 nbl[1]_18 bl[1]_18 vddpe vddc vnwc vpw bl[2]_18
+  nbl[2]_18 bl[0]_17 nbl[0]_17 nbl[1]_17 bl[1]_17 vddpe vddc vnwc vpw
+  bl[2]_17 nbl[2]_17 bl[0]_16 nbl[0]_16 nbl[1]_16 bl[1]_16 vddpe vddc vddc
+  vnwc vpw bl[2]_16 nbl[2]_16 bl[0]_15 nbl[0]_15 nbl[1]_15 bl[1]_15 vddpe
+  vddc vddc vnwc vpw nbl[2]_15 bl[0]_14 nbl[0]_14 nbl[1]_14 bl[1]_14 vddpe
+  vddc vddc vnwc vpw nbl[2]_14 bl[0]_13 nbl[0]_13 nbl[1]_13 bl[1]_13 vddpe
+  vddc vddc vnwc vpw bl[0]_12 nbl[0]_12 nbl[1]_12 bl[1]_12 vddpe vddc vddc
+  vnwc vpw bl[0]_11 nbl[0]_11 nbl[1]_11 bl[1]_11 vddpe vddc vddc vnwc vpw
+  bl[2]_11 nbl[2]_11 bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe vddc vddc
+  vnwc vpw nbl[2]_10 bl[0]_9 nbl[0]_9 nbl[1]_9 bl[1]_9 vddpe vddc vddc vnwc
+  vpw nbl[2]_9 bl[0]_8 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe vddc vddc vnwc vpw
+  bl[0]_7 nbl[0]_7 nbl[1]_7 bl[1]_7 vddpe vddc vddc vnwc vpw bl[0]_6 nbl[0]_6
+  nbl[1]_6 bl[1]_6 vddpe vddc vddc vnwc vpw bl[3]_6 bl[0]_5 nbl[0]_5 nbl[1]_5
+  bl[1]_5 vddpe vddc vddc vnwc vpw nbl[2]_5 bl[0]_4 nbl[0]_4 nbl[1]_4 bl[1]_4
+  vddpe vddc vddc vnwc vpw nbl[2]_4 bl[0]_3 nbl[0]_3 nbl[1]_3 bl[1]_3 vddpe
+  vddc vddc vnwc vpw bl[0]_2 nbl[0]_2 nbl[1]_2 bl[1]_2 vddpe vddc vddc vnwc
+  vpw bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddpe vddc vddc vnwc vpw bl[3]_1
+  bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe vddc vddc vnwc vpw bl[3]_0 vnwc vpw
+  vnwp_1 dbl dwl bl[0]_31 nbl[0]_31 nbl[1]_31 bl[1]_31 vddpe vddc vddc vpw
+  bl[0]_30 nbl[0]_30 nbl[1]_30 vddc vddc vnwc vpw bl[3]_30 bl[0]_29 nbl[0]_29
+  nbl[1]_29 vddc vddc vnwc vpw nbl[3]_29 bl[3]_29 bl[0]_28 nbl[0]_28
+  nbl[1]_28 vddc vddc vnwc vpw nbl[3]_28 bl[3]_28 bl[0]_27 nbl[0]_27
+  nbl[1]_27 vddc vddc vnwc vpw nbl[3]_27 bl[3]_27 nbl[0]_26 nbl[1]_26 vddc
+  vddc vnwc vpw bl[2]_26 bl[3]_26 nbl[0]_25 nbl[1]_25 vddc vpw bl[2]_25
+  bl[3]_25 vddc bl[3]_24 vddc nbl[3]_23 bl[3]_23 vddc nbl[3]_22 bl[3]_22
+  nbl[3]_21 bl[3]_21 bl[2]_20 nbl[3]_20 bl[3]_20 bl[2]_19 nbl[2]_19 nbl[3]_19
+  bl[3]_19 vddc nbl[3]_18 bl[3]_18 vddc nbl[3]_17 bl[3]_17 nbl[3]_16 bl[3]_16
+  bl[2]_15 nbl[3]_15 bl[3]_15 bl[2]_14 nbl[3]_14 bl[3]_14 bl[2]_13 nbl[2]_13
+  nbl[3]_13 bl[3]_13 bl[2]_12 nbl[2]_12 nbl[3]_12 bl[3]_12 nbl[3]_11 bl[3]_11
+  bl[2]_10 nbl[3]_10 bl[3]_10 bl[2]_9 nbl[3]_9 bl[3]_9 bl[2]_8 nbl[2]_8
+  nbl[3]_8 bl[3]_8 bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[2]_6 nbl[2]_6
+  nbl[3]_6 bl[2]_5 nbl[3]_5 bl[3]_5 bl[2]_4 nbl[3]_4 bl[3]_4 bl[2]_3 nbl[2]_3
+  nbl[3]_3 bl[3]_3 bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[2]_1 nbl[2]_1
+  nbl[3]_1 bl[2]_0 nbl[2]_0 nbl[3]_0 vnwp_0 wl[0]_12 wl[1]_12
+  rf64x128mem_l_test12row
xmem_l_row_13 vddc vpw vnwc dbl dwl vddc vnwc bl[2]_31 nbl[2]_31 nbl[3]_31
+  bl[3]_31 bl[1]_30 vddpe bl[2]_30 nbl[2]_30 nbl[3]_30 bl[1]_29 vddpe
+  bl[2]_29 nbl[2]_29 bl[1]_28 vddpe bl[2]_28 nbl[2]_28 bl[1]_27 vddpe
+  bl[2]_27 nbl[2]_27 bl[0]_26 bl[1]_26 vddpe nbl[2]_26 nbl[3]_26 bl[0]_25
+  bl[1]_25 vddpe vddc vnwc vssc nbl[2]_25 nbl[3]_25 bl[0]_24 nbl[0]_24
+  nbl[1]_24 bl[1]_24 vddpe vddc vnwc vpw bl[2]_24 nbl[2]_24 nbl[3]_24
+  bl[0]_23 nbl[0]_23 nbl[1]_23 bl[1]_23 vddpe vddc vnwc vpw bl[2]_23
+  nbl[2]_23 bl[0]_22 nbl[0]_22 nbl[1]_22 bl[1]_22 vddpe vddc vnwc vpw
+  bl[2]_22 nbl[2]_22 bl[0]_21 nbl[0]_21 nbl[1]_21 bl[1]_21 vddpe vddc vddc
+  vnwc vpw bl[2]_21 nbl[2]_21 bl[0]_20 nbl[0]_20 nbl[1]_20 bl[1]_20 vddpe
+  vddc vddc vnwc vpw nbl[2]_20 bl[0]_19 nbl[0]_19 nbl[1]_19 bl[1]_19 vddpe
+  vddc vddc vnwc vpw bl[0]_18 nbl[0]_18 nbl[1]_18 bl[1]_18 vddpe vddc vnwc
+  vpw bl[2]_18 nbl[2]_18 bl[0]_17 nbl[0]_17 nbl[1]_17 bl[1]_17 vddpe vddc
+  vnwc vpw bl[2]_17 nbl[2]_17 bl[0]_16 nbl[0]_16 nbl[1]_16 bl[1]_16 vddpe
+  vddc vddc vnwc vpw bl[2]_16 nbl[2]_16 bl[0]_15 nbl[0]_15 nbl[1]_15 bl[1]_15
+  vddpe vddc vddc vnwc vpw nbl[2]_15 bl[0]_14 nbl[0]_14 nbl[1]_14 bl[1]_14
+  vddpe vddc vddc vnwc vpw nbl[2]_14 bl[0]_13 nbl[0]_13 nbl[1]_13 bl[1]_13
+  vddpe vddc vddc vnwc vpw bl[0]_12 nbl[0]_12 nbl[1]_12 bl[1]_12 vddpe vddc
+  vddc vnwc vpw bl[0]_11 nbl[0]_11 nbl[1]_11 bl[1]_11 vddpe vddc vddc vnwc
+  vpw bl[2]_11 nbl[2]_11 bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe vddc
+  vddc vnwc vpw nbl[2]_10 bl[0]_9 nbl[0]_9 nbl[1]_9 bl[1]_9 vddpe vddc vddc
+  vnwc vpw nbl[2]_9 bl[0]_8 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe vddc vddc vnwc
+  vpw bl[0]_7 nbl[0]_7 nbl[1]_7 bl[1]_7 vddpe vddc vddc vnwc vpw bl[0]_6
+  nbl[0]_6 nbl[1]_6 bl[1]_6 vddpe vddc vddc vnwc vpw bl[3]_6 bl[0]_5 nbl[0]_5
+  nbl[1]_5 bl[1]_5 vddpe vddc vddc vnwc vpw nbl[2]_5 bl[0]_4 nbl[0]_4
+  nbl[1]_4 bl[1]_4 vddpe vddc vddc vnwc vpw nbl[2]_4 bl[0]_3 nbl[0]_3
+  nbl[1]_3 bl[1]_3 vddpe vddc vddc vnwc vpw bl[0]_2 nbl[0]_2 nbl[1]_2 bl[1]_2
+  vddpe vddc vddc vnwc vpw bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddpe vddc vddc
+  vnwc vpw bl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe vddc vddc vnwc vpw
+  bl[3]_0 vnwp_0 vnwc vpw vnwp_1 bl[0]_31 nbl[0]_31 nbl[1]_31 bl[1]_31 vddpe
+  vddc vpw bl[0]_30 nbl[0]_30 nbl[1]_30 vddc vddc vnwc vpw bl[3]_30 bl[0]_29
+  nbl[0]_29 nbl[1]_29 vddc vddc vnwc vpw nbl[3]_29 bl[3]_29 bl[0]_28
+  nbl[0]_28 nbl[1]_28 vddc vddc vnwc vpw nbl[3]_28 bl[3]_28 bl[0]_27
+  nbl[0]_27 nbl[1]_27 vddc vddc vnwc vpw nbl[3]_27 bl[3]_27 nbl[0]_26
+  nbl[1]_26 vddc vddc vnwc vpw bl[2]_26 bl[3]_26 nbl[0]_25 nbl[1]_25 vddc vpw
+  bl[2]_25 bl[3]_25 vddc bl[3]_24 vddc nbl[3]_23 bl[3]_23 vddc nbl[3]_22
+  bl[3]_22 nbl[3]_21 bl[3]_21 bl[2]_20 nbl[3]_20 bl[3]_20 bl[2]_19 nbl[2]_19
+  nbl[3]_19 bl[3]_19 vddc nbl[3]_18 bl[3]_18 vddc nbl[3]_17 bl[3]_17
+  nbl[3]_16 bl[3]_16 bl[2]_15 nbl[3]_15 bl[3]_15 bl[2]_14 nbl[3]_14 bl[3]_14
+  bl[2]_13 nbl[2]_13 nbl[3]_13 bl[3]_13 bl[2]_12 nbl[2]_12 nbl[3]_12 bl[3]_12
+  nbl[3]_11 bl[3]_11 bl[2]_10 nbl[3]_10 bl[3]_10 bl[2]_9 nbl[3]_9 bl[3]_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[2]_6
+  nbl[2]_6 nbl[3]_6 bl[2]_5 nbl[3]_5 bl[3]_5 bl[2]_4 nbl[3]_4 bl[3]_4 bl[2]_3
+  nbl[2]_3 nbl[3]_3 bl[3]_3 bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[2]_1
+  nbl[2]_1 nbl[3]_1 bl[2]_0 nbl[2]_0 nbl[3]_0 wl[1]_13 wl[0]_13
+  rf64x128mem_l_test13row
xmem_l_row_14 vddc vpw vnwc vnwc bl[2]_31 nbl[2]_31 nbl[3]_31 bl[3]_31
+  bl[1]_30 vddpe bl[2]_30 nbl[2]_30 nbl[3]_30 bl[1]_29 vddpe bl[2]_29
+  nbl[2]_29 bl[1]_28 vddpe bl[2]_28 nbl[2]_28 bl[1]_27 vddpe bl[2]_27
+  nbl[2]_27 bl[0]_26 bl[1]_26 vddpe nbl[2]_26 nbl[3]_26 bl[0]_25 bl[1]_25
+  vddpe vddc vnwc vssc nbl[2]_25 nbl[3]_25 bl[0]_24 nbl[0]_24 nbl[1]_24
+  bl[1]_24 vddpe vddc vnwc vpw bl[2]_24 nbl[2]_24 nbl[3]_24 bl[0]_23
+  nbl[0]_23 nbl[1]_23 bl[1]_23 vddpe vddc vnwc vpw bl[2]_23 nbl[2]_23
+  bl[0]_22 nbl[0]_22 nbl[1]_22 bl[1]_22 vddpe vddc vnwc vpw bl[2]_22
+  nbl[2]_22 bl[0]_21 nbl[0]_21 nbl[1]_21 bl[1]_21 vddpe vddc vddc vnwc vpw
+  bl[2]_21 nbl[2]_21 bl[0]_20 nbl[0]_20 nbl[1]_20 bl[1]_20 vddpe vddc vddc
+  vnwc vpw nbl[2]_20 bl[0]_19 nbl[0]_19 nbl[1]_19 bl[1]_19 vddpe vddc vddc
+  vnwc vpw bl[0]_18 nbl[0]_18 nbl[1]_18 bl[1]_18 vddpe vddc vnwc vpw bl[2]_18
+  nbl[2]_18 bl[0]_17 nbl[0]_17 nbl[1]_17 bl[1]_17 vddpe vddc vnwc vpw
+  bl[2]_17 nbl[2]_17 bl[0]_16 nbl[0]_16 nbl[1]_16 bl[1]_16 vddpe vddc vddc
+  vnwc vpw bl[2]_16 nbl[2]_16 bl[0]_15 nbl[0]_15 nbl[1]_15 bl[1]_15 vddpe
+  vddc vddc vnwc vpw nbl[2]_15 bl[0]_14 nbl[0]_14 nbl[1]_14 bl[1]_14 vddpe
+  vddc vddc vnwc vpw nbl[2]_14 bl[0]_13 nbl[0]_13 nbl[1]_13 bl[1]_13 vddpe
+  vddc vddc vnwc vpw bl[0]_12 nbl[0]_12 nbl[1]_12 bl[1]_12 vddpe vddc vddc
+  vnwc vpw bl[0]_11 nbl[0]_11 nbl[1]_11 bl[1]_11 vddpe vddc vddc vnwc vpw
+  bl[2]_11 nbl[2]_11 bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe vddc vddc
+  vnwc vpw nbl[2]_10 bl[0]_9 nbl[0]_9 nbl[1]_9 bl[1]_9 vddpe vddc vddc vnwc
+  vpw nbl[2]_9 bl[0]_8 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe vddc vddc vnwc vpw
+  bl[0]_7 nbl[0]_7 nbl[1]_7 bl[1]_7 vddpe vddc vddc vnwc vpw bl[0]_6 nbl[0]_6
+  nbl[1]_6 bl[1]_6 vddpe vddc vddc vnwc vpw bl[3]_6 bl[0]_5 nbl[0]_5 nbl[1]_5
+  bl[1]_5 vddpe vddc vddc vnwc vpw nbl[2]_5 bl[0]_4 nbl[0]_4 nbl[1]_4 bl[1]_4
+  vddpe vddc vddc vnwc vpw nbl[2]_4 bl[0]_3 nbl[0]_3 nbl[1]_3 bl[1]_3 vddpe
+  vddc vddc vnwc vpw bl[0]_2 nbl[0]_2 nbl[1]_2 bl[1]_2 vddpe vddc vddc vnwc
+  vpw bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddpe vddc vddc vnwc vpw bl[3]_1
+  bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe vddc vddc vnwc vpw bl[3]_0 vnwc vpw
+  vnwp_1 dbl dwl bl[0]_31 nbl[0]_31 nbl[1]_31 bl[1]_31 vddpe vddc vddc vpw
+  bl[0]_30 nbl[0]_30 nbl[1]_30 vddc vddc vnwc vpw bl[3]_30 bl[0]_29 nbl[0]_29
+  nbl[1]_29 vddc vddc vnwc vpw nbl[3]_29 bl[3]_29 bl[0]_28 nbl[0]_28
+  nbl[1]_28 vddc vddc vnwc vpw nbl[3]_28 bl[3]_28 bl[0]_27 nbl[0]_27
+  nbl[1]_27 vddc vddc vnwc vpw nbl[3]_27 bl[3]_27 nbl[0]_26 nbl[1]_26 vddc
+  vddc vnwc vpw bl[2]_26 bl[3]_26 nbl[0]_25 nbl[1]_25 vddc vpw bl[2]_25
+  bl[3]_25 vddc bl[3]_24 vddc nbl[3]_23 bl[3]_23 vddc nbl[3]_22 bl[3]_22
+  nbl[3]_21 bl[3]_21 bl[2]_20 nbl[3]_20 bl[3]_20 bl[2]_19 nbl[2]_19 nbl[3]_19
+  bl[3]_19 vddc nbl[3]_18 bl[3]_18 vddc nbl[3]_17 bl[3]_17 nbl[3]_16 bl[3]_16
+  bl[2]_15 nbl[3]_15 bl[3]_15 bl[2]_14 nbl[3]_14 bl[3]_14 bl[2]_13 nbl[2]_13
+  nbl[3]_13 bl[3]_13 bl[2]_12 nbl[2]_12 nbl[3]_12 bl[3]_12 nbl[3]_11 bl[3]_11
+  bl[2]_10 nbl[3]_10 bl[3]_10 bl[2]_9 nbl[3]_9 bl[3]_9 bl[2]_8 nbl[2]_8
+  nbl[3]_8 bl[3]_8 bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[2]_6 nbl[2]_6
+  nbl[3]_6 bl[2]_5 nbl[3]_5 bl[3]_5 bl[2]_4 nbl[3]_4 bl[3]_4 bl[2]_3 nbl[2]_3
+  nbl[3]_3 bl[3]_3 bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[2]_1 nbl[2]_1
+  nbl[3]_1 bl[2]_0 nbl[2]_0 nbl[3]_0 vnwp_0 wl[0]_14 wl[1]_14
+  rf64x128mem_l_test14row
xmem_l_row_2 vddc vnwc dbl dwl vnwc bl[2]_31 nbl[2]_31 nbl[3]_31 bl[3]_31
+  bl[1]_30 vddpe bl[2]_30 nbl[2]_30 nbl[3]_30 bl[1]_29 vddpe bl[2]_29
+  nbl[2]_29 bl[1]_28 vddpe bl[2]_28 nbl[2]_28 bl[1]_27 vddpe bl[2]_27
+  nbl[2]_27 bl[0]_26 bl[1]_26 vddpe nbl[2]_26 nbl[3]_26 bl[0]_25 bl[1]_25
+  vddpe vddc vnwc vssc nbl[2]_25 nbl[3]_25 bl[0]_24 nbl[0]_24 nbl[1]_24
+  bl[1]_24 vddpe vddc vnwc vpw bl[2]_24 nbl[2]_24 nbl[3]_24 bl[0]_23
+  nbl[0]_23 nbl[1]_23 bl[1]_23 vddpe vddc vnwc vpw bl[2]_23 nbl[2]_23
+  bl[0]_22 nbl[0]_22 nbl[1]_22 bl[1]_22 vddpe vddc vnwc vpw bl[2]_22
+  nbl[2]_22 bl[0]_21 nbl[0]_21 nbl[1]_21 bl[1]_21 vddpe vddc vddc vnwc vpw
+  bl[2]_21 nbl[2]_21 bl[0]_20 nbl[0]_20 nbl[1]_20 bl[1]_20 vddpe vddc vddc
+  vnwc vpw nbl[2]_20 bl[0]_19 nbl[0]_19 nbl[1]_19 bl[1]_19 vddpe vddc vddc
+  vnwc vpw bl[0]_18 nbl[0]_18 nbl[1]_18 bl[1]_18 vddpe vddc vnwc vpw bl[2]_18
+  nbl[2]_18 bl[0]_17 nbl[0]_17 nbl[1]_17 bl[1]_17 vddpe vddc vnwc vpw
+  bl[2]_17 nbl[2]_17 bl[0]_16 nbl[0]_16 nbl[1]_16 bl[1]_16 vddpe vddc vddc
+  vnwc vpw bl[2]_16 nbl[2]_16 bl[0]_15 nbl[0]_15 nbl[1]_15 bl[1]_15 vddpe
+  vddc vddc vnwc vpw nbl[2]_15 bl[0]_14 nbl[0]_14 nbl[1]_14 bl[1]_14 vddpe
+  vddc vddc vnwc vpw nbl[2]_14 bl[0]_13 nbl[0]_13 nbl[1]_13 bl[1]_13 vddpe
+  vddc vddc vnwc vpw bl[0]_12 nbl[0]_12 nbl[1]_12 bl[1]_12 vddpe vddc vddc
+  vnwc vpw bl[0]_11 nbl[0]_11 nbl[1]_11 bl[1]_11 vddpe vddc vddc vnwc vpw
+  bl[2]_11 nbl[2]_11 bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe vddc vddc
+  vnwc vpw nbl[2]_10 bl[0]_9 nbl[0]_9 nbl[1]_9 bl[1]_9 vddpe vddc vddc vnwc
+  vpw nbl[2]_9 bl[0]_8 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe vddc vddc vnwc vpw
+  bl[0]_7 nbl[0]_7 nbl[1]_7 bl[1]_7 vddpe vddc vddc vnwc vpw bl[0]_6 nbl[0]_6
+  nbl[1]_6 bl[1]_6 vddpe vddc vddc vnwc vpw bl[3]_6 bl[0]_5 nbl[0]_5 nbl[1]_5
+  bl[1]_5 vddpe vddc vddc vnwc vpw nbl[2]_5 bl[0]_4 nbl[0]_4 nbl[1]_4 bl[1]_4
+  vddpe vddc vddc vnwc vpw nbl[2]_4 bl[0]_3 nbl[0]_3 nbl[1]_3 bl[1]_3 vddpe
+  vddc vddc vnwc vpw bl[0]_2 nbl[0]_2 nbl[1]_2 bl[1]_2 vddpe vddc vddc vnwc
+  vpw bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddpe vddc vddc vnwc vpw bl[3]_1
+  bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe vddc vddc vnwc vpw bl[3]_0 vnwp_0
+  vnwc vpw vpw vnwp_1 bl[0]_31 nbl[0]_31 nbl[1]_31 bl[1]_31 vddpe vddc vddc
+  vpw bl[0]_30 nbl[0]_30 nbl[1]_30 vddc vddc vnwc vpw bl[3]_30 bl[0]_29
+  nbl[0]_29 nbl[1]_29 vddc vddc vnwc vpw nbl[3]_29 bl[3]_29 bl[0]_28
+  nbl[0]_28 nbl[1]_28 vddc vddc vnwc vpw nbl[3]_28 bl[3]_28 bl[0]_27
+  nbl[0]_27 nbl[1]_27 vddc vddc vnwc vpw nbl[3]_27 bl[3]_27 nbl[0]_26
+  nbl[1]_26 vddc vddc vnwc vpw bl[2]_26 bl[3]_26 nbl[0]_25 nbl[1]_25 vddc vpw
+  bl[2]_25 bl[3]_25 vddc bl[3]_24 vddc nbl[3]_23 bl[3]_23 vddc nbl[3]_22
+  bl[3]_22 nbl[3]_21 bl[3]_21 bl[2]_20 nbl[3]_20 bl[3]_20 bl[2]_19 nbl[2]_19
+  nbl[3]_19 bl[3]_19 vddc nbl[3]_18 bl[3]_18 vddc nbl[3]_17 bl[3]_17
+  nbl[3]_16 bl[3]_16 bl[2]_15 nbl[3]_15 bl[3]_15 bl[2]_14 nbl[3]_14 bl[3]_14
+  bl[2]_13 nbl[2]_13 nbl[3]_13 bl[3]_13 bl[2]_12 nbl[2]_12 nbl[3]_12 bl[3]_12
+  nbl[3]_11 bl[3]_11 bl[2]_10 nbl[3]_10 bl[3]_10 bl[2]_9 nbl[3]_9 bl[3]_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[2]_6
+  nbl[2]_6 nbl[3]_6 bl[2]_5 nbl[3]_5 bl[3]_5 bl[2]_4 nbl[3]_4 bl[3]_4 bl[2]_3
+  nbl[2]_3 nbl[3]_3 bl[3]_3 bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[2]_1
+  nbl[2]_1 nbl[3]_1 bl[2]_0 nbl[2]_0 nbl[3]_0 wl[1]_2 wl[0]_2
+  rf64x128mem_l_test2row
xmem_l_row_3 vddc vpw vddc vnwc bl[2]_31 nbl[2]_31 nbl[3]_31 bl[3]_31 bl[1]_30
+  vddpe bl[2]_30 nbl[2]_30 nbl[3]_30 bl[1]_29 vddpe bl[2]_29 nbl[2]_29
+  bl[1]_28 vddpe bl[2]_28 nbl[2]_28 bl[1]_27 vddpe bl[2]_27 nbl[2]_27
+  bl[0]_26 bl[1]_26 vddpe nbl[2]_26 nbl[3]_26 bl[0]_25 bl[1]_25 vddpe vddc
+  vnwc vssc nbl[2]_25 nbl[3]_25 bl[0]_24 nbl[0]_24 nbl[1]_24 bl[1]_24 vddpe
+  vddc vnwc vpw bl[2]_24 nbl[2]_24 nbl[3]_24 bl[0]_23 nbl[0]_23 nbl[1]_23
+  bl[1]_23 vddpe vddc vnwc vpw bl[2]_23 nbl[2]_23 bl[0]_22 nbl[0]_22
+  nbl[1]_22 bl[1]_22 vddpe vddc vnwc vpw bl[2]_22 nbl[2]_22 bl[0]_21
+  nbl[0]_21 nbl[1]_21 bl[1]_21 vddpe vddc vddc vnwc vpw bl[2]_21 nbl[2]_21
+  bl[0]_20 nbl[0]_20 nbl[1]_20 bl[1]_20 vddpe vddc vddc vnwc vpw nbl[2]_20
+  bl[0]_19 nbl[0]_19 nbl[1]_19 bl[1]_19 vddpe vddc vddc vnwc vpw bl[0]_18
+  nbl[0]_18 nbl[1]_18 bl[1]_18 vddpe vddc vnwc vpw bl[2]_18 nbl[2]_18
+  bl[0]_17 nbl[0]_17 nbl[1]_17 bl[1]_17 vddpe vddc vnwc vpw bl[2]_17
+  nbl[2]_17 bl[0]_16 nbl[0]_16 nbl[1]_16 bl[1]_16 vddpe vddc vddc vnwc vpw
+  bl[2]_16 nbl[2]_16 bl[0]_15 nbl[0]_15 nbl[1]_15 bl[1]_15 vddpe vddc vddc
+  vnwc vpw nbl[2]_15 bl[0]_14 nbl[0]_14 nbl[1]_14 bl[1]_14 vddpe vddc vddc
+  vnwc vpw nbl[2]_14 bl[0]_13 nbl[0]_13 nbl[1]_13 bl[1]_13 vddpe vddc vddc
+  vnwc vpw bl[0]_12 nbl[0]_12 nbl[1]_12 bl[1]_12 vddpe vddc vddc vnwc vpw
+  bl[0]_11 nbl[0]_11 nbl[1]_11 bl[1]_11 vddpe vddc vddc vnwc vpw bl[2]_11
+  nbl[2]_11 bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe vddc vddc vnwc vpw
+  nbl[2]_10 bl[0]_9 nbl[0]_9 nbl[1]_9 bl[1]_9 vddpe vddc vddc vnwc vpw
+  nbl[2]_9 bl[0]_8 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe vddc vddc vnwc vpw bl[0]_7
+  nbl[0]_7 nbl[1]_7 bl[1]_7 vddpe vddc vddc vnwc vpw bl[0]_6 nbl[0]_6
+  nbl[1]_6 bl[1]_6 vddpe vddc vddc vnwc vpw bl[3]_6 bl[0]_5 nbl[0]_5 nbl[1]_5
+  bl[1]_5 vddpe vddc vddc vnwc vpw nbl[2]_5 bl[0]_4 nbl[0]_4 nbl[1]_4 bl[1]_4
+  vddpe vddc vddc vnwc vpw nbl[2]_4 bl[0]_3 nbl[0]_3 nbl[1]_3 bl[1]_3 vddpe
+  vddc vddc vnwc vpw bl[0]_2 nbl[0]_2 nbl[1]_2 bl[1]_2 vddpe vddc vddc vnwc
+  vpw bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddpe vddc vddc vnwc vpw bl[3]_1
+  bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe vddc vddc vnwc vpw bl[3]_0 vnwc vpw
+  vnwc vnwp_1 dbl dwl bl[0]_31 nbl[0]_31 nbl[1]_31 bl[1]_31 vddpe vddc vpw
+  bl[0]_30 nbl[0]_30 nbl[1]_30 vddc vddc vnwc vpw bl[3]_30 bl[0]_29 nbl[0]_29
+  nbl[1]_29 vddc vddc vnwc vpw nbl[3]_29 bl[3]_29 bl[0]_28 nbl[0]_28
+  nbl[1]_28 vddc vddc vnwc vpw nbl[3]_28 bl[3]_28 bl[0]_27 nbl[0]_27
+  nbl[1]_27 vddc vddc vnwc vpw nbl[3]_27 bl[3]_27 nbl[0]_26 nbl[1]_26 vddc
+  vddc vnwc vpw bl[2]_26 bl[3]_26 nbl[0]_25 nbl[1]_25 vddc vpw bl[2]_25
+  bl[3]_25 vddc bl[3]_24 vddc nbl[3]_23 bl[3]_23 vddc nbl[3]_22 bl[3]_22
+  nbl[3]_21 bl[3]_21 bl[2]_20 nbl[3]_20 bl[3]_20 bl[2]_19 nbl[2]_19 nbl[3]_19
+  bl[3]_19 vddc nbl[3]_18 bl[3]_18 vddc nbl[3]_17 bl[3]_17 nbl[3]_16 bl[3]_16
+  bl[2]_15 nbl[3]_15 bl[3]_15 bl[2]_14 nbl[3]_14 bl[3]_14 bl[2]_13 nbl[2]_13
+  nbl[3]_13 bl[3]_13 bl[2]_12 nbl[2]_12 nbl[3]_12 bl[3]_12 nbl[3]_11 bl[3]_11
+  bl[2]_10 nbl[3]_10 bl[3]_10 bl[2]_9 nbl[3]_9 bl[3]_9 bl[2]_8 nbl[2]_8
+  nbl[3]_8 bl[3]_8 bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[2]_6 nbl[2]_6
+  nbl[3]_6 bl[2]_5 nbl[3]_5 bl[3]_5 bl[2]_4 nbl[3]_4 bl[3]_4 bl[2]_3 nbl[2]_3
+  nbl[3]_3 bl[3]_3 bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[2]_1 nbl[2]_1
+  nbl[3]_1 bl[2]_0 nbl[2]_0 nbl[3]_0 vnwp_0 wl[0]_3 wl[1]_3
+  rf64x128mem_l_test3row
xmem_l_row_4 vddc vnwc dbl dwl vnwc bl[2]_31 nbl[2]_31 nbl[3]_31 bl[3]_31
+  bl[1]_30 vddpe bl[2]_30 nbl[2]_30 nbl[3]_30 bl[1]_29 vddpe bl[2]_29
+  nbl[2]_29 bl[1]_28 vddpe bl[2]_28 nbl[2]_28 bl[1]_27 vddpe bl[2]_27
+  nbl[2]_27 bl[0]_26 bl[1]_26 vddpe nbl[2]_26 nbl[3]_26 bl[0]_25 bl[1]_25
+  vddpe vddc vnwc vssc nbl[2]_25 nbl[3]_25 bl[0]_24 nbl[0]_24 nbl[1]_24
+  bl[1]_24 vddpe vddc vnwc vpw bl[2]_24 nbl[2]_24 nbl[3]_24 bl[0]_23
+  nbl[0]_23 nbl[1]_23 bl[1]_23 vddpe vddc vnwc vpw bl[2]_23 nbl[2]_23
+  bl[0]_22 nbl[0]_22 nbl[1]_22 bl[1]_22 vddpe vddc vnwc vpw bl[2]_22
+  nbl[2]_22 bl[0]_21 nbl[0]_21 nbl[1]_21 bl[1]_21 vddpe vddc vddc vnwc vpw
+  bl[2]_21 nbl[2]_21 bl[0]_20 nbl[0]_20 nbl[1]_20 bl[1]_20 vddpe vddc vddc
+  vnwc vpw nbl[2]_20 bl[0]_19 nbl[0]_19 nbl[1]_19 bl[1]_19 vddpe vddc vddc
+  vnwc vpw bl[0]_18 nbl[0]_18 nbl[1]_18 bl[1]_18 vddpe vddc vnwc vpw bl[2]_18
+  nbl[2]_18 bl[0]_17 nbl[0]_17 nbl[1]_17 bl[1]_17 vddpe vddc vnwc vpw
+  bl[2]_17 nbl[2]_17 bl[0]_16 nbl[0]_16 nbl[1]_16 bl[1]_16 vddpe vddc vddc
+  vnwc vpw bl[2]_16 nbl[2]_16 bl[0]_15 nbl[0]_15 nbl[1]_15 bl[1]_15 vddpe
+  vddc vddc vnwc vpw nbl[2]_15 bl[0]_14 nbl[0]_14 nbl[1]_14 bl[1]_14 vddpe
+  vddc vddc vnwc vpw nbl[2]_14 bl[0]_13 nbl[0]_13 nbl[1]_13 bl[1]_13 vddpe
+  vddc vddc vnwc vpw bl[0]_12 nbl[0]_12 nbl[1]_12 bl[1]_12 vddpe vddc vddc
+  vnwc vpw bl[0]_11 nbl[0]_11 nbl[1]_11 bl[1]_11 vddpe vddc vddc vnwc vpw
+  bl[2]_11 nbl[2]_11 bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe vddc vddc
+  vnwc vpw nbl[2]_10 bl[0]_9 nbl[0]_9 nbl[1]_9 bl[1]_9 vddpe vddc vddc vnwc
+  vpw nbl[2]_9 bl[0]_8 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe vddc vddc vnwc vpw
+  bl[0]_7 nbl[0]_7 nbl[1]_7 bl[1]_7 vddpe vddc vddc vnwc vpw bl[0]_6 nbl[0]_6
+  nbl[1]_6 bl[1]_6 vddpe vddc vddc vnwc vpw bl[3]_6 bl[0]_5 nbl[0]_5 nbl[1]_5
+  bl[1]_5 vddpe vddc vddc vnwc vpw nbl[2]_5 bl[0]_4 nbl[0]_4 nbl[1]_4 bl[1]_4
+  vddpe vddc vddc vnwc vpw nbl[2]_4 bl[0]_3 nbl[0]_3 nbl[1]_3 bl[1]_3 vddpe
+  vddc vddc vnwc vpw bl[0]_2 nbl[0]_2 nbl[1]_2 bl[1]_2 vddpe vddc vddc vnwc
+  vpw bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddpe vddc vddc vnwc vpw bl[3]_1
+  bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe vddc vddc vnwc vpw bl[3]_0 vnwp_0
+  vnwc vpw vpw vnwp_1 bl[0]_31 nbl[0]_31 nbl[1]_31 bl[1]_31 vddpe vddc vddc
+  vpw bl[0]_30 nbl[0]_30 nbl[1]_30 vddc vddc vnwc vpw bl[3]_30 bl[0]_29
+  nbl[0]_29 nbl[1]_29 vddc vddc vnwc vpw nbl[3]_29 bl[3]_29 bl[0]_28
+  nbl[0]_28 nbl[1]_28 vddc vddc vnwc vpw nbl[3]_28 bl[3]_28 bl[0]_27
+  nbl[0]_27 nbl[1]_27 vddc vddc vnwc vpw nbl[3]_27 bl[3]_27 nbl[0]_26
+  nbl[1]_26 vddc vddc vnwc vpw bl[2]_26 bl[3]_26 nbl[0]_25 nbl[1]_25 vddc vpw
+  bl[2]_25 bl[3]_25 vddc bl[3]_24 vddc nbl[3]_23 bl[3]_23 vddc nbl[3]_22
+  bl[3]_22 nbl[3]_21 bl[3]_21 bl[2]_20 nbl[3]_20 bl[3]_20 bl[2]_19 nbl[2]_19
+  nbl[3]_19 bl[3]_19 vddc nbl[3]_18 bl[3]_18 vddc nbl[3]_17 bl[3]_17
+  nbl[3]_16 bl[3]_16 bl[2]_15 nbl[3]_15 bl[3]_15 bl[2]_14 nbl[3]_14 bl[3]_14
+  bl[2]_13 nbl[2]_13 nbl[3]_13 bl[3]_13 bl[2]_12 nbl[2]_12 nbl[3]_12 bl[3]_12
+  nbl[3]_11 bl[3]_11 bl[2]_10 nbl[3]_10 bl[3]_10 bl[2]_9 nbl[3]_9 bl[3]_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[2]_6
+  nbl[2]_6 nbl[3]_6 bl[2]_5 nbl[3]_5 bl[3]_5 bl[2]_4 nbl[3]_4 bl[3]_4 bl[2]_3
+  nbl[2]_3 nbl[3]_3 bl[3]_3 bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[2]_1
+  nbl[2]_1 nbl[3]_1 bl[2]_0 nbl[2]_0 nbl[3]_0 wl[1]_4 wl[0]_4
+  rf64x128mem_l_test4row
xmem_l_row_5 vddc vpw vddc vnwc bl[2]_31 nbl[2]_31 nbl[3]_31 bl[3]_31 bl[1]_30
+  vddpe bl[2]_30 nbl[2]_30 nbl[3]_30 bl[1]_29 vddpe bl[2]_29 nbl[2]_29
+  bl[1]_28 vddpe bl[2]_28 nbl[2]_28 bl[1]_27 vddpe bl[2]_27 nbl[2]_27
+  bl[0]_26 bl[1]_26 vddpe nbl[2]_26 nbl[3]_26 bl[0]_25 bl[1]_25 vddpe vddc
+  vnwc vssc nbl[2]_25 nbl[3]_25 bl[0]_24 nbl[0]_24 nbl[1]_24 bl[1]_24 vddpe
+  vddc vnwc vpw bl[2]_24 nbl[2]_24 nbl[3]_24 bl[0]_23 nbl[0]_23 nbl[1]_23
+  bl[1]_23 vddpe vddc vnwc vpw bl[2]_23 nbl[2]_23 bl[0]_22 nbl[0]_22
+  nbl[1]_22 bl[1]_22 vddpe vddc vnwc vpw bl[2]_22 nbl[2]_22 bl[0]_21
+  nbl[0]_21 nbl[1]_21 bl[1]_21 vddpe vddc vddc vnwc vpw bl[2]_21 nbl[2]_21
+  bl[0]_20 nbl[0]_20 nbl[1]_20 bl[1]_20 vddpe vddc vddc vnwc vpw nbl[2]_20
+  bl[0]_19 nbl[0]_19 nbl[1]_19 bl[1]_19 vddpe vddc vddc vnwc vpw bl[0]_18
+  nbl[0]_18 nbl[1]_18 bl[1]_18 vddpe vddc vnwc vpw bl[2]_18 nbl[2]_18
+  bl[0]_17 nbl[0]_17 nbl[1]_17 bl[1]_17 vddpe vddc vnwc vpw bl[2]_17
+  nbl[2]_17 bl[0]_16 nbl[0]_16 nbl[1]_16 bl[1]_16 vddpe vddc vddc vnwc vpw
+  bl[2]_16 nbl[2]_16 bl[0]_15 nbl[0]_15 nbl[1]_15 bl[1]_15 vddpe vddc vddc
+  vnwc vpw nbl[2]_15 bl[0]_14 nbl[0]_14 nbl[1]_14 bl[1]_14 vddpe vddc vddc
+  vnwc vpw nbl[2]_14 bl[0]_13 nbl[0]_13 nbl[1]_13 bl[1]_13 vddpe vddc vddc
+  vnwc vpw bl[0]_12 nbl[0]_12 nbl[1]_12 bl[1]_12 vddpe vddc vddc vnwc vpw
+  bl[0]_11 nbl[0]_11 nbl[1]_11 bl[1]_11 vddpe vddc vddc vnwc vpw bl[2]_11
+  nbl[2]_11 bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe vddc vddc vnwc vpw
+  nbl[2]_10 bl[0]_9 nbl[0]_9 nbl[1]_9 bl[1]_9 vddpe vddc vddc vnwc vpw
+  nbl[2]_9 bl[0]_8 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe vddc vddc vnwc vpw bl[0]_7
+  nbl[0]_7 nbl[1]_7 bl[1]_7 vddpe vddc vddc vnwc vpw bl[0]_6 nbl[0]_6
+  nbl[1]_6 bl[1]_6 vddpe vddc vddc vnwc vpw bl[3]_6 bl[0]_5 nbl[0]_5 nbl[1]_5
+  bl[1]_5 vddpe vddc vddc vnwc vpw nbl[2]_5 bl[0]_4 nbl[0]_4 nbl[1]_4 bl[1]_4
+  vddpe vddc vddc vnwc vpw nbl[2]_4 bl[0]_3 nbl[0]_3 nbl[1]_3 bl[1]_3 vddpe
+  vddc vddc vnwc vpw bl[0]_2 nbl[0]_2 nbl[1]_2 bl[1]_2 vddpe vddc vddc vnwc
+  vpw bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddpe vddc vddc vnwc vpw bl[3]_1
+  bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe vddc vddc vnwc vpw bl[3]_0 vnwc vpw
+  vnwc vnwp_1 dbl dwl bl[0]_31 nbl[0]_31 nbl[1]_31 bl[1]_31 vddpe vddc vpw
+  bl[0]_30 nbl[0]_30 nbl[1]_30 vddc vddc vnwc vpw bl[3]_30 bl[0]_29 nbl[0]_29
+  nbl[1]_29 vddc vddc vnwc vpw nbl[3]_29 bl[3]_29 bl[0]_28 nbl[0]_28
+  nbl[1]_28 vddc vddc vnwc vpw nbl[3]_28 bl[3]_28 bl[0]_27 nbl[0]_27
+  nbl[1]_27 vddc vddc vnwc vpw nbl[3]_27 bl[3]_27 nbl[0]_26 nbl[1]_26 vddc
+  vddc vnwc vpw bl[2]_26 bl[3]_26 nbl[0]_25 nbl[1]_25 vddc vpw bl[2]_25
+  bl[3]_25 vddc bl[3]_24 vddc nbl[3]_23 bl[3]_23 vddc nbl[3]_22 bl[3]_22
+  nbl[3]_21 bl[3]_21 bl[2]_20 nbl[3]_20 bl[3]_20 bl[2]_19 nbl[2]_19 nbl[3]_19
+  bl[3]_19 vddc nbl[3]_18 bl[3]_18 vddc nbl[3]_17 bl[3]_17 nbl[3]_16 bl[3]_16
+  bl[2]_15 nbl[3]_15 bl[3]_15 bl[2]_14 nbl[3]_14 bl[3]_14 bl[2]_13 nbl[2]_13
+  nbl[3]_13 bl[3]_13 bl[2]_12 nbl[2]_12 nbl[3]_12 bl[3]_12 nbl[3]_11 bl[3]_11
+  bl[2]_10 nbl[3]_10 bl[3]_10 bl[2]_9 nbl[3]_9 bl[3]_9 bl[2]_8 nbl[2]_8
+  nbl[3]_8 bl[3]_8 bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[2]_6 nbl[2]_6
+  nbl[3]_6 bl[2]_5 nbl[3]_5 bl[3]_5 bl[2]_4 nbl[3]_4 bl[3]_4 bl[2]_3 nbl[2]_3
+  nbl[3]_3 bl[3]_3 bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[2]_1 nbl[2]_1
+  nbl[3]_1 bl[2]_0 nbl[2]_0 nbl[3]_0 vnwp_0 wl[0]_5 wl[1]_5
+  rf64x128mem_l_test5row
xmem_l_row_9 vddc vpw vddc vnwc bl[2]_31 nbl[2]_31 nbl[3]_31 bl[3]_31 bl[1]_30
+  vddpe bl[2]_30 nbl[2]_30 nbl[3]_30 bl[1]_29 vddpe bl[2]_29 nbl[2]_29
+  bl[1]_28 vddpe bl[2]_28 nbl[2]_28 bl[1]_27 vddpe bl[2]_27 nbl[2]_27
+  bl[0]_26 bl[1]_26 vddpe nbl[2]_26 nbl[3]_26 bl[0]_25 bl[1]_25 vddpe vddc
+  vnwc vssc nbl[2]_25 nbl[3]_25 bl[0]_24 nbl[0]_24 nbl[1]_24 bl[1]_24 vddpe
+  vddc vnwc vpw bl[2]_24 nbl[2]_24 nbl[3]_24 bl[0]_23 nbl[0]_23 nbl[1]_23
+  bl[1]_23 vddpe vddc vnwc vpw bl[2]_23 nbl[2]_23 bl[0]_22 nbl[0]_22
+  nbl[1]_22 bl[1]_22 vddpe vddc vnwc vpw bl[2]_22 nbl[2]_22 bl[0]_21
+  nbl[0]_21 nbl[1]_21 bl[1]_21 vddpe vddc vddc vnwc vpw bl[2]_21 nbl[2]_21
+  bl[0]_20 nbl[0]_20 nbl[1]_20 bl[1]_20 vddpe vddc vddc vnwc vpw nbl[2]_20
+  bl[0]_19 nbl[0]_19 nbl[1]_19 bl[1]_19 vddpe vddc vddc vnwc vpw bl[0]_18
+  nbl[0]_18 nbl[1]_18 bl[1]_18 vddpe vddc vnwc vpw bl[2]_18 nbl[2]_18
+  bl[0]_17 nbl[0]_17 nbl[1]_17 bl[1]_17 vddpe vddc vnwc vpw bl[2]_17
+  nbl[2]_17 bl[0]_16 nbl[0]_16 nbl[1]_16 bl[1]_16 vddpe vddc vddc vnwc vpw
+  bl[2]_16 nbl[2]_16 bl[0]_15 nbl[0]_15 nbl[1]_15 bl[1]_15 vddpe vddc vddc
+  vnwc vpw nbl[2]_15 bl[0]_14 nbl[0]_14 nbl[1]_14 bl[1]_14 vddpe vddc vddc
+  vnwc vpw nbl[2]_14 bl[0]_13 nbl[0]_13 nbl[1]_13 bl[1]_13 vddpe vddc vddc
+  vnwc vpw bl[0]_12 nbl[0]_12 nbl[1]_12 bl[1]_12 vddpe vddc vddc vnwc vpw
+  bl[0]_11 nbl[0]_11 nbl[1]_11 bl[1]_11 vddpe vddc vddc vnwc vpw bl[2]_11
+  nbl[2]_11 bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe vddc vddc vnwc vpw
+  nbl[2]_10 bl[0]_9 nbl[0]_9 nbl[1]_9 bl[1]_9 vddpe vddc vddc vnwc vpw
+  nbl[2]_9 bl[0]_8 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe vddc vddc vnwc vpw bl[0]_7
+  nbl[0]_7 nbl[1]_7 bl[1]_7 vddpe vddc vddc vnwc vpw bl[0]_6 nbl[0]_6
+  nbl[1]_6 bl[1]_6 vddpe vddc vddc vnwc vpw bl[3]_6 bl[0]_5 nbl[0]_5 nbl[1]_5
+  bl[1]_5 vddpe vddc vddc vnwc vpw nbl[2]_5 bl[0]_4 nbl[0]_4 nbl[1]_4 bl[1]_4
+  vddpe vddc vddc vnwc vpw nbl[2]_4 bl[0]_3 nbl[0]_3 nbl[1]_3 bl[1]_3 vddpe
+  vddc vddc vnwc vpw bl[0]_2 nbl[0]_2 nbl[1]_2 bl[1]_2 vddpe vddc vddc vnwc
+  vpw bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddpe vddc vddc vnwc vpw bl[3]_1
+  bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe vddc vddc vnwc vpw bl[3]_0 vnwc vpw
+  vnwc vnwp_1 dbl dwl bl[0]_31 nbl[0]_31 nbl[1]_31 bl[1]_31 vddpe vddc vpw
+  bl[0]_30 nbl[0]_30 nbl[1]_30 vddc vddc vnwc vpw bl[3]_30 bl[0]_29 nbl[0]_29
+  nbl[1]_29 vddc vddc vnwc vpw nbl[3]_29 bl[3]_29 bl[0]_28 nbl[0]_28
+  nbl[1]_28 vddc vddc vnwc vpw nbl[3]_28 bl[3]_28 bl[0]_27 nbl[0]_27
+  nbl[1]_27 vddc vddc vnwc vpw nbl[3]_27 bl[3]_27 nbl[0]_26 nbl[1]_26 vddc
+  vddc vnwc vpw bl[2]_26 bl[3]_26 nbl[0]_25 nbl[1]_25 vddc vpw bl[2]_25
+  bl[3]_25 vddc bl[3]_24 vddc nbl[3]_23 bl[3]_23 vddc nbl[3]_22 bl[3]_22
+  nbl[3]_21 bl[3]_21 bl[2]_20 nbl[3]_20 bl[3]_20 bl[2]_19 nbl[2]_19 nbl[3]_19
+  bl[3]_19 vddc nbl[3]_18 bl[3]_18 vddc nbl[3]_17 bl[3]_17 nbl[3]_16 bl[3]_16
+  bl[2]_15 nbl[3]_15 bl[3]_15 bl[2]_14 nbl[3]_14 bl[3]_14 bl[2]_13 nbl[2]_13
+  nbl[3]_13 bl[3]_13 bl[2]_12 nbl[2]_12 nbl[3]_12 bl[3]_12 nbl[3]_11 bl[3]_11
+  bl[2]_10 nbl[3]_10 bl[3]_10 bl[2]_9 nbl[3]_9 bl[3]_9 bl[2]_8 nbl[2]_8
+  nbl[3]_8 bl[3]_8 bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[2]_6 nbl[2]_6
+  nbl[3]_6 bl[2]_5 nbl[3]_5 bl[3]_5 bl[2]_4 nbl[3]_4 bl[3]_4 bl[2]_3 nbl[2]_3
+  nbl[3]_3 bl[3]_3 bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[2]_1 nbl[2]_1
+  nbl[3]_1 bl[2]_0 nbl[2]_0 nbl[3]_0 vnwp_0 wl[0]_9 wl[1]_9
+  rf64x128mem_l_test9row
xmem_l_row_bot vddc vnwc dbl dwl vnwc bl[2]_31 nbl[2]_31 nbl[3]_31 bl[3]_31
+  bl[1]_30 vddpe bl[2]_30 nbl[2]_30 nbl[3]_30 bl[1]_29 vddpe bl[2]_29
+  nbl[2]_29 bl[1]_28 vddpe bl[2]_28 nbl[2]_28 bl[1]_27 vddpe bl[2]_27
+  nbl[2]_27 bl[0]_26 bl[1]_26 vddpe nbl[2]_26 nbl[3]_26 bl[0]_25 bl[1]_25
+  vddpe vddc vnwc vssc nbl[2]_25 nbl[3]_25 bl[0]_24 nbl[0]_24 nbl[1]_24
+  bl[1]_24 vddpe vddc vnwc vpw bl[2]_24 nbl[2]_24 nbl[3]_24 bl[0]_23
+  nbl[0]_23 nbl[1]_23 bl[1]_23 vddpe vddc vnwc vpw bl[2]_23 nbl[2]_23
+  bl[0]_22 nbl[0]_22 nbl[1]_22 bl[1]_22 vddpe vddc vnwc vpw bl[2]_22
+  nbl[2]_22 bl[0]_21 nbl[0]_21 nbl[1]_21 bl[1]_21 vddpe vddc vddc vnwc vpw
+  bl[2]_21 nbl[2]_21 bl[0]_20 nbl[0]_20 nbl[1]_20 bl[1]_20 vddpe vddc vddc
+  vnwc vpw nbl[2]_20 bl[0]_19 nbl[0]_19 nbl[1]_19 bl[1]_19 vddpe vddc vddc
+  vnwc vpw bl[0]_18 nbl[0]_18 nbl[1]_18 bl[1]_18 vddpe vddc vnwc vpw bl[2]_18
+  nbl[2]_18 bl[0]_17 nbl[0]_17 nbl[1]_17 bl[1]_17 vddpe vddc vnwc vpw
+  bl[2]_17 nbl[2]_17 bl[0]_16 nbl[0]_16 nbl[1]_16 bl[1]_16 vddpe vddc vddc
+  vnwc vpw bl[2]_16 nbl[2]_16 bl[0]_15 nbl[0]_15 nbl[1]_15 bl[1]_15 vddpe
+  vddc vddc vnwc vpw nbl[2]_15 bl[0]_14 nbl[0]_14 nbl[1]_14 bl[1]_14 vddpe
+  vddc vddc vnwc vpw nbl[2]_14 bl[0]_13 nbl[0]_13 nbl[1]_13 bl[1]_13 vddpe
+  vddc vddc vnwc vpw bl[0]_12 nbl[0]_12 nbl[1]_12 bl[1]_12 vddpe vddc vddc
+  vnwc vpw bl[0]_11 nbl[0]_11 nbl[1]_11 bl[1]_11 vddpe vddc vddc vnwc vpw
+  bl[2]_11 nbl[2]_11 bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe vddc vddc
+  vnwc vpw nbl[2]_10 bl[0]_9 nbl[0]_9 nbl[1]_9 bl[1]_9 vddpe vddc vddc vnwc
+  vpw nbl[2]_9 bl[0]_8 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe vddc vddc vnwc vpw
+  bl[0]_7 nbl[0]_7 nbl[1]_7 bl[1]_7 vddpe vddc vddc vnwc vpw bl[0]_6 nbl[0]_6
+  nbl[1]_6 bl[1]_6 vddpe vddc vddc vnwc vpw bl[3]_6 bl[0]_5 nbl[0]_5 nbl[1]_5
+  bl[1]_5 vddpe vddc vddc vnwc vpw nbl[2]_5 bl[0]_4 nbl[0]_4 nbl[1]_4 bl[1]_4
+  vddpe vddc vddc vnwc vpw nbl[2]_4 bl[0]_3 nbl[0]_3 nbl[1]_3 bl[1]_3 vddpe
+  vddc vddc vnwc vpw bl[0]_2 nbl[0]_2 nbl[1]_2 bl[1]_2 vddpe vddc vddc vnwc
+  vpw bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddpe vddc vddc vnwc vpw bl[3]_1
+  bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe vddc vddc vnwc vssc vpw bl[3]_0
+  vnwp_0 vnwc vpw vpw vnwp_1 bl[0]_31 nbl[0]_31 nbl[1]_31 bl[1]_31 vddpe vddc
+  vddc vssc vpw bl[0]_30 nbl[0]_30 nbl[1]_30 vddc vddc vnwc vpw bl[3]_30
+  bl[0]_29 nbl[0]_29 nbl[1]_29 vddc vddc vnwc vpw nbl[3]_29 bl[3]_29 bl[0]_28
+  nbl[0]_28 nbl[1]_28 vddc vddc vnwc vpw nbl[3]_28 bl[3]_28 bl[0]_27
+  nbl[0]_27 nbl[1]_27 vddc vddc vnwc vpw nbl[3]_27 bl[3]_27 nbl[0]_26
+  nbl[1]_26 vddc vddc vnwc vpw bl[2]_26 bl[3]_26 nbl[0]_25 nbl[1]_25 vddc vpw
+  bl[2]_25 bl[3]_25 vddc bl[3]_24 vddc nbl[3]_23 bl[3]_23 vddc nbl[3]_22
+  bl[3]_22 nbl[3]_21 bl[3]_21 bl[2]_20 nbl[3]_20 bl[3]_20 bl[2]_19 nbl[2]_19
+  nbl[3]_19 bl[3]_19 vddc nbl[3]_18 bl[3]_18 vddc nbl[3]_17 bl[3]_17
+  nbl[3]_16 bl[3]_16 bl[2]_15 nbl[3]_15 bl[3]_15 bl[2]_14 nbl[3]_14 bl[3]_14
+  bl[2]_13 nbl[2]_13 nbl[3]_13 bl[3]_13 bl[2]_12 nbl[2]_12 nbl[3]_12 bl[3]_12
+  nbl[3]_11 bl[3]_11 bl[2]_10 nbl[3]_10 bl[3]_10 bl[2]_9 nbl[3]_9 bl[3]_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[2]_6
+  nbl[2]_6 nbl[3]_6 bl[2]_5 nbl[3]_5 bl[3]_5 bl[2]_4 nbl[3]_4 bl[3]_4 bl[2]_3
+  nbl[2]_3 nbl[3]_3 bl[3]_3 bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[2]_1
+  nbl[2]_1 nbl[3]_1 bl[2]_0 nbl[2]_0 nbl[3]_0 wl[1]_0 wl[0]_0
+  rf64x128mem_l_bot_row
xmem_l_row_mid vddc vpw vddc vnwc bl[2]_31 nbl[2]_31 nbl[3]_31 bl[3]_31
+  bl[1]_30 vddpe bl[2]_30 nbl[2]_30 nbl[3]_30 bl[1]_29 vddpe bl[2]_29
+  nbl[2]_29 bl[1]_28 vddpe bl[2]_28 nbl[2]_28 bl[1]_27 vddpe bl[2]_27
+  nbl[2]_27 bl[0]_26 bl[1]_26 vddpe nbl[2]_26 nbl[3]_26 bl[0]_25 bl[1]_25
+  vddpe vddc vnwc vssc nbl[2]_25 nbl[3]_25 bl[0]_24 nbl[0]_24 nbl[1]_24
+  bl[1]_24 vddpe vddc vnwc vpw bl[2]_24 nbl[2]_24 nbl[3]_24 bl[0]_23
+  nbl[0]_23 nbl[1]_23 bl[1]_23 vddpe vddc vnwc vpw bl[2]_23 nbl[2]_23
+  bl[0]_22 nbl[0]_22 nbl[1]_22 bl[1]_22 vddpe vddc vnwc vpw bl[2]_22
+  nbl[2]_22 bl[0]_21 nbl[0]_21 nbl[1]_21 bl[1]_21 vddpe vddc vddc vnwc vpw
+  bl[2]_21 nbl[2]_21 bl[0]_20 nbl[0]_20 nbl[1]_20 bl[1]_20 vddpe vddc vddc
+  vnwc vpw nbl[2]_20 bl[0]_19 nbl[0]_19 nbl[1]_19 bl[1]_19 vddpe vddc vddc
+  vnwc vpw bl[0]_18 nbl[0]_18 nbl[1]_18 bl[1]_18 vddpe vddc vnwc vpw bl[2]_18
+  nbl[2]_18 bl[0]_17 nbl[0]_17 nbl[1]_17 bl[1]_17 vddpe vddc vnwc vpw
+  bl[2]_17 nbl[2]_17 bl[0]_16 nbl[0]_16 nbl[1]_16 bl[1]_16 vddpe vddc vddc
+  vnwc vpw bl[2]_16 nbl[2]_16 bl[0]_15 nbl[0]_15 nbl[1]_15 bl[1]_15 vddpe
+  vddc vddc vnwc vpw nbl[2]_15 bl[0]_14 nbl[0]_14 nbl[1]_14 bl[1]_14 vddpe
+  vddc vddc vnwc vpw nbl[2]_14 bl[0]_13 nbl[0]_13 nbl[1]_13 bl[1]_13 vddpe
+  vddc vddc vnwc vpw bl[0]_12 nbl[0]_12 nbl[1]_12 bl[1]_12 vddpe vddc vddc
+  vnwc vpw bl[0]_11 nbl[0]_11 nbl[1]_11 bl[1]_11 vddpe vddc vddc vnwc vpw
+  bl[2]_11 nbl[2]_11 bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe vddc vddc
+  vnwc vpw nbl[2]_10 bl[0]_9 nbl[0]_9 nbl[1]_9 bl[1]_9 vddpe vddc vddc vnwc
+  vpw nbl[2]_9 bl[0]_8 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe vddc vddc vnwc vpw
+  bl[0]_7 nbl[0]_7 nbl[1]_7 bl[1]_7 vddpe vddc vddc vnwc vpw bl[0]_6 nbl[0]_6
+  nbl[1]_6 bl[1]_6 vddpe vddc vddc vnwc vpw bl[3]_6 bl[0]_5 nbl[0]_5 nbl[1]_5
+  bl[1]_5 vddpe vddc vddc vnwc vpw nbl[2]_5 bl[0]_4 nbl[0]_4 nbl[1]_4 bl[1]_4
+  vddpe vddc vddc vnwc vpw nbl[2]_4 bl[0]_3 nbl[0]_3 nbl[1]_3 bl[1]_3 vddpe
+  vddc vddc vnwc vpw bl[0]_2 nbl[0]_2 nbl[1]_2 bl[1]_2 vddpe vddc vddc vnwc
+  vpw bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddpe vddc vddc vnwc vpw bl[3]_1
+  bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe vddc vddc vnwc vpw bl[3]_0 vnwc vpw
+  vnwc vnwp_1 dbl dwl bl[0]_31 nbl[0]_31 nbl[1]_31 bl[1]_31 vddpe vddc vpw
+  bl[0]_30 nbl[0]_30 nbl[1]_30 vddc vddc vnwc vpw bl[3]_30 bl[0]_29 nbl[0]_29
+  nbl[1]_29 vddc vddc vnwc vpw nbl[3]_29 bl[3]_29 bl[0]_28 nbl[0]_28
+  nbl[1]_28 vddc vddc vnwc vpw nbl[3]_28 bl[3]_28 bl[0]_27 nbl[0]_27
+  nbl[1]_27 vddc vddc vnwc vpw nbl[3]_27 bl[3]_27 nbl[0]_26 nbl[1]_26 vddc
+  vddc vnwc vpw bl[2]_26 bl[3]_26 nbl[0]_25 nbl[1]_25 vddc vpw bl[2]_25
+  bl[3]_25 vddc bl[3]_24 vddc nbl[3]_23 bl[3]_23 vddc nbl[3]_22 bl[3]_22
+  nbl[3]_21 bl[3]_21 bl[2]_20 nbl[3]_20 bl[3]_20 bl[2]_19 nbl[2]_19 nbl[3]_19
+  bl[3]_19 vddc nbl[3]_18 bl[3]_18 vddc nbl[3]_17 bl[3]_17 nbl[3]_16 bl[3]_16
+  bl[2]_15 nbl[3]_15 bl[3]_15 bl[2]_14 nbl[3]_14 bl[3]_14 bl[2]_13 nbl[2]_13
+  nbl[3]_13 bl[3]_13 bl[2]_12 nbl[2]_12 nbl[3]_12 bl[3]_12 nbl[3]_11 bl[3]_11
+  bl[2]_10 nbl[3]_10 bl[3]_10 bl[2]_9 nbl[3]_9 bl[3]_9 bl[2]_8 nbl[2]_8
+  nbl[3]_8 bl[3]_8 bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[2]_6 nbl[2]_6
+  nbl[3]_6 bl[2]_5 nbl[3]_5 bl[3]_5 bl[2]_4 nbl[3]_4 bl[3]_4 bl[2]_3 nbl[2]_3
+  nbl[3]_3 bl[3]_3 bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[2]_1 nbl[2]_1
+  nbl[3]_1 bl[2]_0 nbl[2]_0 nbl[3]_0 vnwp_0 wl[0]_7 wl[1]_7
+  rf64x128mem_l_mid_row
xmem_l_row_midb vddc vnwc dbl dwl vnwc bl[2]_31 nbl[2]_31 nbl[3]_31 bl[3]_31
+  bl[1]_30 vddpe bl[2]_30 nbl[2]_30 nbl[3]_30 bl[1]_29 vddpe bl[2]_29
+  nbl[2]_29 bl[1]_28 vddpe bl[2]_28 nbl[2]_28 bl[1]_27 vddpe bl[2]_27
+  nbl[2]_27 bl[0]_26 bl[1]_26 vddpe nbl[2]_26 nbl[3]_26 bl[0]_25 bl[1]_25
+  vddpe vddc vnwc vssc nbl[2]_25 nbl[3]_25 bl[0]_24 nbl[0]_24 nbl[1]_24
+  bl[1]_24 vddpe vddc vnwc vpw bl[2]_24 nbl[2]_24 nbl[3]_24 bl[0]_23
+  nbl[0]_23 nbl[1]_23 bl[1]_23 vddpe vddc vnwc vpw bl[2]_23 nbl[2]_23
+  bl[0]_22 nbl[0]_22 nbl[1]_22 bl[1]_22 vddpe vddc vnwc vpw bl[2]_22
+  nbl[2]_22 bl[0]_21 nbl[0]_21 nbl[1]_21 bl[1]_21 vddpe vddc vddc vnwc vpw
+  bl[2]_21 nbl[2]_21 bl[0]_20 nbl[0]_20 nbl[1]_20 bl[1]_20 vddpe vddc vddc
+  vnwc vpw nbl[2]_20 bl[0]_19 nbl[0]_19 nbl[1]_19 bl[1]_19 vddpe vddc vddc
+  vnwc vpw bl[0]_18 nbl[0]_18 nbl[1]_18 bl[1]_18 vddpe vddc vnwc vpw bl[2]_18
+  nbl[2]_18 bl[0]_17 nbl[0]_17 nbl[1]_17 bl[1]_17 vddpe vddc vnwc vpw
+  bl[2]_17 nbl[2]_17 bl[0]_16 nbl[0]_16 nbl[1]_16 bl[1]_16 vddpe vddc vddc
+  vnwc vpw bl[2]_16 nbl[2]_16 bl[0]_15 nbl[0]_15 nbl[1]_15 bl[1]_15 vddpe
+  vddc vddc vnwc vpw nbl[2]_15 bl[0]_14 nbl[0]_14 nbl[1]_14 bl[1]_14 vddpe
+  vddc vddc vnwc vpw nbl[2]_14 bl[0]_13 nbl[0]_13 nbl[1]_13 bl[1]_13 vddpe
+  vddc vddc vnwc vpw bl[0]_12 nbl[0]_12 nbl[1]_12 bl[1]_12 vddpe vddc vddc
+  vnwc vpw bl[0]_11 nbl[0]_11 nbl[1]_11 bl[1]_11 vddpe vddc vddc vnwc vpw
+  bl[2]_11 nbl[2]_11 bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe vddc vddc
+  vnwc vpw nbl[2]_10 bl[0]_9 nbl[0]_9 nbl[1]_9 bl[1]_9 vddpe vddc vddc vnwc
+  vpw nbl[2]_9 bl[0]_8 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe vddc vddc vnwc vpw
+  bl[0]_7 nbl[0]_7 nbl[1]_7 bl[1]_7 vddpe vddc vddc vnwc vpw bl[0]_6 nbl[0]_6
+  nbl[1]_6 bl[1]_6 vddpe vddc vddc vnwc vpw bl[3]_6 bl[0]_5 nbl[0]_5 nbl[1]_5
+  bl[1]_5 vddpe vddc vddc vnwc vpw nbl[2]_5 bl[0]_4 nbl[0]_4 nbl[1]_4 bl[1]_4
+  vddpe vddc vddc vnwc vpw nbl[2]_4 bl[0]_3 nbl[0]_3 nbl[1]_3 bl[1]_3 vddpe
+  vddc vddc vnwc vpw bl[0]_2 nbl[0]_2 nbl[1]_2 bl[1]_2 vddpe vddc vddc vnwc
+  vpw bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddpe vddc vddc vnwc vpw bl[3]_1
+  bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe vddc vddc vnwc vpw bl[3]_0 vnwp_0
+  vnwc vpw vpw vnwp_1 bl[0]_31 nbl[0]_31 nbl[1]_31 bl[1]_31 vddpe vddc vddc
+  vpw bl[0]_30 nbl[0]_30 nbl[1]_30 vddc vddc vnwc vpw bl[3]_30 bl[0]_29
+  nbl[0]_29 nbl[1]_29 vddc vddc vnwc vpw nbl[3]_29 bl[3]_29 bl[0]_28
+  nbl[0]_28 nbl[1]_28 vddc vddc vnwc vpw nbl[3]_28 bl[3]_28 bl[0]_27
+  nbl[0]_27 nbl[1]_27 vddc vddc vnwc vpw nbl[3]_27 bl[3]_27 nbl[0]_26
+  nbl[1]_26 vddc vddc vnwc vpw bl[2]_26 bl[3]_26 nbl[0]_25 nbl[1]_25 vddc vpw
+  bl[2]_25 bl[3]_25 vddc bl[3]_24 vddc nbl[3]_23 bl[3]_23 vddc nbl[3]_22
+  bl[3]_22 nbl[3]_21 bl[3]_21 bl[2]_20 nbl[3]_20 bl[3]_20 bl[2]_19 nbl[2]_19
+  nbl[3]_19 bl[3]_19 vddc nbl[3]_18 bl[3]_18 vddc nbl[3]_17 bl[3]_17
+  nbl[3]_16 bl[3]_16 bl[2]_15 nbl[3]_15 bl[3]_15 bl[2]_14 nbl[3]_14 bl[3]_14
+  bl[2]_13 nbl[2]_13 nbl[3]_13 bl[3]_13 bl[2]_12 nbl[2]_12 nbl[3]_12 bl[3]_12
+  nbl[3]_11 bl[3]_11 bl[2]_10 nbl[3]_10 bl[3]_10 bl[2]_9 nbl[3]_9 bl[3]_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[2]_6
+  nbl[2]_6 nbl[3]_6 bl[2]_5 nbl[3]_5 bl[3]_5 bl[2]_4 nbl[3]_4 bl[3]_4 bl[2]_3
+  nbl[2]_3 nbl[3]_3 bl[3]_3 bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[2]_1
+  nbl[2]_1 nbl[3]_1 bl[2]_0 nbl[2]_0 nbl[3]_0 wl[1]_6 wl[0]_6
+  rf64x128mem_l_midb_row
xmem_l_row_midt vddc vnwc dbl dwl vnwc bl[2]_31 nbl[2]_31 nbl[3]_31 bl[3]_31
+  bl[1]_30 vddpe bl[2]_30 nbl[2]_30 nbl[3]_30 bl[1]_29 vddpe bl[2]_29
+  nbl[2]_29 bl[1]_28 vddpe bl[2]_28 nbl[2]_28 bl[1]_27 vddpe bl[2]_27
+  nbl[2]_27 bl[0]_26 bl[1]_26 vddpe nbl[2]_26 nbl[3]_26 bl[0]_25 bl[1]_25
+  vddpe vddc vnwc vssc nbl[2]_25 nbl[3]_25 bl[0]_24 nbl[0]_24 nbl[1]_24
+  bl[1]_24 vddpe vddc vnwc vpw bl[2]_24 nbl[2]_24 nbl[3]_24 bl[0]_23
+  nbl[0]_23 nbl[1]_23 bl[1]_23 vddpe vddc vnwc vpw bl[2]_23 nbl[2]_23
+  bl[0]_22 nbl[0]_22 nbl[1]_22 bl[1]_22 vddpe vddc vnwc vpw bl[2]_22
+  nbl[2]_22 bl[0]_21 nbl[0]_21 nbl[1]_21 bl[1]_21 vddpe vddc vddc vnwc vpw
+  bl[2]_21 nbl[2]_21 bl[0]_20 nbl[0]_20 nbl[1]_20 bl[1]_20 vddpe vddc vddc
+  vnwc vpw nbl[2]_20 bl[0]_19 nbl[0]_19 nbl[1]_19 bl[1]_19 vddpe vddc vddc
+  vnwc vpw bl[0]_18 nbl[0]_18 nbl[1]_18 bl[1]_18 vddpe vddc vnwc vpw bl[2]_18
+  nbl[2]_18 bl[0]_17 nbl[0]_17 nbl[1]_17 bl[1]_17 vddpe vddc vnwc vpw
+  bl[2]_17 nbl[2]_17 bl[0]_16 nbl[0]_16 nbl[1]_16 bl[1]_16 vddpe vddc vddc
+  vnwc vpw bl[2]_16 nbl[2]_16 bl[0]_15 nbl[0]_15 nbl[1]_15 bl[1]_15 vddpe
+  vddc vddc vnwc vpw nbl[2]_15 bl[0]_14 nbl[0]_14 nbl[1]_14 bl[1]_14 vddpe
+  vddc vddc vnwc vpw nbl[2]_14 bl[0]_13 nbl[0]_13 nbl[1]_13 bl[1]_13 vddpe
+  vddc vddc vnwc vpw bl[0]_12 nbl[0]_12 nbl[1]_12 bl[1]_12 vddpe vddc vddc
+  vnwc vpw bl[0]_11 nbl[0]_11 nbl[1]_11 bl[1]_11 vddpe vddc vddc vnwc vpw
+  bl[2]_11 nbl[2]_11 bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe vddc vddc
+  vnwc vpw nbl[2]_10 bl[0]_9 nbl[0]_9 nbl[1]_9 bl[1]_9 vddpe vddc vddc vnwc
+  vpw nbl[2]_9 bl[0]_8 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe vddc vddc vnwc vpw
+  bl[0]_7 nbl[0]_7 nbl[1]_7 bl[1]_7 vddpe vddc vddc vnwc vpw bl[0]_6 nbl[0]_6
+  nbl[1]_6 bl[1]_6 vddpe vddc vddc vnwc vpw bl[3]_6 bl[0]_5 nbl[0]_5 nbl[1]_5
+  bl[1]_5 vddpe vddc vddc vnwc vpw nbl[2]_5 bl[0]_4 nbl[0]_4 nbl[1]_4 bl[1]_4
+  vddpe vddc vddc vnwc vpw nbl[2]_4 bl[0]_3 nbl[0]_3 nbl[1]_3 bl[1]_3 vddpe
+  vddc vddc vnwc vpw bl[0]_2 nbl[0]_2 nbl[1]_2 bl[1]_2 vddpe vddc vddc vnwc
+  vpw bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddpe vddc vddc vnwc vpw bl[3]_1
+  bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe vddc vddc vnwc vpw bl[3]_0 vnwp_0
+  vnwc vpw vpw vnwp_1 bl[0]_31 nbl[0]_31 nbl[1]_31 bl[1]_31 vddpe vddc vddc
+  vpw bl[0]_30 nbl[0]_30 nbl[1]_30 vddc vddc vnwc vpw bl[3]_30 bl[0]_29
+  nbl[0]_29 nbl[1]_29 vddc vddc vnwc vpw nbl[3]_29 bl[3]_29 bl[0]_28
+  nbl[0]_28 nbl[1]_28 vddc vddc vnwc vpw nbl[3]_28 bl[3]_28 bl[0]_27
+  nbl[0]_27 nbl[1]_27 vddc vddc vnwc vpw nbl[3]_27 bl[3]_27 nbl[0]_26
+  nbl[1]_26 vddc vddc vnwc vpw bl[2]_26 bl[3]_26 nbl[0]_25 nbl[1]_25 vddc vpw
+  bl[2]_25 bl[3]_25 vddc bl[3]_24 vddc nbl[3]_23 bl[3]_23 vddc nbl[3]_22
+  bl[3]_22 nbl[3]_21 bl[3]_21 bl[2]_20 nbl[3]_20 bl[3]_20 bl[2]_19 nbl[2]_19
+  nbl[3]_19 bl[3]_19 vddc nbl[3]_18 bl[3]_18 vddc nbl[3]_17 bl[3]_17
+  nbl[3]_16 bl[3]_16 bl[2]_15 nbl[3]_15 bl[3]_15 bl[2]_14 nbl[3]_14 bl[3]_14
+  bl[2]_13 nbl[2]_13 nbl[3]_13 bl[3]_13 bl[2]_12 nbl[2]_12 nbl[3]_12 bl[3]_12
+  nbl[3]_11 bl[3]_11 bl[2]_10 nbl[3]_10 bl[3]_10 bl[2]_9 nbl[3]_9 bl[3]_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[2]_6
+  nbl[2]_6 nbl[3]_6 bl[2]_5 nbl[3]_5 bl[3]_5 bl[2]_4 nbl[3]_4 bl[3]_4 bl[2]_3
+  nbl[2]_3 nbl[3]_3 bl[3]_3 bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[2]_1
+  nbl[2]_1 nbl[3]_1 bl[2]_0 nbl[2]_0 nbl[3]_0 wl[1]_8 wl[0]_8
+  rf64x128mem_l_midt_row
xmem_l_row_top vddc vpw vnwc dbl dwl vddc vnwc bl[2]_31 nbl[2]_31 nbl[3]_31
+  bl[3]_31 bl[1]_30 vddpe bl[2]_30 nbl[2]_30 nbl[3]_30 bl[1]_29 vddpe
+  bl[2]_29 nbl[2]_29 bl[1]_28 vddpe bl[2]_28 nbl[2]_28 bl[1]_27 vddpe
+  bl[2]_27 nbl[2]_27 bl[0]_26 bl[1]_26 vddpe nbl[2]_26 nbl[3]_26 bl[0]_25
+  bl[1]_25 vddpe vddc vnwc vssc nbl[2]_25 nbl[3]_25 bl[0]_24 nbl[0]_24
+  nbl[1]_24 bl[1]_24 vddpe vddc vnwc vpw bl[2]_24 nbl[2]_24 nbl[3]_24
+  bl[0]_23 nbl[0]_23 nbl[1]_23 bl[1]_23 vddpe vddc vnwc vpw bl[2]_23
+  nbl[2]_23 bl[0]_22 nbl[0]_22 nbl[1]_22 bl[1]_22 vddpe vddc vnwc vpw
+  bl[2]_22 nbl[2]_22 bl[0]_21 nbl[0]_21 nbl[1]_21 bl[1]_21 vddpe vddc vddc
+  vnwc vpw bl[2]_21 nbl[2]_21 bl[0]_20 nbl[0]_20 nbl[1]_20 bl[1]_20 vddpe
+  vddc vddc vnwc vpw nbl[2]_20 bl[0]_19 nbl[0]_19 nbl[1]_19 bl[1]_19 vddpe
+  vddc vddc vnwc vpw bl[0]_18 nbl[0]_18 nbl[1]_18 bl[1]_18 vddpe vddc vnwc
+  vpw bl[2]_18 nbl[2]_18 bl[0]_17 nbl[0]_17 nbl[1]_17 bl[1]_17 vddpe vddc
+  vnwc vpw bl[2]_17 nbl[2]_17 bl[0]_16 nbl[0]_16 nbl[1]_16 bl[1]_16 vddpe
+  vddc vddc vnwc vpw bl[2]_16 nbl[2]_16 bl[0]_15 nbl[0]_15 nbl[1]_15 bl[1]_15
+  vddpe vddc vddc vnwc vpw nbl[2]_15 bl[0]_14 nbl[0]_14 nbl[1]_14 bl[1]_14
+  vddpe vddc vddc vnwc vpw nbl[2]_14 bl[0]_13 nbl[0]_13 nbl[1]_13 bl[1]_13
+  vddpe vddc vddc vnwc vpw bl[0]_12 nbl[0]_12 nbl[1]_12 bl[1]_12 vddpe vddc
+  vddc vnwc vpw bl[0]_11 nbl[0]_11 nbl[1]_11 bl[1]_11 vddpe vddc vddc vnwc
+  vpw bl[2]_11 nbl[2]_11 bl[0]_10 nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe vddc
+  vddc vnwc vpw nbl[2]_10 bl[0]_9 nbl[0]_9 nbl[1]_9 bl[1]_9 vddpe vddc vddc
+  vnwc vpw nbl[2]_9 bl[0]_8 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe vddc vddc vnwc
+  vpw bl[0]_7 nbl[0]_7 nbl[1]_7 bl[1]_7 vddpe vddc vddc vnwc vpw bl[0]_6
+  nbl[0]_6 nbl[1]_6 bl[1]_6 vddpe vddc vddc vnwc vpw bl[3]_6 bl[0]_5 nbl[0]_5
+  nbl[1]_5 bl[1]_5 vddpe vddc vddc vnwc vpw nbl[2]_5 bl[0]_4 nbl[0]_4
+  nbl[1]_4 bl[1]_4 vddpe vddc vddc vnwc vpw nbl[2]_4 bl[0]_3 nbl[0]_3
+  nbl[1]_3 bl[1]_3 vddpe vddc vddc vnwc vpw bl[0]_2 nbl[0]_2 nbl[1]_2 bl[1]_2
+  vddpe vddc vddc vnwc vpw bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddpe vddc vddc
+  vnwc vpw bl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe vddc vddc vnwc
+  vssc vpw bl[3]_0 vnwp_0 vnwc vpw vnwp_1 bl[0]_31 nbl[0]_31 nbl[1]_31
+  bl[1]_31 vddpe vddc vssc vpw bl[0]_30 nbl[0]_30 nbl[1]_30 vddc vddc vnwc
+  vpw bl[3]_30 bl[0]_29 nbl[0]_29 nbl[1]_29 vddc vddc vnwc vpw nbl[3]_29
+  bl[3]_29 bl[0]_28 nbl[0]_28 nbl[1]_28 vddc vddc vnwc vpw nbl[3]_28 bl[3]_28
+  bl[0]_27 nbl[0]_27 nbl[1]_27 vddc vddc vnwc vpw nbl[3]_27 bl[3]_27
+  nbl[0]_26 nbl[1]_26 vddc vddc vnwc vpw bl[2]_26 bl[3]_26 nbl[0]_25
+  nbl[1]_25 vddc vpw bl[2]_25 bl[3]_25 vddc bl[3]_24 vddc nbl[3]_23 bl[3]_23
+  vddc nbl[3]_22 bl[3]_22 nbl[3]_21 bl[3]_21 bl[2]_20 nbl[3]_20 bl[3]_20
+  bl[2]_19 nbl[2]_19 nbl[3]_19 bl[3]_19 vddc nbl[3]_18 bl[3]_18 vddc
+  nbl[3]_17 bl[3]_17 nbl[3]_16 bl[3]_16 bl[2]_15 nbl[3]_15 bl[3]_15 bl[2]_14
+  nbl[3]_14 bl[3]_14 bl[2]_13 nbl[2]_13 nbl[3]_13 bl[3]_13 bl[2]_12 nbl[2]_12
+  nbl[3]_12 bl[3]_12 nbl[3]_11 bl[3]_11 bl[2]_10 nbl[3]_10 bl[3]_10 bl[2]_9
+  nbl[3]_9 bl[3]_9 bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[2]_7 nbl[2]_7
+  nbl[3]_7 bl[3]_7 bl[2]_6 nbl[2]_6 nbl[3]_6 bl[2]_5 nbl[3]_5 bl[3]_5 bl[2]_4
+  nbl[3]_4 bl[3]_4 bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3 bl[2]_2 nbl[2]_2
+  nbl[3]_2 bl[3]_2 bl[2]_1 nbl[2]_1 nbl[3]_1 bl[2]_0 nbl[2]_0 nbl[3]_0
+  wl[1]_15 wl[0]_15 rf64x128mem_l_top_row
.ends rf64x128memcore_l
****
.subckt rf64x128mem_r_midb_row vpw_33 vnwc_33 bl[3]_31 nbl[3]_31 nbl[2]_31
+  bl[2]_31 vnwc_32 vddc_31 bl[3]_30 nbl[3]_30 nbl[2]_30 bl[2]_30 vddpe_30
+  bl[1]_30 nbl[3]_29 nbl[2]_29 bl[2]_29 vddpe_29 bl[1]_29 nbl[3]_28 nbl[2]_28
+  bl[2]_28 vddpe_28 bl[1]_28 nbl[2]_27 bl[2]_27 vddpe_27 bl[1]_27 nbl[2]_26
+  bl[2]_26 vddpe_26 bl[1]_26 bl[0]_26 nbl[3]_25 nbl[2]_25 vnwc_26 vddce_25
+  vddpe_25 bl[1]_25 nbl[1]_25 bl[0]_25 nbl[2]_24 bl[2]_24 vssc vpw_25 vnwc_25
+  vddce_24 vddpe_24 bl[1]_24 nbl[1]_24 nbl[0]_24 bl[0]_24 nbl[3]_23 nbl[2]_23
+  bl[2]_23 vpw_24 vnwc_24 vddce_23 vddpe_23 bl[1]_23 nbl[1]_23 nbl[0]_23
+  bl[0]_23 nbl[2]_22 bl[2]_22 vpw_23 vnwc_23 vddce_22 vddpe_22 bl[1]_22
+  nbl[1]_22 nbl[0]_22 bl[0]_22 nbl[2]_21 bl[2]_21 vpw_22 vnwc_22 vddc_21
+  vddce_21 vddpe_21 bl[1]_21 nbl[1]_21 nbl[0]_21 bl[0]_21 nbl[2]_20 vpw_21
+  vnwc_21 vddc_20 vddce_20 vddpe_20 bl[1]_20 nbl[1]_20 nbl[0]_20 bl[0]_20
+  nbl[2]_19 vpw_20 vnwc_20 vddc_19 vddce_19 vddpe_19 bl[1]_19 nbl[1]_19
+  nbl[0]_19 bl[0]_19 nbl[2]_18 vpw_19 vnwc_19 vddce_18 vddpe_18 bl[1]_18
+  nbl[1]_18 nbl[0]_18 bl[0]_18 nbl[2]_17 bl[2]_17 vpw_18 vnwc_18 vddce_17
+  vddpe_17 bl[1]_17 nbl[1]_17 nbl[0]_17 bl[0]_17 nbl[2]_16 bl[2]_16 vpw_17
+  vnwc_17 vddc_16 vddce_16 vddpe_16 bl[1]_16 nbl[1]_16 nbl[0]_16 bl[0]_16
+  nbl[2]_15 bl[2]_15 vpw_16 vnwc_16 vddc_15 vddce_15 vddpe_15 bl[1]_15
+  nbl[1]_15 nbl[0]_15 bl[0]_15 nbl[2]_14 vpw_15 vnwc_15 vddc_14 vddce_14
+  vddpe_14 bl[1]_14 nbl[1]_14 nbl[0]_14 bl[0]_14 nbl[2]_13 vpw_14 vnwc_14
+  vddc_13 vddce_13 vddpe_13 bl[1]_13 nbl[1]_13 nbl[0]_13 bl[0]_13 vpw_13
+  vnwc_13 vddc_12 vddce_12 vddpe_12 bl[1]_12 nbl[1]_12 nbl[0]_12 bl[0]_12
+  vpw_12 vnwc_12 vddc_11 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11
+  bl[0]_11 nbl[2]_10 bl[2]_10 vpw_11 vnwc_11 vddc_10 vddce_10 vddpe_10
+  bl[1]_10 nbl[1]_10 nbl[0]_10 bl[0]_10 nbl[2]_9 vpw_10 vnwc_10 vddc_9
+  vddce_9 vddpe_9 bl[1]_9 nbl[1]_9 nbl[0]_9 bl[0]_9 nbl[2]_8 vpw_9 vnwc_9
+  vddc_8 vddce_8 vddpe_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 vpw_8 vnwc_8
+  vddc_7 vddce_7 vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 vpw_7 vnwc_7
+  vddc_6 vddce_6 vddpe_6 bl[1]_6 nbl[1]_6 nbl[0]_6 bl[0]_6 bl[3]_5 vpw_6
+  vnwc_6 vddc_5 vddce_5 vddpe_5 bl[1]_5 nbl[1]_5 nbl[0]_5 bl[0]_5 vpw_5
+  vnwc_5 vddc_4 vddce_4 vddpe_4 bl[1]_4 nbl[1]_4 nbl[0]_4 bl[0]_4 nbl[2]_3
+  vpw_4 vnwc_4 vddc_3 vddce_3 vddpe_3 bl[1]_3 nbl[1]_3 nbl[0]_3 bl[0]_3
+  nbl[2]_2 vpw_3 vnwc_3 vddc_2 vddce_2 vddpe_2 bl[1]_2 nbl[1]_2 nbl[0]_2
+  bl[0]_2 vpw_2 vnwc_2 vddc_1 vddce_1 vddpe_1 bl[1]_1 nbl[1]_1 nbl[0]_1
+  bl[0]_1 vpw_1 vnwc_1 vddc_0 vddce_0 vddpe_0 bl[1]_0 nbl[1]_0 nbl[0]_0
+  bl[0]_0 vnwp_0 vnwc_0 vpw_0 vnwp_1 vpw_32 vddce_31 vddpe_31 bl[1]_31
+  nbl[1]_31 nbl[0]_31 bl[0]_31 vpw_31 vnwc_31 vddc_30 vddce_30 nbl[1]_30
+  nbl[0]_30 bl[0]_30 bl[3]_29 vpw_30 vnwc_30 vddc_29 vddce_29 nbl[1]_29
+  nbl[0]_29 bl[0]_29 bl[3]_28 vpw_29 vnwc_29 vddc_28 vddce_28 nbl[1]_28
+  nbl[0]_28 bl[0]_28 bl[3]_27 nbl[3]_27 vpw_28 vnwc_28 vddc_27 vddce_27
+  nbl[1]_27 nbl[0]_27 bl[0]_27 bl[3]_26 nbl[3]_26 vpw_27 vnwc_27 vddc_26
+  vddce_26 nbl[1]_26 nbl[0]_26 bl[3]_25 bl[2]_25 vpw_26 vddc_25 nbl[0]_25
+  bl[3]_24 nbl[3]_24 vddc_24 bl[3]_23 vddc_23 bl[3]_22 nbl[3]_22 vddc_22
+  bl[3]_21 nbl[3]_21 bl[3]_20 nbl[3]_20 bl[2]_20 bl[3]_19 nbl[3]_19 bl[2]_19
+  bl[3]_18 nbl[3]_18 bl[2]_18 vddc_18 bl[3]_17 nbl[3]_17 vddc_17 bl[3]_16
+  nbl[3]_16 bl[3]_15 nbl[3]_15 bl[3]_14 nbl[3]_14 bl[2]_14 bl[3]_13 nbl[3]_13
+  bl[2]_13 bl[3]_12 nbl[3]_12 nbl[2]_12 bl[2]_12 bl[3]_11 nbl[3]_11 nbl[2]_11
+  bl[2]_11 bl[3]_10 nbl[3]_10 bl[3]_9 nbl[3]_9 bl[2]_9 bl[3]_8 nbl[3]_8
+  bl[2]_8 bl[3]_7 nbl[3]_7 nbl[2]_7 bl[2]_7 bl[3]_6 nbl[3]_6 nbl[2]_6 bl[2]_6
+  nbl[3]_5 nbl[2]_5 bl[2]_5 bl[3]_4 nbl[3]_4 nbl[2]_4 bl[2]_4 bl[3]_3
+  nbl[3]_3 bl[2]_3 bl[3]_2 nbl[3]_2 bl[2]_2 bl[3]_1 nbl[3]_1 nbl[2]_1 bl[2]_1
+  bl[3]_0 nbl[3]_0 nbl[2]_0 bl[2]_0 wl[1] wl[0]
** rf64x128mem_r_midb_row: 1536 flat devices **
xmem_r_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0 ncored00_320 ncored01_322 ncored10_324
+  ncored11_326 ncored20_328 ncored21_330 ncored30_332 ncored31_334 vddc_0
+  vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_1 nbl[1]_1 nbl[2]_1 nbl[3]_1 ncored00_352 ncored01_354 ncored10_356
+  ncored11_358 ncored20_360 ncored21_362 ncored30_364 ncored31_366 vddc_1
+  vddce_1 vddpe_1 vnwc_2 vpw_2 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_624 cored01_626
+  cored10_628 cored11_630 cored20_632 cored21_634 cored30_636 cored31_638
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_640 ncored01_642
+  ncored10_644 ncored11_646 ncored20_648 ncored21_650 ncored30_652
+  ncored31_654 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_656 cored01_658
+  cored10_660 cored11_662 cored20_664 cored21_666 cored30_668 cored31_670
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_672 ncored01_674
+  ncored10_676 ncored11_678 ncored20_680 ncored21_682 ncored30_684
+  ncored31_686 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_12 bl[0]_12 bl[1]_12 bl[2]_12 bl[3]_12 cored00_688 cored01_690
+  cored10_692 cored11_694 cored20_696 cored21_698 cored30_700 cored31_702
+  nbl[0]_12 nbl[1]_12 nbl[2]_12 nbl[3]_12 ncored00_704 ncored01_706
+  ncored10_708 ncored11_710 ncored20_712 ncored21_714 ncored30_716
+  ncored31_718 vddc_12 vddce_12 vddpe_12 vnwc_13 vpw_13 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_13 bl[0]_13 bl[1]_13 bl[2]_13 bl[3]_13 cored00_752 cored01_754
+  cored10_756 cored11_758 cored20_760 cored21_762 cored30_764 cored31_766
+  nbl[0]_13 nbl[1]_13 nbl[2]_13 nbl[3]_13 ncored00_768 ncored01_770
+  ncored10_772 ncored11_774 ncored20_776 ncored21_778 ncored30_780
+  ncored31_782 vddc_13 vddce_13 vddpe_13 vnwc_14 vpw_14 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_14 bl[0]_14 bl[1]_14 bl[2]_14 bl[3]_14 cored00_816 cored01_818
+  cored10_820 cored11_822 cored20_824 cored21_826 cored30_828 cored31_830
+  nbl[0]_14 nbl[1]_14 nbl[2]_14 nbl[3]_14 ncored00_832 ncored01_834
+  ncored10_836 ncored11_838 ncored20_840 ncored21_842 ncored30_844
+  ncored31_846 vddc_14 vddce_14 vddpe_14 vnwc_15 vpw_15 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_15 bl[0]_15 bl[1]_15 bl[2]_15 bl[3]_15 cored00_848 cored01_850
+  cored10_852 cored11_854 cored20_856 cored21_858 cored30_860 cored31_862
+  nbl[0]_15 nbl[1]_15 nbl[2]_15 nbl[3]_15 ncored00_864 ncored01_866
+  ncored10_868 ncored11_870 ncored20_872 ncored21_874 ncored30_876
+  ncored31_878 vddc_15 vddce_15 vddpe_15 vnwc_16 vpw_16 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_16 bl[0]_16 bl[1]_16 bl[2]_16 bl[3]_16 cored00_880 cored01_882
+  cored10_884 cored11_886 cored20_888 cored21_890 cored30_892 cored31_894
+  nbl[0]_16 nbl[1]_16 nbl[2]_16 nbl[3]_16 ncored00_896 ncored01_898
+  ncored10_900 ncored11_902 ncored20_904 ncored21_906 ncored30_908
+  ncored31_910 vddc_16 vddce_16 vddpe_16 vnwc_17 vpw_17 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_17 bl[0]_17 bl[1]_17 bl[2]_17 bl[3]_17 cored00_912 cored01_914
+  cored10_916 cored11_918 cored20_920 cored21_922 cored30_924 cored31_926
+  nbl[0]_17 nbl[1]_17 nbl[2]_17 nbl[3]_17 ncored00_928 ncored01_930
+  ncored10_932 ncored11_934 ncored20_936 ncored21_938 ncored30_940
+  ncored31_942 vddc_17 vddce_17 vddpe_17 vnwc_18 vpw_18 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_18 bl[0]_18 bl[1]_18 bl[2]_18 bl[3]_18 cored00_944 cored01_946
+  cored10_948 cored11_950 cored20_952 cored21_954 cored30_956 cored31_958
+  nbl[0]_18 nbl[1]_18 nbl[2]_18 nbl[3]_18 ncored00_960 ncored01_962
+  ncored10_964 ncored11_966 ncored20_968 ncored21_970 ncored30_972
+  ncored31_974 vddc_18 vddce_18 vddpe_18 vnwc_19 vpw_19 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_19 bl[0]_19 bl[1]_19 bl[2]_19 bl[3]_19 cored00_976 cored01_978
+  cored10_980 cored11_982 cored20_984 cored21_986 cored30_988 cored31_990
+  nbl[0]_19 nbl[1]_19 nbl[2]_19 nbl[3]_19 ncored00_992 ncored01_994
+  ncored10_996 ncored11_998 ncored20_1000 ncored21_1002 ncored30_1004
+  ncored31_1006 vddc_19 vddce_19 vddpe_19 vnwc_20 vpw_20 vssc vssc wl[0]
+  wl[1] rf64x128cchs4
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_368 cored01_370
+  cored10_372 cored11_374 cored20_376 cored21_378 cored30_380 cored31_382
+  nbl[0]_2 nbl[1]_2 nbl[2]_2 nbl[3]_2 ncored00_384 ncored01_386 ncored10_388
+  ncored11_390 ncored20_392 ncored21_394 ncored30_396 ncored31_398 vddc_2
+  vddce_2 vddpe_2 vnwc_3 vpw_3 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_20 bl[0]_20 bl[1]_20 bl[2]_20 bl[3]_20 cored00 cored01 cored10
+  cored11 cored20 cored21 cored30 cored31 nbl[0]_20 nbl[1]_20 nbl[2]_20
+  nbl[3]_20 ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30
+  ncored31 vddc_20 vddce_20 vddpe_20 vnwc_21 vpw_21 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_21 bl[0]_21 bl[1]_21 bl[2]_21 bl[3]_21 cored00_16 cored01_18
+  cored10_20 cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_21
+  nbl[1]_21 nbl[2]_21 nbl[3]_21 ncored00_32 ncored01_34 ncored10_36
+  ncored11_38 ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_21
+  vddce_21 vddpe_21 vnwc_22 vpw_22 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_22 bl[0]_22 bl[1]_22 bl[2]_22 bl[3]_22 cored00_48 cored01_50
+  cored10_52 cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_22
+  nbl[1]_22 nbl[2]_22 nbl[3]_22 ncored00_64 ncored01_66 ncored10_68
+  ncored11_70 ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_22
+  vddce_22 vddpe_22 vnwc_23 vpw_23 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_23 bl[0]_23 bl[1]_23 bl[2]_23 bl[3]_23 cored00_80 cored01_82
+  cored10_84 cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_23
+  nbl[1]_23 nbl[2]_23 nbl[3]_23 ncored00_96 ncored01_98 ncored10_100
+  ncored11_102 ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_23
+  vddce_23 vddpe_23 vnwc_24 vpw_24 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_24 bl[0]_24 bl[1]_24 bl[2]_24 bl[3]_24 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_24 nbl[1]_24 nbl[2]_24 nbl[3]_24 ncored00_128 ncored01_130
+  ncored10_132 ncored11_134 ncored20_136 ncored21_138 ncored30_140
+  ncored31_142 vddc_24 vddce_24 vddpe_24 vnwc_25 vpw_25 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_25 bl[0]_25 bl[1]_25 bl[2]_25 bl[3]_25 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_25 nbl[1]_25 nbl[2]_25 nbl[3]_25 ncored00_160 ncored01_162
+  ncored10_164 ncored11_166 ncored20_168 ncored21_170 ncored30_172
+  ncored31_174 vddc_25 vddce_25 vddpe_25 vnwc_26 vpw_26 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_26 bl[0]_26 bl[1]_26 bl[2]_26 bl[3]_26 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_26 nbl[1]_26 nbl[2]_26 nbl[3]_26 ncored00_192 ncored01_194
+  ncored10_196 ncored11_198 ncored20_200 ncored21_202 ncored30_204
+  ncored31_206 vddc_26 vddce_26 vddpe_26 vnwc_27 vpw_27 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_27 bl[0]_27 bl[1]_27 bl[2]_27 bl[3]_27 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_27 nbl[1]_27 nbl[2]_27 nbl[3]_27 ncored00_224 ncored01_226
+  ncored10_228 ncored11_230 ncored20_232 ncored21_234 ncored30_236
+  ncored31_238 vddc_27 vddce_27 vddpe_27 vnwc_28 vpw_28 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_28 bl[0]_28 bl[1]_28 bl[2]_28 bl[3]_28 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_28 nbl[1]_28 nbl[2]_28 nbl[3]_28 ncored00_256 ncored01_258
+  ncored10_260 ncored11_262 ncored20_264 ncored21_266 ncored30_268
+  ncored31_270 vddc_28 vddce_28 vddpe_28 vnwc_29 vpw_29 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_29 bl[0]_29 bl[1]_29 bl[2]_29 bl[3]_29 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_29 nbl[1]_29 nbl[2]_29 nbl[3]_29 ncored00_288 ncored01_290
+  ncored10_292 ncored11_294 ncored20_296 ncored21_298 ncored30_300
+  ncored31_302 vddc_29 vddce_29 vddpe_29 vnwc_30 vpw_30 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_400 cored01_402
+  cored10_404 cored11_406 cored20_408 cored21_410 cored30_412 cored31_414
+  nbl[0]_3 nbl[1]_3 nbl[2]_3 nbl[3]_3 ncored00_416 ncored01_418 ncored10_420
+  ncored11_422 ncored20_424 ncored21_426 ncored30_428 ncored31_430 vddc_3
+  vddce_3 vddpe_3 vnwc_4 vpw_4 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_30 bl[0]_30 bl[1]_30 bl[2]_30 bl[3]_30 cored00_720 cored01_722
+  cored10_724 cored11_726 cored20_728 cored21_730 cored30_732 cored31_734
+  nbl[0]_30 nbl[1]_30 nbl[2]_30 nbl[3]_30 ncored00_736 ncored01_738
+  ncored10_740 ncored11_742 ncored20_744 ncored21_746 ncored30_748
+  ncored31_750 vddc_30 vddce_30 vddpe_30 vnwc_31 vpw_31 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_31 bl[0]_31 bl[1]_31 bl[2]_31 bl[3]_31 cored00_784 cored01_786
+  cored10_788 cored11_790 cored20_792 cored21_794 cored30_796 cored31_798
+  nbl[0]_31 nbl[1]_31 nbl[2]_31 nbl[3]_31 ncored00_800 ncored01_802
+  ncored10_804 ncored11_806 ncored20_808 ncored21_810 ncored30_812
+  ncored31_814 vddc_31 vddce_31 vddpe_31 vnwc_32 vpw_32 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_432 cored01_434
+  cored10_436 cored11_438 cored20_440 cored21_442 cored30_444 cored31_446
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_448 ncored01_450 ncored10_452
+  ncored11_454 ncored20_456 ncored21_458 ncored30_460 ncored31_462 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_464 cored01_466
+  cored10_468 cored11_470 cored20_472 cored21_474 cored30_476 cored31_478
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_480 ncored01_482 ncored10_484
+  ncored11_486 ncored20_488 ncored21_490 ncored30_492 ncored31_494 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_496 cored01_498
+  cored10_500 cored11_502 cored20_504 cored21_506 cored30_508 cored31_510
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_512 ncored01_514 ncored10_516
+  ncored11_518 ncored20_520 ncored21_522 ncored30_524 ncored31_526 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_528 cored01_530
+  cored10_532 cored11_534 cored20_536 cored21_538 cored30_540 cored31_542
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_544 ncored01_546 ncored10_548
+  ncored11_550 ncored20_552 ncored21_554 ncored30_556 ncored31_558 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_560 cored01_562
+  cored10_564 cored11_566 cored20_568 cored21_570 cored30_572 cored31_574
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_576 ncored01_578 ncored10_580
+  ncored11_582 ncored20_584 ncored21_586 ncored30_588 ncored31_590 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_592 cored01_594
+  cored10_596 cored11_598 cored20_600 cored21_602 cored30_604 cored31_606
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_608 ncored01_610 ncored10_612
+  ncored11_614 ncored20_616 ncored21_618 ncored30_620 ncored31_622 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] rf64x128cchs4
.ends rf64x128mem_r_midb_row
****
.subckt rf64x128mem_r_test10row vpw_33 vnwc_33 bl[3]_31 nbl[3]_31 nbl[2]_31
+  bl[2]_31 vnwc_32 vddc_31 bl[3]_30 nbl[3]_30 nbl[2]_30 bl[2]_30 vddpe_30
+  bl[1]_30 nbl[3]_29 nbl[2]_29 bl[2]_29 vddpe_29 bl[1]_29 nbl[3]_28 nbl[2]_28
+  bl[2]_28 vddpe_28 bl[1]_28 nbl[2]_27 bl[2]_27 vddpe_27 bl[1]_27 nbl[2]_26
+  bl[2]_26 vddpe_26 bl[1]_26 bl[0]_26 nbl[3]_25 nbl[2]_25 vnwc_26 vddce_25
+  vddpe_25 bl[1]_25 nbl[1]_25 bl[0]_25 nbl[2]_24 bl[2]_24 vssc vpw_25 vnwc_25
+  vddce_24 vddpe_24 bl[1]_24 nbl[1]_24 nbl[0]_24 bl[0]_24 nbl[3]_23 nbl[2]_23
+  bl[2]_23 vpw_24 vnwc_24 vddce_23 vddpe_23 bl[1]_23 nbl[1]_23 nbl[0]_23
+  bl[0]_23 nbl[2]_22 bl[2]_22 vpw_23 vnwc_23 vddce_22 vddpe_22 bl[1]_22
+  nbl[1]_22 nbl[0]_22 bl[0]_22 nbl[2]_21 bl[2]_21 vpw_22 vnwc_22 vddc_21
+  vddce_21 vddpe_21 bl[1]_21 nbl[1]_21 nbl[0]_21 bl[0]_21 nbl[2]_20 vpw_21
+  vnwc_21 vddc_20 vddce_20 vddpe_20 bl[1]_20 nbl[1]_20 nbl[0]_20 bl[0]_20
+  nbl[2]_19 vpw_20 vnwc_20 vddc_19 vddce_19 vddpe_19 bl[1]_19 nbl[1]_19
+  nbl[0]_19 bl[0]_19 nbl[2]_18 vpw_19 vnwc_19 vddce_18 vddpe_18 bl[1]_18
+  nbl[1]_18 nbl[0]_18 bl[0]_18 nbl[2]_17 bl[2]_17 vpw_18 vnwc_18 vddce_17
+  vddpe_17 bl[1]_17 nbl[1]_17 nbl[0]_17 bl[0]_17 nbl[2]_16 bl[2]_16 vpw_17
+  vnwc_17 vddc_16 vddce_16 vddpe_16 bl[1]_16 nbl[1]_16 nbl[0]_16 bl[0]_16
+  nbl[2]_15 bl[2]_15 vpw_16 vnwc_16 vddc_15 vddce_15 vddpe_15 bl[1]_15
+  nbl[1]_15 nbl[0]_15 bl[0]_15 nbl[2]_14 vpw_15 vnwc_15 vddc_14 vddce_14
+  vddpe_14 bl[1]_14 nbl[1]_14 nbl[0]_14 bl[0]_14 nbl[2]_13 vpw_14 vnwc_14
+  vddc_13 vddce_13 vddpe_13 bl[1]_13 nbl[1]_13 nbl[0]_13 bl[0]_13 vpw_13
+  vnwc_13 vddc_12 vddce_12 vddpe_12 bl[1]_12 nbl[1]_12 nbl[0]_12 bl[0]_12
+  vpw_12 vnwc_12 vddc_11 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11
+  bl[0]_11 nbl[2]_10 bl[2]_10 vpw_11 vnwc_11 vddc_10 vddce_10 vddpe_10
+  bl[1]_10 nbl[1]_10 nbl[0]_10 bl[0]_10 nbl[2]_9 vpw_10 vnwc_10 vddc_9
+  vddce_9 vddpe_9 bl[1]_9 nbl[1]_9 nbl[0]_9 bl[0]_9 nbl[2]_8 vpw_9 vnwc_9
+  vddc_8 vddce_8 vddpe_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 vpw_8 vnwc_8
+  vddc_7 vddce_7 vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 vpw_7 vnwc_7
+  vddc_6 vddce_6 vddpe_6 bl[1]_6 nbl[1]_6 nbl[0]_6 bl[0]_6 bl[3]_5 vpw_6
+  vnwc_6 vddc_5 vddce_5 vddpe_5 bl[1]_5 nbl[1]_5 nbl[0]_5 bl[0]_5 vpw_5
+  vnwc_5 vddc_4 vddce_4 vddpe_4 bl[1]_4 nbl[1]_4 nbl[0]_4 bl[0]_4 nbl[2]_3
+  vpw_4 vnwc_4 vddc_3 vddce_3 vddpe_3 bl[1]_3 nbl[1]_3 nbl[0]_3 bl[0]_3
+  nbl[2]_2 vpw_3 vnwc_3 vddc_2 vddce_2 vddpe_2 bl[1]_2 nbl[1]_2 nbl[0]_2
+  bl[0]_2 vpw_2 vnwc_2 vddc_1 vddce_1 vddpe_1 bl[1]_1 nbl[1]_1 nbl[0]_1
+  bl[0]_1 vpw_1 vnwc_1 vddc_0 vddce_0 vddpe_0 bl[1]_0 nbl[1]_0 nbl[0]_0
+  bl[0]_0 vnwp_0 vnwc_0 vpw_0 vnwp_1 vpw_32 vddce_31 vddpe_31 bl[1]_31
+  nbl[1]_31 nbl[0]_31 bl[0]_31 vpw_31 vnwc_31 vddc_30 vddce_30 nbl[1]_30
+  nbl[0]_30 bl[0]_30 bl[3]_29 vpw_30 vnwc_30 vddc_29 vddce_29 nbl[1]_29
+  nbl[0]_29 bl[0]_29 bl[3]_28 vpw_29 vnwc_29 vddc_28 vddce_28 nbl[1]_28
+  nbl[0]_28 bl[0]_28 bl[3]_27 nbl[3]_27 vpw_28 vnwc_28 vddc_27 vddce_27
+  nbl[1]_27 nbl[0]_27 bl[0]_27 bl[3]_26 nbl[3]_26 vpw_27 vnwc_27 vddc_26
+  vddce_26 nbl[1]_26 nbl[0]_26 bl[3]_25 bl[2]_25 vpw_26 vddc_25 nbl[0]_25
+  bl[3]_24 nbl[3]_24 vddc_24 bl[3]_23 vddc_23 bl[3]_22 nbl[3]_22 vddc_22
+  bl[3]_21 nbl[3]_21 bl[3]_20 nbl[3]_20 bl[2]_20 bl[3]_19 nbl[3]_19 bl[2]_19
+  bl[3]_18 nbl[3]_18 bl[2]_18 vddc_18 bl[3]_17 nbl[3]_17 vddc_17 bl[3]_16
+  nbl[3]_16 bl[3]_15 nbl[3]_15 bl[3]_14 nbl[3]_14 bl[2]_14 bl[3]_13 nbl[3]_13
+  bl[2]_13 bl[3]_12 nbl[3]_12 nbl[2]_12 bl[2]_12 bl[3]_11 nbl[3]_11 nbl[2]_11
+  bl[2]_11 bl[3]_10 nbl[3]_10 bl[3]_9 nbl[3]_9 bl[2]_9 bl[3]_8 nbl[3]_8
+  bl[2]_8 bl[3]_7 nbl[3]_7 nbl[2]_7 bl[2]_7 bl[3]_6 nbl[3]_6 nbl[2]_6 bl[2]_6
+  nbl[3]_5 nbl[2]_5 bl[2]_5 bl[3]_4 nbl[3]_4 nbl[2]_4 bl[2]_4 bl[3]_3
+  nbl[3]_3 bl[2]_3 bl[3]_2 nbl[3]_2 bl[2]_2 bl[3]_1 nbl[3]_1 nbl[2]_1 bl[2]_1
+  bl[3]_0 nbl[3]_0 nbl[2]_0 bl[2]_0 wl[1] wl[0]
** rf64x128mem_r_test10row: 1536 flat devices **
xmem_r_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0 ncored00_320 ncored01_322 ncored10_324
+  ncored11_326 ncored20_328 ncored21_330 ncored30_332 ncored31_334 vddc_0
+  vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_1 nbl[1]_1 nbl[2]_1 nbl[3]_1 ncored00_352 ncored01_354 ncored10_356
+  ncored11_358 ncored20_360 ncored21_362 ncored30_364 ncored31_366 vddc_1
+  vddce_1 vddpe_1 vnwc_2 vpw_2 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_624 cored01_626
+  cored10_628 cored11_630 cored20_632 cored21_634 cored30_636 cored31_638
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_640 ncored01_642
+  ncored10_644 ncored11_646 ncored20_648 ncored21_650 ncored30_652
+  ncored31_654 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_656 cored01_658
+  cored10_660 cored11_662 cored20_664 cored21_666 cored30_668 cored31_670
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_672 ncored01_674
+  ncored10_676 ncored11_678 ncored20_680 ncored21_682 ncored30_684
+  ncored31_686 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_12 bl[0]_12 bl[1]_12 bl[2]_12 bl[3]_12 cored00_688 cored01_690
+  cored10_692 cored11_694 cored20_696 cored21_698 cored30_700 cored31_702
+  nbl[0]_12 nbl[1]_12 nbl[2]_12 nbl[3]_12 ncored00_704 ncored01_706
+  ncored10_708 ncored11_710 ncored20_712 ncored21_714 ncored30_716
+  ncored31_718 vddc_12 vddce_12 vddpe_12 vnwc_13 vpw_13 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_13 bl[0]_13 bl[1]_13 bl[2]_13 bl[3]_13 cored00_752 cored01_754
+  cored10_756 cored11_758 cored20_760 cored21_762 cored30_764 cored31_766
+  nbl[0]_13 nbl[1]_13 nbl[2]_13 nbl[3]_13 ncored00_768 ncored01_770
+  ncored10_772 ncored11_774 ncored20_776 ncored21_778 ncored30_780
+  ncored31_782 vddc_13 vddce_13 vddpe_13 vnwc_14 vpw_14 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_14 bl[0]_14 bl[1]_14 bl[2]_14 bl[3]_14 cored00_816 cored01_818
+  cored10_820 cored11_822 cored20_824 cored21_826 cored30_828 cored31_830
+  nbl[0]_14 nbl[1]_14 nbl[2]_14 nbl[3]_14 ncored00_832 ncored01_834
+  ncored10_836 ncored11_838 ncored20_840 ncored21_842 ncored30_844
+  ncored31_846 vddc_14 vddce_14 vddpe_14 vnwc_15 vpw_15 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_15 bl[0]_15 bl[1]_15 bl[2]_15 bl[3]_15 cored00_848 cored01_850
+  cored10_852 cored11_854 cored20_856 cored21_858 cored30_860 cored31_862
+  nbl[0]_15 nbl[1]_15 nbl[2]_15 nbl[3]_15 ncored00_864 ncored01_866
+  ncored10_868 ncored11_870 ncored20_872 ncored21_874 ncored30_876
+  ncored31_878 vddc_15 vddce_15 vddpe_15 vnwc_16 vpw_16 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_16 bl[0]_16 bl[1]_16 bl[2]_16 bl[3]_16 cored00_880 cored01_882
+  cored10_884 cored11_886 cored20_888 cored21_890 cored30_892 cored31_894
+  nbl[0]_16 nbl[1]_16 nbl[2]_16 nbl[3]_16 ncored00_896 ncored01_898
+  ncored10_900 ncored11_902 ncored20_904 ncored21_906 ncored30_908
+  ncored31_910 vddc_16 vddce_16 vddpe_16 vnwc_17 vpw_17 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_17 bl[0]_17 bl[1]_17 bl[2]_17 bl[3]_17 cored00_912 cored01_914
+  cored10_916 cored11_918 cored20_920 cored21_922 cored30_924 cored31_926
+  nbl[0]_17 nbl[1]_17 nbl[2]_17 nbl[3]_17 ncored00_928 ncored01_930
+  ncored10_932 ncored11_934 ncored20_936 ncored21_938 ncored30_940
+  ncored31_942 vddc_17 vddce_17 vddpe_17 vnwc_18 vpw_18 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_18 bl[0]_18 bl[1]_18 bl[2]_18 bl[3]_18 cored00_944 cored01_946
+  cored10_948 cored11_950 cored20_952 cored21_954 cored30_956 cored31_958
+  nbl[0]_18 nbl[1]_18 nbl[2]_18 nbl[3]_18 ncored00_960 ncored01_962
+  ncored10_964 ncored11_966 ncored20_968 ncored21_970 ncored30_972
+  ncored31_974 vddc_18 vddce_18 vddpe_18 vnwc_19 vpw_19 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_19 bl[0]_19 bl[1]_19 bl[2]_19 bl[3]_19 cored00_976 cored01_978
+  cored10_980 cored11_982 cored20_984 cored21_986 cored30_988 cored31_990
+  nbl[0]_19 nbl[1]_19 nbl[2]_19 nbl[3]_19 ncored00_992 ncored01_994
+  ncored10_996 ncored11_998 ncored20_1000 ncored21_1002 ncored30_1004
+  ncored31_1006 vddc_19 vddce_19 vddpe_19 vnwc_20 vpw_20 vssc vssc wl[0]
+  wl[1] rf64x128cchs4
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_368 cored01_370
+  cored10_372 cored11_374 cored20_376 cored21_378 cored30_380 cored31_382
+  nbl[0]_2 nbl[1]_2 nbl[2]_2 nbl[3]_2 ncored00_384 ncored01_386 ncored10_388
+  ncored11_390 ncored20_392 ncored21_394 ncored30_396 ncored31_398 vddc_2
+  vddce_2 vddpe_2 vnwc_3 vpw_3 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_20 bl[0]_20 bl[1]_20 bl[2]_20 bl[3]_20 cored00 cored01 cored10
+  cored11 cored20 cored21 cored30 cored31 nbl[0]_20 nbl[1]_20 nbl[2]_20
+  nbl[3]_20 ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30
+  ncored31 vddc_20 vddce_20 vddpe_20 vnwc_21 vpw_21 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_21 bl[0]_21 bl[1]_21 bl[2]_21 bl[3]_21 cored00_16 cored01_18
+  cored10_20 cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_21
+  nbl[1]_21 nbl[2]_21 nbl[3]_21 ncored00_32 ncored01_34 ncored10_36
+  ncored11_38 ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_21
+  vddce_21 vddpe_21 vnwc_22 vpw_22 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_22 bl[0]_22 bl[1]_22 bl[2]_22 bl[3]_22 cored00_48 cored01_50
+  cored10_52 cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_22
+  nbl[1]_22 nbl[2]_22 nbl[3]_22 ncored00_64 ncored01_66 ncored10_68
+  ncored11_70 ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_22
+  vddce_22 vddpe_22 vnwc_23 vpw_23 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_23 bl[0]_23 bl[1]_23 bl[2]_23 bl[3]_23 cored00_80 cored01_82
+  cored10_84 cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_23
+  nbl[1]_23 nbl[2]_23 nbl[3]_23 ncored00_96 ncored01_98 ncored10_100
+  ncored11_102 ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_23
+  vddce_23 vddpe_23 vnwc_24 vpw_24 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_24 bl[0]_24 bl[1]_24 bl[2]_24 bl[3]_24 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_24 nbl[1]_24 nbl[2]_24 nbl[3]_24 ncored00_128 ncored01_130
+  ncored10_132 ncored11_134 ncored20_136 ncored21_138 ncored30_140
+  ncored31_142 vddc_24 vddce_24 vddpe_24 vnwc_25 vpw_25 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_25 bl[0]_25 bl[1]_25 bl[2]_25 bl[3]_25 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_25 nbl[1]_25 nbl[2]_25 nbl[3]_25 ncored00_160 ncored01_162
+  ncored10_164 ncored11_166 ncored20_168 ncored21_170 ncored30_172
+  ncored31_174 vddc_25 vddce_25 vddpe_25 vnwc_26 vpw_26 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_26 bl[0]_26 bl[1]_26 bl[2]_26 bl[3]_26 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_26 nbl[1]_26 nbl[2]_26 nbl[3]_26 ncored00_192 ncored01_194
+  ncored10_196 ncored11_198 ncored20_200 ncored21_202 ncored30_204
+  ncored31_206 vddc_26 vddce_26 vddpe_26 vnwc_27 vpw_27 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_27 bl[0]_27 bl[1]_27 bl[2]_27 bl[3]_27 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_27 nbl[1]_27 nbl[2]_27 nbl[3]_27 ncored00_224 ncored01_226
+  ncored10_228 ncored11_230 ncored20_232 ncored21_234 ncored30_236
+  ncored31_238 vddc_27 vddce_27 vddpe_27 vnwc_28 vpw_28 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_28 bl[0]_28 bl[1]_28 bl[2]_28 bl[3]_28 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_28 nbl[1]_28 nbl[2]_28 nbl[3]_28 ncored00_256 ncored01_258
+  ncored10_260 ncored11_262 ncored20_264 ncored21_266 ncored30_268
+  ncored31_270 vddc_28 vddce_28 vddpe_28 vnwc_29 vpw_29 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_29 bl[0]_29 bl[1]_29 bl[2]_29 bl[3]_29 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_29 nbl[1]_29 nbl[2]_29 nbl[3]_29 ncored00_288 ncored01_290
+  ncored10_292 ncored11_294 ncored20_296 ncored21_298 ncored30_300
+  ncored31_302 vddc_29 vddce_29 vddpe_29 vnwc_30 vpw_30 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_400 cored01_402
+  cored10_404 cored11_406 cored20_408 cored21_410 cored30_412 cored31_414
+  nbl[0]_3 nbl[1]_3 nbl[2]_3 nbl[3]_3 ncored00_416 ncored01_418 ncored10_420
+  ncored11_422 ncored20_424 ncored21_426 ncored30_428 ncored31_430 vddc_3
+  vddce_3 vddpe_3 vnwc_4 vpw_4 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_30 bl[0]_30 bl[1]_30 bl[2]_30 bl[3]_30 cored00_720 cored01_722
+  cored10_724 cored11_726 cored20_728 cored21_730 cored30_732 cored31_734
+  nbl[0]_30 nbl[1]_30 nbl[2]_30 nbl[3]_30 ncored00_736 ncored01_738
+  ncored10_740 ncored11_742 ncored20_744 ncored21_746 ncored30_748
+  ncored31_750 vddc_30 vddce_30 vddpe_30 vnwc_31 vpw_31 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_31 bl[0]_31 bl[1]_31 bl[2]_31 bl[3]_31 cored00_784 cored01_786
+  cored10_788 cored11_790 cored20_792 cored21_794 cored30_796 cored31_798
+  nbl[0]_31 nbl[1]_31 nbl[2]_31 nbl[3]_31 ncored00_800 ncored01_802
+  ncored10_804 ncored11_806 ncored20_808 ncored21_810 ncored30_812
+  ncored31_814 vddc_31 vddce_31 vddpe_31 vnwc_32 vpw_32 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_432 cored01_434
+  cored10_436 cored11_438 cored20_440 cored21_442 cored30_444 cored31_446
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_448 ncored01_450 ncored10_452
+  ncored11_454 ncored20_456 ncored21_458 ncored30_460 ncored31_462 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_464 cored01_466
+  cored10_468 cored11_470 cored20_472 cored21_474 cored30_476 cored31_478
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_480 ncored01_482 ncored10_484
+  ncored11_486 ncored20_488 ncored21_490 ncored30_492 ncored31_494 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_496 cored01_498
+  cored10_500 cored11_502 cored20_504 cored21_506 cored30_508 cored31_510
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_512 ncored01_514 ncored10_516
+  ncored11_518 ncored20_520 ncored21_522 ncored30_524 ncored31_526 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_528 cored01_530
+  cored10_532 cored11_534 cored20_536 cored21_538 cored30_540 cored31_542
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_544 ncored01_546 ncored10_548
+  ncored11_550 ncored20_552 ncored21_554 ncored30_556 ncored31_558 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_560 cored01_562
+  cored10_564 cored11_566 cored20_568 cored21_570 cored30_572 cored31_574
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_576 ncored01_578 ncored10_580
+  ncored11_582 ncored20_584 ncored21_586 ncored30_588 ncored31_590 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_592 cored01_594
+  cored10_596 cored11_598 cored20_600 cored21_602 cored30_604 cored31_606
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_608 ncored01_610 ncored10_612
+  ncored11_614 ncored20_616 ncored21_618 ncored30_620 ncored31_622 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] rf64x128cchs4
.ends rf64x128mem_r_test10row
****
.subckt rf64x128mem_r_test11row vpw_33 vnwc_33 bl[3]_31 nbl[3]_31 nbl[2]_31
+  bl[2]_31 vnwc_32 vddc_31 bl[3]_30 nbl[3]_30 nbl[2]_30 bl[2]_30 vddpe_30
+  bl[1]_30 nbl[3]_29 nbl[2]_29 bl[2]_29 vddpe_29 bl[1]_29 nbl[3]_28 nbl[2]_28
+  bl[2]_28 vddpe_28 bl[1]_28 nbl[2]_27 bl[2]_27 vddpe_27 bl[1]_27 nbl[2]_26
+  bl[2]_26 vddpe_26 bl[1]_26 bl[0]_26 nbl[3]_25 nbl[2]_25 vnwc_26 vddce_25
+  vddpe_25 bl[1]_25 nbl[1]_25 bl[0]_25 nbl[2]_24 bl[2]_24 vssc vpw_25 vnwc_25
+  vddce_24 vddpe_24 bl[1]_24 nbl[1]_24 nbl[0]_24 bl[0]_24 nbl[3]_23 nbl[2]_23
+  bl[2]_23 vpw_24 vnwc_24 vddce_23 vddpe_23 bl[1]_23 nbl[1]_23 nbl[0]_23
+  bl[0]_23 nbl[2]_22 bl[2]_22 vpw_23 vnwc_23 vddce_22 vddpe_22 bl[1]_22
+  nbl[1]_22 nbl[0]_22 bl[0]_22 nbl[2]_21 bl[2]_21 vpw_22 vnwc_22 vddc_21
+  vddce_21 vddpe_21 bl[1]_21 nbl[1]_21 nbl[0]_21 bl[0]_21 nbl[2]_20 vpw_21
+  vnwc_21 vddc_20 vddce_20 vddpe_20 bl[1]_20 nbl[1]_20 nbl[0]_20 bl[0]_20
+  nbl[2]_19 vpw_20 vnwc_20 vddc_19 vddce_19 vddpe_19 bl[1]_19 nbl[1]_19
+  nbl[0]_19 bl[0]_19 nbl[2]_18 vpw_19 vnwc_19 vddce_18 vddpe_18 bl[1]_18
+  nbl[1]_18 nbl[0]_18 bl[0]_18 nbl[2]_17 bl[2]_17 vpw_18 vnwc_18 vddce_17
+  vddpe_17 bl[1]_17 nbl[1]_17 nbl[0]_17 bl[0]_17 nbl[2]_16 bl[2]_16 vpw_17
+  vnwc_17 vddc_16 vddce_16 vddpe_16 bl[1]_16 nbl[1]_16 nbl[0]_16 bl[0]_16
+  nbl[2]_15 bl[2]_15 vpw_16 vnwc_16 vddc_15 vddce_15 vddpe_15 bl[1]_15
+  nbl[1]_15 nbl[0]_15 bl[0]_15 nbl[2]_14 vpw_15 vnwc_15 vddc_14 vddce_14
+  vddpe_14 bl[1]_14 nbl[1]_14 nbl[0]_14 bl[0]_14 nbl[2]_13 vpw_14 vnwc_14
+  vddc_13 vddce_13 vddpe_13 bl[1]_13 nbl[1]_13 nbl[0]_13 bl[0]_13 vpw_13
+  vnwc_13 vddc_12 vddce_12 vddpe_12 bl[1]_12 nbl[1]_12 nbl[0]_12 bl[0]_12
+  vpw_12 vnwc_12 vddc_11 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11
+  bl[0]_11 nbl[2]_10 bl[2]_10 vpw_11 vnwc_11 vddc_10 vddce_10 vddpe_10
+  bl[1]_10 nbl[1]_10 nbl[0]_10 bl[0]_10 nbl[2]_9 vpw_10 vnwc_10 vddc_9
+  vddce_9 vddpe_9 bl[1]_9 nbl[1]_9 nbl[0]_9 bl[0]_9 nbl[2]_8 vpw_9 vnwc_9
+  vddc_8 vddce_8 vddpe_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 vpw_8 vnwc_8
+  vddc_7 vddce_7 vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 vpw_7 vnwc_7
+  vddc_6 vddce_6 vddpe_6 bl[1]_6 nbl[1]_6 nbl[0]_6 bl[0]_6 bl[3]_5 vpw_6
+  vnwc_6 vddc_5 vddce_5 vddpe_5 bl[1]_5 nbl[1]_5 nbl[0]_5 bl[0]_5 vpw_5
+  vnwc_5 vddc_4 vddce_4 vddpe_4 bl[1]_4 nbl[1]_4 nbl[0]_4 bl[0]_4 nbl[2]_3
+  vpw_4 vnwc_4 vddc_3 vddce_3 vddpe_3 bl[1]_3 nbl[1]_3 nbl[0]_3 bl[0]_3
+  nbl[2]_2 vpw_3 vnwc_3 vddc_2 vddce_2 vddpe_2 bl[1]_2 nbl[1]_2 nbl[0]_2
+  bl[0]_2 vpw_2 vnwc_2 vddc_1 vddce_1 vddpe_1 bl[1]_1 nbl[1]_1 nbl[0]_1
+  bl[0]_1 vpw_1 vnwc_1 vddc_0 vddce_0 vddpe_0 bl[1]_0 nbl[1]_0 nbl[0]_0
+  bl[0]_0 vnwp_0 vnwc_0 vpw_0 vnwp_1 vpw_32 vddce_31 vddpe_31 bl[1]_31
+  nbl[1]_31 nbl[0]_31 bl[0]_31 vpw_31 vnwc_31 vddc_30 vddce_30 nbl[1]_30
+  nbl[0]_30 bl[0]_30 bl[3]_29 vpw_30 vnwc_30 vddc_29 vddce_29 nbl[1]_29
+  nbl[0]_29 bl[0]_29 bl[3]_28 vpw_29 vnwc_29 vddc_28 vddce_28 nbl[1]_28
+  nbl[0]_28 bl[0]_28 bl[3]_27 nbl[3]_27 vpw_28 vnwc_28 vddc_27 vddce_27
+  nbl[1]_27 nbl[0]_27 bl[0]_27 bl[3]_26 nbl[3]_26 vpw_27 vnwc_27 vddc_26
+  vddce_26 nbl[1]_26 nbl[0]_26 bl[3]_25 bl[2]_25 vpw_26 vddc_25 nbl[0]_25
+  bl[3]_24 nbl[3]_24 vddc_24 bl[3]_23 vddc_23 bl[3]_22 nbl[3]_22 vddc_22
+  bl[3]_21 nbl[3]_21 bl[3]_20 nbl[3]_20 bl[2]_20 bl[3]_19 nbl[3]_19 bl[2]_19
+  bl[3]_18 nbl[3]_18 bl[2]_18 vddc_18 bl[3]_17 nbl[3]_17 vddc_17 bl[3]_16
+  nbl[3]_16 bl[3]_15 nbl[3]_15 bl[3]_14 nbl[3]_14 bl[2]_14 bl[3]_13 nbl[3]_13
+  bl[2]_13 bl[3]_12 nbl[3]_12 nbl[2]_12 bl[2]_12 bl[3]_11 nbl[3]_11 nbl[2]_11
+  bl[2]_11 bl[3]_10 nbl[3]_10 bl[3]_9 nbl[3]_9 bl[2]_9 bl[3]_8 nbl[3]_8
+  bl[2]_8 bl[3]_7 nbl[3]_7 nbl[2]_7 bl[2]_7 bl[3]_6 nbl[3]_6 nbl[2]_6 bl[2]_6
+  nbl[3]_5 nbl[2]_5 bl[2]_5 bl[3]_4 nbl[3]_4 nbl[2]_4 bl[2]_4 bl[3]_3
+  nbl[3]_3 bl[2]_3 bl[3]_2 nbl[3]_2 bl[2]_2 bl[3]_1 nbl[3]_1 nbl[2]_1 bl[2]_1
+  bl[3]_0 nbl[3]_0 nbl[2]_0 bl[2]_0 wl[1] wl[0]
** rf64x128mem_r_test11row: 1536 flat devices **
xmem_r_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0 ncored00_320 ncored01_322 ncored10_324
+  ncored11_326 ncored20_328 ncored21_330 ncored30_332 ncored31_334 vddc_0
+  vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_1 nbl[1]_1 nbl[2]_1 nbl[3]_1 ncored00_352 ncored01_354 ncored10_356
+  ncored11_358 ncored20_360 ncored21_362 ncored30_364 ncored31_366 vddc_1
+  vddce_1 vddpe_1 vnwc_2 vpw_2 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_624 cored01_626
+  cored10_628 cored11_630 cored20_632 cored21_634 cored30_636 cored31_638
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_640 ncored01_642
+  ncored10_644 ncored11_646 ncored20_648 ncored21_650 ncored30_652
+  ncored31_654 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_656 cored01_658
+  cored10_660 cored11_662 cored20_664 cored21_666 cored30_668 cored31_670
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_672 ncored01_674
+  ncored10_676 ncored11_678 ncored20_680 ncored21_682 ncored30_684
+  ncored31_686 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_12 bl[0]_12 bl[1]_12 bl[2]_12 bl[3]_12 cored00_688 cored01_690
+  cored10_692 cored11_694 cored20_696 cored21_698 cored30_700 cored31_702
+  nbl[0]_12 nbl[1]_12 nbl[2]_12 nbl[3]_12 ncored00_704 ncored01_706
+  ncored10_708 ncored11_710 ncored20_712 ncored21_714 ncored30_716
+  ncored31_718 vddc_12 vddce_12 vddpe_12 vnwc_13 vpw_13 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_13 bl[0]_13 bl[1]_13 bl[2]_13 bl[3]_13 cored00_752 cored01_754
+  cored10_756 cored11_758 cored20_760 cored21_762 cored30_764 cored31_766
+  nbl[0]_13 nbl[1]_13 nbl[2]_13 nbl[3]_13 ncored00_768 ncored01_770
+  ncored10_772 ncored11_774 ncored20_776 ncored21_778 ncored30_780
+  ncored31_782 vddc_13 vddce_13 vddpe_13 vnwc_14 vpw_14 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_14 bl[0]_14 bl[1]_14 bl[2]_14 bl[3]_14 cored00_816 cored01_818
+  cored10_820 cored11_822 cored20_824 cored21_826 cored30_828 cored31_830
+  nbl[0]_14 nbl[1]_14 nbl[2]_14 nbl[3]_14 ncored00_832 ncored01_834
+  ncored10_836 ncored11_838 ncored20_840 ncored21_842 ncored30_844
+  ncored31_846 vddc_14 vddce_14 vddpe_14 vnwc_15 vpw_15 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_15 bl[0]_15 bl[1]_15 bl[2]_15 bl[3]_15 cored00_848 cored01_850
+  cored10_852 cored11_854 cored20_856 cored21_858 cored30_860 cored31_862
+  nbl[0]_15 nbl[1]_15 nbl[2]_15 nbl[3]_15 ncored00_864 ncored01_866
+  ncored10_868 ncored11_870 ncored20_872 ncored21_874 ncored30_876
+  ncored31_878 vddc_15 vddce_15 vddpe_15 vnwc_16 vpw_16 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_16 bl[0]_16 bl[1]_16 bl[2]_16 bl[3]_16 cored00_880 cored01_882
+  cored10_884 cored11_886 cored20_888 cored21_890 cored30_892 cored31_894
+  nbl[0]_16 nbl[1]_16 nbl[2]_16 nbl[3]_16 ncored00_896 ncored01_898
+  ncored10_900 ncored11_902 ncored20_904 ncored21_906 ncored30_908
+  ncored31_910 vddc_16 vddce_16 vddpe_16 vnwc_17 vpw_17 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_17 bl[0]_17 bl[1]_17 bl[2]_17 bl[3]_17 cored00_912 cored01_914
+  cored10_916 cored11_918 cored20_920 cored21_922 cored30_924 cored31_926
+  nbl[0]_17 nbl[1]_17 nbl[2]_17 nbl[3]_17 ncored00_928 ncored01_930
+  ncored10_932 ncored11_934 ncored20_936 ncored21_938 ncored30_940
+  ncored31_942 vddc_17 vddce_17 vddpe_17 vnwc_18 vpw_18 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_18 bl[0]_18 bl[1]_18 bl[2]_18 bl[3]_18 cored00_944 cored01_946
+  cored10_948 cored11_950 cored20_952 cored21_954 cored30_956 cored31_958
+  nbl[0]_18 nbl[1]_18 nbl[2]_18 nbl[3]_18 ncored00_960 ncored01_962
+  ncored10_964 ncored11_966 ncored20_968 ncored21_970 ncored30_972
+  ncored31_974 vddc_18 vddce_18 vddpe_18 vnwc_19 vpw_19 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_19 bl[0]_19 bl[1]_19 bl[2]_19 bl[3]_19 cored00_976 cored01_978
+  cored10_980 cored11_982 cored20_984 cored21_986 cored30_988 cored31_990
+  nbl[0]_19 nbl[1]_19 nbl[2]_19 nbl[3]_19 ncored00_992 ncored01_994
+  ncored10_996 ncored11_998 ncored20_1000 ncored21_1002 ncored30_1004
+  ncored31_1006 vddc_19 vddce_19 vddpe_19 vnwc_20 vpw_20 vssc vssc wl[0]
+  wl[1] rf64x128cchs4
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_368 cored01_370
+  cored10_372 cored11_374 cored20_376 cored21_378 cored30_380 cored31_382
+  nbl[0]_2 nbl[1]_2 nbl[2]_2 nbl[3]_2 ncored00_384 ncored01_386 ncored10_388
+  ncored11_390 ncored20_392 ncored21_394 ncored30_396 ncored31_398 vddc_2
+  vddce_2 vddpe_2 vnwc_3 vpw_3 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_20 bl[0]_20 bl[1]_20 bl[2]_20 bl[3]_20 cored00 cored01 cored10
+  cored11 cored20 cored21 cored30 cored31 nbl[0]_20 nbl[1]_20 nbl[2]_20
+  nbl[3]_20 ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30
+  ncored31 vddc_20 vddce_20 vddpe_20 vnwc_21 vpw_21 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_21 bl[0]_21 bl[1]_21 bl[2]_21 bl[3]_21 cored00_16 cored01_18
+  cored10_20 cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_21
+  nbl[1]_21 nbl[2]_21 nbl[3]_21 ncored00_32 ncored01_34 ncored10_36
+  ncored11_38 ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_21
+  vddce_21 vddpe_21 vnwc_22 vpw_22 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_22 bl[0]_22 bl[1]_22 bl[2]_22 bl[3]_22 cored00_48 cored01_50
+  cored10_52 cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_22
+  nbl[1]_22 nbl[2]_22 nbl[3]_22 ncored00_64 ncored01_66 ncored10_68
+  ncored11_70 ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_22
+  vddce_22 vddpe_22 vnwc_23 vpw_23 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_23 bl[0]_23 bl[1]_23 bl[2]_23 bl[3]_23 cored00_80 cored01_82
+  cored10_84 cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_23
+  nbl[1]_23 nbl[2]_23 nbl[3]_23 ncored00_96 ncored01_98 ncored10_100
+  ncored11_102 ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_23
+  vddce_23 vddpe_23 vnwc_24 vpw_24 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_24 bl[0]_24 bl[1]_24 bl[2]_24 bl[3]_24 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_24 nbl[1]_24 nbl[2]_24 nbl[3]_24 ncored00_128 ncored01_130
+  ncored10_132 ncored11_134 ncored20_136 ncored21_138 ncored30_140
+  ncored31_142 vddc_24 vddce_24 vddpe_24 vnwc_25 vpw_25 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_25 bl[0]_25 bl[1]_25 bl[2]_25 bl[3]_25 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_25 nbl[1]_25 nbl[2]_25 nbl[3]_25 ncored00_160 ncored01_162
+  ncored10_164 ncored11_166 ncored20_168 ncored21_170 ncored30_172
+  ncored31_174 vddc_25 vddce_25 vddpe_25 vnwc_26 vpw_26 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_26 bl[0]_26 bl[1]_26 bl[2]_26 bl[3]_26 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_26 nbl[1]_26 nbl[2]_26 nbl[3]_26 ncored00_192 ncored01_194
+  ncored10_196 ncored11_198 ncored20_200 ncored21_202 ncored30_204
+  ncored31_206 vddc_26 vddce_26 vddpe_26 vnwc_27 vpw_27 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_27 bl[0]_27 bl[1]_27 bl[2]_27 bl[3]_27 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_27 nbl[1]_27 nbl[2]_27 nbl[3]_27 ncored00_224 ncored01_226
+  ncored10_228 ncored11_230 ncored20_232 ncored21_234 ncored30_236
+  ncored31_238 vddc_27 vddce_27 vddpe_27 vnwc_28 vpw_28 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_28 bl[0]_28 bl[1]_28 bl[2]_28 bl[3]_28 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_28 nbl[1]_28 nbl[2]_28 nbl[3]_28 ncored00_256 ncored01_258
+  ncored10_260 ncored11_262 ncored20_264 ncored21_266 ncored30_268
+  ncored31_270 vddc_28 vddce_28 vddpe_28 vnwc_29 vpw_29 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_29 bl[0]_29 bl[1]_29 bl[2]_29 bl[3]_29 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_29 nbl[1]_29 nbl[2]_29 nbl[3]_29 ncored00_288 ncored01_290
+  ncored10_292 ncored11_294 ncored20_296 ncored21_298 ncored30_300
+  ncored31_302 vddc_29 vddce_29 vddpe_29 vnwc_30 vpw_30 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_400 cored01_402
+  cored10_404 cored11_406 cored20_408 cored21_410 cored30_412 cored31_414
+  nbl[0]_3 nbl[1]_3 nbl[2]_3 nbl[3]_3 ncored00_416 ncored01_418 ncored10_420
+  ncored11_422 ncored20_424 ncored21_426 ncored30_428 ncored31_430 vddc_3
+  vddce_3 vddpe_3 vnwc_4 vpw_4 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_30 bl[0]_30 bl[1]_30 bl[2]_30 bl[3]_30 cored00_720 cored01_722
+  cored10_724 cored11_726 cored20_728 cored21_730 cored30_732 cored31_734
+  nbl[0]_30 nbl[1]_30 nbl[2]_30 nbl[3]_30 ncored00_736 ncored01_738
+  ncored10_740 ncored11_742 ncored20_744 ncored21_746 ncored30_748
+  ncored31_750 vddc_30 vddce_30 vddpe_30 vnwc_31 vpw_31 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_31 bl[0]_31 bl[1]_31 bl[2]_31 bl[3]_31 cored00_784 cored01_786
+  cored10_788 cored11_790 cored20_792 cored21_794 cored30_796 cored31_798
+  nbl[0]_31 nbl[1]_31 nbl[2]_31 nbl[3]_31 ncored00_800 ncored01_802
+  ncored10_804 ncored11_806 ncored20_808 ncored21_810 ncored30_812
+  ncored31_814 vddc_31 vddce_31 vddpe_31 vnwc_32 vpw_32 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_432 cored01_434
+  cored10_436 cored11_438 cored20_440 cored21_442 cored30_444 cored31_446
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_448 ncored01_450 ncored10_452
+  ncored11_454 ncored20_456 ncored21_458 ncored30_460 ncored31_462 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_464 cored01_466
+  cored10_468 cored11_470 cored20_472 cored21_474 cored30_476 cored31_478
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_480 ncored01_482 ncored10_484
+  ncored11_486 ncored20_488 ncored21_490 ncored30_492 ncored31_494 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_496 cored01_498
+  cored10_500 cored11_502 cored20_504 cored21_506 cored30_508 cored31_510
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_512 ncored01_514 ncored10_516
+  ncored11_518 ncored20_520 ncored21_522 ncored30_524 ncored31_526 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_528 cored01_530
+  cored10_532 cored11_534 cored20_536 cored21_538 cored30_540 cored31_542
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_544 ncored01_546 ncored10_548
+  ncored11_550 ncored20_552 ncored21_554 ncored30_556 ncored31_558 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_560 cored01_562
+  cored10_564 cored11_566 cored20_568 cored21_570 cored30_572 cored31_574
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_576 ncored01_578 ncored10_580
+  ncored11_582 ncored20_584 ncored21_586 ncored30_588 ncored31_590 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_592 cored01_594
+  cored10_596 cored11_598 cored20_600 cored21_602 cored30_604 cored31_606
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_608 ncored01_610 ncored10_612
+  ncored11_614 ncored20_616 ncored21_618 ncored30_620 ncored31_622 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] rf64x128cchs4
.ends rf64x128mem_r_test11row
****
.subckt rf64x128mem_r_test12row vpw_33 vnwc_33 bl[3]_31 nbl[3]_31 nbl[2]_31
+  bl[2]_31 vnwc_32 vddc_31 bl[3]_30 nbl[3]_30 nbl[2]_30 bl[2]_30 vddpe_30
+  bl[1]_30 nbl[3]_29 nbl[2]_29 bl[2]_29 vddpe_29 bl[1]_29 nbl[3]_28 nbl[2]_28
+  bl[2]_28 vddpe_28 bl[1]_28 nbl[2]_27 bl[2]_27 vddpe_27 bl[1]_27 nbl[2]_26
+  bl[2]_26 vddpe_26 bl[1]_26 bl[0]_26 nbl[3]_25 nbl[2]_25 vnwc_26 vddce_25
+  vddpe_25 bl[1]_25 nbl[1]_25 bl[0]_25 nbl[2]_24 bl[2]_24 vssc vpw_25 vnwc_25
+  vddce_24 vddpe_24 bl[1]_24 nbl[1]_24 nbl[0]_24 bl[0]_24 nbl[3]_23 nbl[2]_23
+  bl[2]_23 vpw_24 vnwc_24 vddce_23 vddpe_23 bl[1]_23 nbl[1]_23 nbl[0]_23
+  bl[0]_23 nbl[2]_22 bl[2]_22 vpw_23 vnwc_23 vddce_22 vddpe_22 bl[1]_22
+  nbl[1]_22 nbl[0]_22 bl[0]_22 nbl[2]_21 bl[2]_21 vpw_22 vnwc_22 vddc_21
+  vddce_21 vddpe_21 bl[1]_21 nbl[1]_21 nbl[0]_21 bl[0]_21 nbl[2]_20 vpw_21
+  vnwc_21 vddc_20 vddce_20 vddpe_20 bl[1]_20 nbl[1]_20 nbl[0]_20 bl[0]_20
+  nbl[2]_19 vpw_20 vnwc_20 vddc_19 vddce_19 vddpe_19 bl[1]_19 nbl[1]_19
+  nbl[0]_19 bl[0]_19 nbl[2]_18 vpw_19 vnwc_19 vddce_18 vddpe_18 bl[1]_18
+  nbl[1]_18 nbl[0]_18 bl[0]_18 nbl[2]_17 bl[2]_17 vpw_18 vnwc_18 vddce_17
+  vddpe_17 bl[1]_17 nbl[1]_17 nbl[0]_17 bl[0]_17 nbl[2]_16 bl[2]_16 vpw_17
+  vnwc_17 vddc_16 vddce_16 vddpe_16 bl[1]_16 nbl[1]_16 nbl[0]_16 bl[0]_16
+  nbl[2]_15 bl[2]_15 vpw_16 vnwc_16 vddc_15 vddce_15 vddpe_15 bl[1]_15
+  nbl[1]_15 nbl[0]_15 bl[0]_15 nbl[2]_14 vpw_15 vnwc_15 vddc_14 vddce_14
+  vddpe_14 bl[1]_14 nbl[1]_14 nbl[0]_14 bl[0]_14 nbl[2]_13 vpw_14 vnwc_14
+  vddc_13 vddce_13 vddpe_13 bl[1]_13 nbl[1]_13 nbl[0]_13 bl[0]_13 vpw_13
+  vnwc_13 vddc_12 vddce_12 vddpe_12 bl[1]_12 nbl[1]_12 nbl[0]_12 bl[0]_12
+  vpw_12 vnwc_12 vddc_11 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11
+  bl[0]_11 nbl[2]_10 bl[2]_10 vpw_11 vnwc_11 vddc_10 vddce_10 vddpe_10
+  bl[1]_10 nbl[1]_10 nbl[0]_10 bl[0]_10 nbl[2]_9 vpw_10 vnwc_10 vddc_9
+  vddce_9 vddpe_9 bl[1]_9 nbl[1]_9 nbl[0]_9 bl[0]_9 nbl[2]_8 vpw_9 vnwc_9
+  vddc_8 vddce_8 vddpe_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 vpw_8 vnwc_8
+  vddc_7 vddce_7 vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 vpw_7 vnwc_7
+  vddc_6 vddce_6 vddpe_6 bl[1]_6 nbl[1]_6 nbl[0]_6 bl[0]_6 bl[3]_5 vpw_6
+  vnwc_6 vddc_5 vddce_5 vddpe_5 bl[1]_5 nbl[1]_5 nbl[0]_5 bl[0]_5 vpw_5
+  vnwc_5 vddc_4 vddce_4 vddpe_4 bl[1]_4 nbl[1]_4 nbl[0]_4 bl[0]_4 nbl[2]_3
+  vpw_4 vnwc_4 vddc_3 vddce_3 vddpe_3 bl[1]_3 nbl[1]_3 nbl[0]_3 bl[0]_3
+  nbl[2]_2 vpw_3 vnwc_3 vddc_2 vddce_2 vddpe_2 bl[1]_2 nbl[1]_2 nbl[0]_2
+  bl[0]_2 vpw_2 vnwc_2 vddc_1 vddce_1 vddpe_1 bl[1]_1 nbl[1]_1 nbl[0]_1
+  bl[0]_1 vpw_1 vnwc_1 vddc_0 vddce_0 vddpe_0 bl[1]_0 nbl[1]_0 nbl[0]_0
+  bl[0]_0 vnwp_0 vnwc_0 vpw_0 vnwp_1 vpw_32 vddce_31 vddpe_31 bl[1]_31
+  nbl[1]_31 nbl[0]_31 bl[0]_31 vpw_31 vnwc_31 vddc_30 vddce_30 nbl[1]_30
+  nbl[0]_30 bl[0]_30 bl[3]_29 vpw_30 vnwc_30 vddc_29 vddce_29 nbl[1]_29
+  nbl[0]_29 bl[0]_29 bl[3]_28 vpw_29 vnwc_29 vddc_28 vddce_28 nbl[1]_28
+  nbl[0]_28 bl[0]_28 bl[3]_27 nbl[3]_27 vpw_28 vnwc_28 vddc_27 vddce_27
+  nbl[1]_27 nbl[0]_27 bl[0]_27 bl[3]_26 nbl[3]_26 vpw_27 vnwc_27 vddc_26
+  vddce_26 nbl[1]_26 nbl[0]_26 bl[3]_25 bl[2]_25 vpw_26 vddc_25 nbl[0]_25
+  bl[3]_24 nbl[3]_24 vddc_24 bl[3]_23 vddc_23 bl[3]_22 nbl[3]_22 vddc_22
+  bl[3]_21 nbl[3]_21 bl[3]_20 nbl[3]_20 bl[2]_20 bl[3]_19 nbl[3]_19 bl[2]_19
+  bl[3]_18 nbl[3]_18 bl[2]_18 vddc_18 bl[3]_17 nbl[3]_17 vddc_17 bl[3]_16
+  nbl[3]_16 bl[3]_15 nbl[3]_15 bl[3]_14 nbl[3]_14 bl[2]_14 bl[3]_13 nbl[3]_13
+  bl[2]_13 bl[3]_12 nbl[3]_12 nbl[2]_12 bl[2]_12 bl[3]_11 nbl[3]_11 nbl[2]_11
+  bl[2]_11 bl[3]_10 nbl[3]_10 bl[3]_9 nbl[3]_9 bl[2]_9 bl[3]_8 nbl[3]_8
+  bl[2]_8 bl[3]_7 nbl[3]_7 nbl[2]_7 bl[2]_7 bl[3]_6 nbl[3]_6 nbl[2]_6 bl[2]_6
+  nbl[3]_5 nbl[2]_5 bl[2]_5 bl[3]_4 nbl[3]_4 nbl[2]_4 bl[2]_4 bl[3]_3
+  nbl[3]_3 bl[2]_3 bl[3]_2 nbl[3]_2 bl[2]_2 bl[3]_1 nbl[3]_1 nbl[2]_1 bl[2]_1
+  bl[3]_0 nbl[3]_0 nbl[2]_0 bl[2]_0 wl[1] wl[0]
** rf64x128mem_r_test12row: 1536 flat devices **
xmem_r_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0 ncored00_320 ncored01_322 ncored10_324
+  ncored11_326 ncored20_328 ncored21_330 ncored30_332 ncored31_334 vddc_0
+  vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_1 nbl[1]_1 nbl[2]_1 nbl[3]_1 ncored00_352 ncored01_354 ncored10_356
+  ncored11_358 ncored20_360 ncored21_362 ncored30_364 ncored31_366 vddc_1
+  vddce_1 vddpe_1 vnwc_2 vpw_2 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_624 cored01_626
+  cored10_628 cored11_630 cored20_632 cored21_634 cored30_636 cored31_638
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_640 ncored01_642
+  ncored10_644 ncored11_646 ncored20_648 ncored21_650 ncored30_652
+  ncored31_654 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_656 cored01_658
+  cored10_660 cored11_662 cored20_664 cored21_666 cored30_668 cored31_670
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_672 ncored01_674
+  ncored10_676 ncored11_678 ncored20_680 ncored21_682 ncored30_684
+  ncored31_686 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_12 bl[0]_12 bl[1]_12 bl[2]_12 bl[3]_12 cored00_688 cored01_690
+  cored10_692 cored11_694 cored20_696 cored21_698 cored30_700 cored31_702
+  nbl[0]_12 nbl[1]_12 nbl[2]_12 nbl[3]_12 ncored00_704 ncored01_706
+  ncored10_708 ncored11_710 ncored20_712 ncored21_714 ncored30_716
+  ncored31_718 vddc_12 vddce_12 vddpe_12 vnwc_13 vpw_13 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_13 bl[0]_13 bl[1]_13 bl[2]_13 bl[3]_13 cored00_752 cored01_754
+  cored10_756 cored11_758 cored20_760 cored21_762 cored30_764 cored31_766
+  nbl[0]_13 nbl[1]_13 nbl[2]_13 nbl[3]_13 ncored00_768 ncored01_770
+  ncored10_772 ncored11_774 ncored20_776 ncored21_778 ncored30_780
+  ncored31_782 vddc_13 vddce_13 vddpe_13 vnwc_14 vpw_14 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_14 bl[0]_14 bl[1]_14 bl[2]_14 bl[3]_14 cored00_816 cored01_818
+  cored10_820 cored11_822 cored20_824 cored21_826 cored30_828 cored31_830
+  nbl[0]_14 nbl[1]_14 nbl[2]_14 nbl[3]_14 ncored00_832 ncored01_834
+  ncored10_836 ncored11_838 ncored20_840 ncored21_842 ncored30_844
+  ncored31_846 vddc_14 vddce_14 vddpe_14 vnwc_15 vpw_15 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_15 bl[0]_15 bl[1]_15 bl[2]_15 bl[3]_15 cored00_848 cored01_850
+  cored10_852 cored11_854 cored20_856 cored21_858 cored30_860 cored31_862
+  nbl[0]_15 nbl[1]_15 nbl[2]_15 nbl[3]_15 ncored00_864 ncored01_866
+  ncored10_868 ncored11_870 ncored20_872 ncored21_874 ncored30_876
+  ncored31_878 vddc_15 vddce_15 vddpe_15 vnwc_16 vpw_16 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_16 bl[0]_16 bl[1]_16 bl[2]_16 bl[3]_16 cored00_880 cored01_882
+  cored10_884 cored11_886 cored20_888 cored21_890 cored30_892 cored31_894
+  nbl[0]_16 nbl[1]_16 nbl[2]_16 nbl[3]_16 ncored00_896 ncored01_898
+  ncored10_900 ncored11_902 ncored20_904 ncored21_906 ncored30_908
+  ncored31_910 vddc_16 vddce_16 vddpe_16 vnwc_17 vpw_17 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_17 bl[0]_17 bl[1]_17 bl[2]_17 bl[3]_17 cored00_912 cored01_914
+  cored10_916 cored11_918 cored20_920 cored21_922 cored30_924 cored31_926
+  nbl[0]_17 nbl[1]_17 nbl[2]_17 nbl[3]_17 ncored00_928 ncored01_930
+  ncored10_932 ncored11_934 ncored20_936 ncored21_938 ncored30_940
+  ncored31_942 vddc_17 vddce_17 vddpe_17 vnwc_18 vpw_18 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_18 bl[0]_18 bl[1]_18 bl[2]_18 bl[3]_18 cored00_944 cored01_946
+  cored10_948 cored11_950 cored20_952 cored21_954 cored30_956 cored31_958
+  nbl[0]_18 nbl[1]_18 nbl[2]_18 nbl[3]_18 ncored00_960 ncored01_962
+  ncored10_964 ncored11_966 ncored20_968 ncored21_970 ncored30_972
+  ncored31_974 vddc_18 vddce_18 vddpe_18 vnwc_19 vpw_19 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_19 bl[0]_19 bl[1]_19 bl[2]_19 bl[3]_19 cored00_976 cored01_978
+  cored10_980 cored11_982 cored20_984 cored21_986 cored30_988 cored31_990
+  nbl[0]_19 nbl[1]_19 nbl[2]_19 nbl[3]_19 ncored00_992 ncored01_994
+  ncored10_996 ncored11_998 ncored20_1000 ncored21_1002 ncored30_1004
+  ncored31_1006 vddc_19 vddce_19 vddpe_19 vnwc_20 vpw_20 vssc vssc wl[0]
+  wl[1] rf64x128cchs4
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_368 cored01_370
+  cored10_372 cored11_374 cored20_376 cored21_378 cored30_380 cored31_382
+  nbl[0]_2 nbl[1]_2 nbl[2]_2 nbl[3]_2 ncored00_384 ncored01_386 ncored10_388
+  ncored11_390 ncored20_392 ncored21_394 ncored30_396 ncored31_398 vddc_2
+  vddce_2 vddpe_2 vnwc_3 vpw_3 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_20 bl[0]_20 bl[1]_20 bl[2]_20 bl[3]_20 cored00 cored01 cored10
+  cored11 cored20 cored21 cored30 cored31 nbl[0]_20 nbl[1]_20 nbl[2]_20
+  nbl[3]_20 ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30
+  ncored31 vddc_20 vddce_20 vddpe_20 vnwc_21 vpw_21 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_21 bl[0]_21 bl[1]_21 bl[2]_21 bl[3]_21 cored00_16 cored01_18
+  cored10_20 cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_21
+  nbl[1]_21 nbl[2]_21 nbl[3]_21 ncored00_32 ncored01_34 ncored10_36
+  ncored11_38 ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_21
+  vddce_21 vddpe_21 vnwc_22 vpw_22 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_22 bl[0]_22 bl[1]_22 bl[2]_22 bl[3]_22 cored00_48 cored01_50
+  cored10_52 cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_22
+  nbl[1]_22 nbl[2]_22 nbl[3]_22 ncored00_64 ncored01_66 ncored10_68
+  ncored11_70 ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_22
+  vddce_22 vddpe_22 vnwc_23 vpw_23 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_23 bl[0]_23 bl[1]_23 bl[2]_23 bl[3]_23 cored00_80 cored01_82
+  cored10_84 cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_23
+  nbl[1]_23 nbl[2]_23 nbl[3]_23 ncored00_96 ncored01_98 ncored10_100
+  ncored11_102 ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_23
+  vddce_23 vddpe_23 vnwc_24 vpw_24 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_24 bl[0]_24 bl[1]_24 bl[2]_24 bl[3]_24 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_24 nbl[1]_24 nbl[2]_24 nbl[3]_24 ncored00_128 ncored01_130
+  ncored10_132 ncored11_134 ncored20_136 ncored21_138 ncored30_140
+  ncored31_142 vddc_24 vddce_24 vddpe_24 vnwc_25 vpw_25 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_25 bl[0]_25 bl[1]_25 bl[2]_25 bl[3]_25 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_25 nbl[1]_25 nbl[2]_25 nbl[3]_25 ncored00_160 ncored01_162
+  ncored10_164 ncored11_166 ncored20_168 ncored21_170 ncored30_172
+  ncored31_174 vddc_25 vddce_25 vddpe_25 vnwc_26 vpw_26 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_26 bl[0]_26 bl[1]_26 bl[2]_26 bl[3]_26 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_26 nbl[1]_26 nbl[2]_26 nbl[3]_26 ncored00_192 ncored01_194
+  ncored10_196 ncored11_198 ncored20_200 ncored21_202 ncored30_204
+  ncored31_206 vddc_26 vddce_26 vddpe_26 vnwc_27 vpw_27 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_27 bl[0]_27 bl[1]_27 bl[2]_27 bl[3]_27 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_27 nbl[1]_27 nbl[2]_27 nbl[3]_27 ncored00_224 ncored01_226
+  ncored10_228 ncored11_230 ncored20_232 ncored21_234 ncored30_236
+  ncored31_238 vddc_27 vddce_27 vddpe_27 vnwc_28 vpw_28 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_28 bl[0]_28 bl[1]_28 bl[2]_28 bl[3]_28 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_28 nbl[1]_28 nbl[2]_28 nbl[3]_28 ncored00_256 ncored01_258
+  ncored10_260 ncored11_262 ncored20_264 ncored21_266 ncored30_268
+  ncored31_270 vddc_28 vddce_28 vddpe_28 vnwc_29 vpw_29 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_29 bl[0]_29 bl[1]_29 bl[2]_29 bl[3]_29 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_29 nbl[1]_29 nbl[2]_29 nbl[3]_29 ncored00_288 ncored01_290
+  ncored10_292 ncored11_294 ncored20_296 ncored21_298 ncored30_300
+  ncored31_302 vddc_29 vddce_29 vddpe_29 vnwc_30 vpw_30 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_400 cored01_402
+  cored10_404 cored11_406 cored20_408 cored21_410 cored30_412 cored31_414
+  nbl[0]_3 nbl[1]_3 nbl[2]_3 nbl[3]_3 ncored00_416 ncored01_418 ncored10_420
+  ncored11_422 ncored20_424 ncored21_426 ncored30_428 ncored31_430 vddc_3
+  vddce_3 vddpe_3 vnwc_4 vpw_4 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_30 bl[0]_30 bl[1]_30 bl[2]_30 bl[3]_30 cored00_720 cored01_722
+  cored10_724 cored11_726 cored20_728 cored21_730 cored30_732 cored31_734
+  nbl[0]_30 nbl[1]_30 nbl[2]_30 nbl[3]_30 ncored00_736 ncored01_738
+  ncored10_740 ncored11_742 ncored20_744 ncored21_746 ncored30_748
+  ncored31_750 vddc_30 vddce_30 vddpe_30 vnwc_31 vpw_31 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_31 bl[0]_31 bl[1]_31 bl[2]_31 bl[3]_31 cored00_784 cored01_786
+  cored10_788 cored11_790 cored20_792 cored21_794 cored30_796 cored31_798
+  nbl[0]_31 nbl[1]_31 nbl[2]_31 nbl[3]_31 ncored00_800 ncored01_802
+  ncored10_804 ncored11_806 ncored20_808 ncored21_810 ncored30_812
+  ncored31_814 vddc_31 vddce_31 vddpe_31 vnwc_32 vpw_32 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_432 cored01_434
+  cored10_436 cored11_438 cored20_440 cored21_442 cored30_444 cored31_446
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_448 ncored01_450 ncored10_452
+  ncored11_454 ncored20_456 ncored21_458 ncored30_460 ncored31_462 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_464 cored01_466
+  cored10_468 cored11_470 cored20_472 cored21_474 cored30_476 cored31_478
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_480 ncored01_482 ncored10_484
+  ncored11_486 ncored20_488 ncored21_490 ncored30_492 ncored31_494 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_496 cored01_498
+  cored10_500 cored11_502 cored20_504 cored21_506 cored30_508 cored31_510
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_512 ncored01_514 ncored10_516
+  ncored11_518 ncored20_520 ncored21_522 ncored30_524 ncored31_526 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_528 cored01_530
+  cored10_532 cored11_534 cored20_536 cored21_538 cored30_540 cored31_542
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_544 ncored01_546 ncored10_548
+  ncored11_550 ncored20_552 ncored21_554 ncored30_556 ncored31_558 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_560 cored01_562
+  cored10_564 cored11_566 cored20_568 cored21_570 cored30_572 cored31_574
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_576 ncored01_578 ncored10_580
+  ncored11_582 ncored20_584 ncored21_586 ncored30_588 ncored31_590 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_592 cored01_594
+  cored10_596 cored11_598 cored20_600 cored21_602 cored30_604 cored31_606
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_608 ncored01_610 ncored10_612
+  ncored11_614 ncored20_616 ncored21_618 ncored30_620 ncored31_622 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] rf64x128cchs4
.ends rf64x128mem_r_test12row
****
.subckt rf64x128mem_r_test13row vpw_33 vnwc_33 bl[3]_31 nbl[3]_31 nbl[2]_31
+  bl[2]_31 vnwc_32 vddc_31 bl[3]_30 nbl[3]_30 nbl[2]_30 bl[2]_30 vddpe_30
+  bl[1]_30 nbl[3]_29 nbl[2]_29 bl[2]_29 vddpe_29 bl[1]_29 nbl[3]_28 nbl[2]_28
+  bl[2]_28 vddpe_28 bl[1]_28 nbl[2]_27 bl[2]_27 vddpe_27 bl[1]_27 nbl[2]_26
+  bl[2]_26 vddpe_26 bl[1]_26 bl[0]_26 nbl[3]_25 nbl[2]_25 vnwc_26 vddce_25
+  vddpe_25 bl[1]_25 nbl[1]_25 bl[0]_25 nbl[2]_24 bl[2]_24 vssc vpw_25 vnwc_25
+  vddce_24 vddpe_24 bl[1]_24 nbl[1]_24 nbl[0]_24 bl[0]_24 nbl[3]_23 nbl[2]_23
+  bl[2]_23 vpw_24 vnwc_24 vddce_23 vddpe_23 bl[1]_23 nbl[1]_23 nbl[0]_23
+  bl[0]_23 nbl[2]_22 bl[2]_22 vpw_23 vnwc_23 vddce_22 vddpe_22 bl[1]_22
+  nbl[1]_22 nbl[0]_22 bl[0]_22 nbl[2]_21 bl[2]_21 vpw_22 vnwc_22 vddc_21
+  vddce_21 vddpe_21 bl[1]_21 nbl[1]_21 nbl[0]_21 bl[0]_21 nbl[2]_20 vpw_21
+  vnwc_21 vddc_20 vddce_20 vddpe_20 bl[1]_20 nbl[1]_20 nbl[0]_20 bl[0]_20
+  nbl[2]_19 vpw_20 vnwc_20 vddc_19 vddce_19 vddpe_19 bl[1]_19 nbl[1]_19
+  nbl[0]_19 bl[0]_19 nbl[2]_18 vpw_19 vnwc_19 vddce_18 vddpe_18 bl[1]_18
+  nbl[1]_18 nbl[0]_18 bl[0]_18 nbl[2]_17 bl[2]_17 vpw_18 vnwc_18 vddce_17
+  vddpe_17 bl[1]_17 nbl[1]_17 nbl[0]_17 bl[0]_17 nbl[2]_16 bl[2]_16 vpw_17
+  vnwc_17 vddc_16 vddce_16 vddpe_16 bl[1]_16 nbl[1]_16 nbl[0]_16 bl[0]_16
+  nbl[2]_15 bl[2]_15 vpw_16 vnwc_16 vddc_15 vddce_15 vddpe_15 bl[1]_15
+  nbl[1]_15 nbl[0]_15 bl[0]_15 nbl[2]_14 vpw_15 vnwc_15 vddc_14 vddce_14
+  vddpe_14 bl[1]_14 nbl[1]_14 nbl[0]_14 bl[0]_14 nbl[2]_13 vpw_14 vnwc_14
+  vddc_13 vddce_13 vddpe_13 bl[1]_13 nbl[1]_13 nbl[0]_13 bl[0]_13 vpw_13
+  vnwc_13 vddc_12 vddce_12 vddpe_12 bl[1]_12 nbl[1]_12 nbl[0]_12 bl[0]_12
+  vpw_12 vnwc_12 vddc_11 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11
+  bl[0]_11 nbl[2]_10 bl[2]_10 vpw_11 vnwc_11 vddc_10 vddce_10 vddpe_10
+  bl[1]_10 nbl[1]_10 nbl[0]_10 bl[0]_10 nbl[2]_9 vpw_10 vnwc_10 vddc_9
+  vddce_9 vddpe_9 bl[1]_9 nbl[1]_9 nbl[0]_9 bl[0]_9 nbl[2]_8 vpw_9 vnwc_9
+  vddc_8 vddce_8 vddpe_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 vpw_8 vnwc_8
+  vddc_7 vddce_7 vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 vpw_7 vnwc_7
+  vddc_6 vddce_6 vddpe_6 bl[1]_6 nbl[1]_6 nbl[0]_6 bl[0]_6 bl[3]_5 vpw_6
+  vnwc_6 vddc_5 vddce_5 vddpe_5 bl[1]_5 nbl[1]_5 nbl[0]_5 bl[0]_5 vpw_5
+  vnwc_5 vddc_4 vddce_4 vddpe_4 bl[1]_4 nbl[1]_4 nbl[0]_4 bl[0]_4 nbl[2]_3
+  vpw_4 vnwc_4 vddc_3 vddce_3 vddpe_3 bl[1]_3 nbl[1]_3 nbl[0]_3 bl[0]_3
+  nbl[2]_2 vpw_3 vnwc_3 vddc_2 vddce_2 vddpe_2 bl[1]_2 nbl[1]_2 nbl[0]_2
+  bl[0]_2 vpw_2 vnwc_2 vddc_1 vddce_1 vddpe_1 bl[1]_1 nbl[1]_1 nbl[0]_1
+  bl[0]_1 vpw_1 vnwc_1 vddc_0 vddce_0 vddpe_0 bl[1]_0 nbl[1]_0 nbl[0]_0
+  bl[0]_0 vnwp_0 vnwc_0 vpw_0 vnwp_1 vpw_32 vddce_31 vddpe_31 bl[1]_31
+  nbl[1]_31 nbl[0]_31 bl[0]_31 vpw_31 vnwc_31 vddc_30 vddce_30 nbl[1]_30
+  nbl[0]_30 bl[0]_30 bl[3]_29 vpw_30 vnwc_30 vddc_29 vddce_29 nbl[1]_29
+  nbl[0]_29 bl[0]_29 bl[3]_28 vpw_29 vnwc_29 vddc_28 vddce_28 nbl[1]_28
+  nbl[0]_28 bl[0]_28 bl[3]_27 nbl[3]_27 vpw_28 vnwc_28 vddc_27 vddce_27
+  nbl[1]_27 nbl[0]_27 bl[0]_27 bl[3]_26 nbl[3]_26 vpw_27 vnwc_27 vddc_26
+  vddce_26 nbl[1]_26 nbl[0]_26 bl[3]_25 bl[2]_25 vpw_26 vddc_25 nbl[0]_25
+  bl[3]_24 nbl[3]_24 vddc_24 bl[3]_23 vddc_23 bl[3]_22 nbl[3]_22 vddc_22
+  bl[3]_21 nbl[3]_21 bl[3]_20 nbl[3]_20 bl[2]_20 bl[3]_19 nbl[3]_19 bl[2]_19
+  bl[3]_18 nbl[3]_18 bl[2]_18 vddc_18 bl[3]_17 nbl[3]_17 vddc_17 bl[3]_16
+  nbl[3]_16 bl[3]_15 nbl[3]_15 bl[3]_14 nbl[3]_14 bl[2]_14 bl[3]_13 nbl[3]_13
+  bl[2]_13 bl[3]_12 nbl[3]_12 nbl[2]_12 bl[2]_12 bl[3]_11 nbl[3]_11 nbl[2]_11
+  bl[2]_11 bl[3]_10 nbl[3]_10 bl[3]_9 nbl[3]_9 bl[2]_9 bl[3]_8 nbl[3]_8
+  bl[2]_8 bl[3]_7 nbl[3]_7 nbl[2]_7 bl[2]_7 bl[3]_6 nbl[3]_6 nbl[2]_6 bl[2]_6
+  nbl[3]_5 nbl[2]_5 bl[2]_5 bl[3]_4 nbl[3]_4 nbl[2]_4 bl[2]_4 bl[3]_3
+  nbl[3]_3 bl[2]_3 bl[3]_2 nbl[3]_2 bl[2]_2 bl[3]_1 nbl[3]_1 nbl[2]_1 bl[2]_1
+  bl[3]_0 nbl[3]_0 nbl[2]_0 bl[2]_0 wl[1] wl[0]
** rf64x128mem_r_test13row: 1536 flat devices **
xmem_r_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0 ncored00_320 ncored01_322 ncored10_324
+  ncored11_326 ncored20_328 ncored21_330 ncored30_332 ncored31_334 vddc_0
+  vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_1 nbl[1]_1 nbl[2]_1 nbl[3]_1 ncored00_352 ncored01_354 ncored10_356
+  ncored11_358 ncored20_360 ncored21_362 ncored30_364 ncored31_366 vddc_1
+  vddce_1 vddpe_1 vnwc_2 vpw_2 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_624 cored01_626
+  cored10_628 cored11_630 cored20_632 cored21_634 cored30_636 cored31_638
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_640 ncored01_642
+  ncored10_644 ncored11_646 ncored20_648 ncored21_650 ncored30_652
+  ncored31_654 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_656 cored01_658
+  cored10_660 cored11_662 cored20_664 cored21_666 cored30_668 cored31_670
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_672 ncored01_674
+  ncored10_676 ncored11_678 ncored20_680 ncored21_682 ncored30_684
+  ncored31_686 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_12 bl[0]_12 bl[1]_12 bl[2]_12 bl[3]_12 cored00_688 cored01_690
+  cored10_692 cored11_694 cored20_696 cored21_698 cored30_700 cored31_702
+  nbl[0]_12 nbl[1]_12 nbl[2]_12 nbl[3]_12 ncored00_704 ncored01_706
+  ncored10_708 ncored11_710 ncored20_712 ncored21_714 ncored30_716
+  ncored31_718 vddc_12 vddce_12 vddpe_12 vnwc_13 vpw_13 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_13 bl[0]_13 bl[1]_13 bl[2]_13 bl[3]_13 cored00_752 cored01_754
+  cored10_756 cored11_758 cored20_760 cored21_762 cored30_764 cored31_766
+  nbl[0]_13 nbl[1]_13 nbl[2]_13 nbl[3]_13 ncored00_768 ncored01_770
+  ncored10_772 ncored11_774 ncored20_776 ncored21_778 ncored30_780
+  ncored31_782 vddc_13 vddce_13 vddpe_13 vnwc_14 vpw_14 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_14 bl[0]_14 bl[1]_14 bl[2]_14 bl[3]_14 cored00_816 cored01_818
+  cored10_820 cored11_822 cored20_824 cored21_826 cored30_828 cored31_830
+  nbl[0]_14 nbl[1]_14 nbl[2]_14 nbl[3]_14 ncored00_832 ncored01_834
+  ncored10_836 ncored11_838 ncored20_840 ncored21_842 ncored30_844
+  ncored31_846 vddc_14 vddce_14 vddpe_14 vnwc_15 vpw_15 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_15 bl[0]_15 bl[1]_15 bl[2]_15 bl[3]_15 cored00_848 cored01_850
+  cored10_852 cored11_854 cored20_856 cored21_858 cored30_860 cored31_862
+  nbl[0]_15 nbl[1]_15 nbl[2]_15 nbl[3]_15 ncored00_864 ncored01_866
+  ncored10_868 ncored11_870 ncored20_872 ncored21_874 ncored30_876
+  ncored31_878 vddc_15 vddce_15 vddpe_15 vnwc_16 vpw_16 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_16 bl[0]_16 bl[1]_16 bl[2]_16 bl[3]_16 cored00_880 cored01_882
+  cored10_884 cored11_886 cored20_888 cored21_890 cored30_892 cored31_894
+  nbl[0]_16 nbl[1]_16 nbl[2]_16 nbl[3]_16 ncored00_896 ncored01_898
+  ncored10_900 ncored11_902 ncored20_904 ncored21_906 ncored30_908
+  ncored31_910 vddc_16 vddce_16 vddpe_16 vnwc_17 vpw_17 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_17 bl[0]_17 bl[1]_17 bl[2]_17 bl[3]_17 cored00_912 cored01_914
+  cored10_916 cored11_918 cored20_920 cored21_922 cored30_924 cored31_926
+  nbl[0]_17 nbl[1]_17 nbl[2]_17 nbl[3]_17 ncored00_928 ncored01_930
+  ncored10_932 ncored11_934 ncored20_936 ncored21_938 ncored30_940
+  ncored31_942 vddc_17 vddce_17 vddpe_17 vnwc_18 vpw_18 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_18 bl[0]_18 bl[1]_18 bl[2]_18 bl[3]_18 cored00_944 cored01_946
+  cored10_948 cored11_950 cored20_952 cored21_954 cored30_956 cored31_958
+  nbl[0]_18 nbl[1]_18 nbl[2]_18 nbl[3]_18 ncored00_960 ncored01_962
+  ncored10_964 ncored11_966 ncored20_968 ncored21_970 ncored30_972
+  ncored31_974 vddc_18 vddce_18 vddpe_18 vnwc_19 vpw_19 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_19 bl[0]_19 bl[1]_19 bl[2]_19 bl[3]_19 cored00_976 cored01_978
+  cored10_980 cored11_982 cored20_984 cored21_986 cored30_988 cored31_990
+  nbl[0]_19 nbl[1]_19 nbl[2]_19 nbl[3]_19 ncored00_992 ncored01_994
+  ncored10_996 ncored11_998 ncored20_1000 ncored21_1002 ncored30_1004
+  ncored31_1006 vddc_19 vddce_19 vddpe_19 vnwc_20 vpw_20 vssc vssc wl[0]
+  wl[1] rf64x128cchs4
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_368 cored01_370
+  cored10_372 cored11_374 cored20_376 cored21_378 cored30_380 cored31_382
+  nbl[0]_2 nbl[1]_2 nbl[2]_2 nbl[3]_2 ncored00_384 ncored01_386 ncored10_388
+  ncored11_390 ncored20_392 ncored21_394 ncored30_396 ncored31_398 vddc_2
+  vddce_2 vddpe_2 vnwc_3 vpw_3 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_20 bl[0]_20 bl[1]_20 bl[2]_20 bl[3]_20 cored00 cored01 cored10
+  cored11 cored20 cored21 cored30 cored31 nbl[0]_20 nbl[1]_20 nbl[2]_20
+  nbl[3]_20 ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30
+  ncored31 vddc_20 vddce_20 vddpe_20 vnwc_21 vpw_21 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_21 bl[0]_21 bl[1]_21 bl[2]_21 bl[3]_21 cored00_16 cored01_18
+  cored10_20 cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_21
+  nbl[1]_21 nbl[2]_21 nbl[3]_21 ncored00_32 ncored01_34 ncored10_36
+  ncored11_38 ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_21
+  vddce_21 vddpe_21 vnwc_22 vpw_22 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_22 bl[0]_22 bl[1]_22 bl[2]_22 bl[3]_22 cored00_48 cored01_50
+  cored10_52 cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_22
+  nbl[1]_22 nbl[2]_22 nbl[3]_22 ncored00_64 ncored01_66 ncored10_68
+  ncored11_70 ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_22
+  vddce_22 vddpe_22 vnwc_23 vpw_23 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_23 bl[0]_23 bl[1]_23 bl[2]_23 bl[3]_23 cored00_80 cored01_82
+  cored10_84 cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_23
+  nbl[1]_23 nbl[2]_23 nbl[3]_23 ncored00_96 ncored01_98 ncored10_100
+  ncored11_102 ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_23
+  vddce_23 vddpe_23 vnwc_24 vpw_24 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_24 bl[0]_24 bl[1]_24 bl[2]_24 bl[3]_24 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_24 nbl[1]_24 nbl[2]_24 nbl[3]_24 ncored00_128 ncored01_130
+  ncored10_132 ncored11_134 ncored20_136 ncored21_138 ncored30_140
+  ncored31_142 vddc_24 vddce_24 vddpe_24 vnwc_25 vpw_25 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_25 bl[0]_25 bl[1]_25 bl[2]_25 bl[3]_25 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_25 nbl[1]_25 nbl[2]_25 nbl[3]_25 ncored00_160 ncored01_162
+  ncored10_164 ncored11_166 ncored20_168 ncored21_170 ncored30_172
+  ncored31_174 vddc_25 vddce_25 vddpe_25 vnwc_26 vpw_26 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_26 bl[0]_26 bl[1]_26 bl[2]_26 bl[3]_26 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_26 nbl[1]_26 nbl[2]_26 nbl[3]_26 ncored00_192 ncored01_194
+  ncored10_196 ncored11_198 ncored20_200 ncored21_202 ncored30_204
+  ncored31_206 vddc_26 vddce_26 vddpe_26 vnwc_27 vpw_27 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_27 bl[0]_27 bl[1]_27 bl[2]_27 bl[3]_27 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_27 nbl[1]_27 nbl[2]_27 nbl[3]_27 ncored00_224 ncored01_226
+  ncored10_228 ncored11_230 ncored20_232 ncored21_234 ncored30_236
+  ncored31_238 vddc_27 vddce_27 vddpe_27 vnwc_28 vpw_28 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_28 bl[0]_28 bl[1]_28 bl[2]_28 bl[3]_28 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_28 nbl[1]_28 nbl[2]_28 nbl[3]_28 ncored00_256 ncored01_258
+  ncored10_260 ncored11_262 ncored20_264 ncored21_266 ncored30_268
+  ncored31_270 vddc_28 vddce_28 vddpe_28 vnwc_29 vpw_29 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_29 bl[0]_29 bl[1]_29 bl[2]_29 bl[3]_29 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_29 nbl[1]_29 nbl[2]_29 nbl[3]_29 ncored00_288 ncored01_290
+  ncored10_292 ncored11_294 ncored20_296 ncored21_298 ncored30_300
+  ncored31_302 vddc_29 vddce_29 vddpe_29 vnwc_30 vpw_30 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_400 cored01_402
+  cored10_404 cored11_406 cored20_408 cored21_410 cored30_412 cored31_414
+  nbl[0]_3 nbl[1]_3 nbl[2]_3 nbl[3]_3 ncored00_416 ncored01_418 ncored10_420
+  ncored11_422 ncored20_424 ncored21_426 ncored30_428 ncored31_430 vddc_3
+  vddce_3 vddpe_3 vnwc_4 vpw_4 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_30 bl[0]_30 bl[1]_30 bl[2]_30 bl[3]_30 cored00_720 cored01_722
+  cored10_724 cored11_726 cored20_728 cored21_730 cored30_732 cored31_734
+  nbl[0]_30 nbl[1]_30 nbl[2]_30 nbl[3]_30 ncored00_736 ncored01_738
+  ncored10_740 ncored11_742 ncored20_744 ncored21_746 ncored30_748
+  ncored31_750 vddc_30 vddce_30 vddpe_30 vnwc_31 vpw_31 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_31 bl[0]_31 bl[1]_31 bl[2]_31 bl[3]_31 cored00_784 cored01_786
+  cored10_788 cored11_790 cored20_792 cored21_794 cored30_796 cored31_798
+  nbl[0]_31 nbl[1]_31 nbl[2]_31 nbl[3]_31 ncored00_800 ncored01_802
+  ncored10_804 ncored11_806 ncored20_808 ncored21_810 ncored30_812
+  ncored31_814 vddc_31 vddce_31 vddpe_31 vnwc_32 vpw_32 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_432 cored01_434
+  cored10_436 cored11_438 cored20_440 cored21_442 cored30_444 cored31_446
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_448 ncored01_450 ncored10_452
+  ncored11_454 ncored20_456 ncored21_458 ncored30_460 ncored31_462 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_464 cored01_466
+  cored10_468 cored11_470 cored20_472 cored21_474 cored30_476 cored31_478
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_480 ncored01_482 ncored10_484
+  ncored11_486 ncored20_488 ncored21_490 ncored30_492 ncored31_494 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_496 cored01_498
+  cored10_500 cored11_502 cored20_504 cored21_506 cored30_508 cored31_510
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_512 ncored01_514 ncored10_516
+  ncored11_518 ncored20_520 ncored21_522 ncored30_524 ncored31_526 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_528 cored01_530
+  cored10_532 cored11_534 cored20_536 cored21_538 cored30_540 cored31_542
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_544 ncored01_546 ncored10_548
+  ncored11_550 ncored20_552 ncored21_554 ncored30_556 ncored31_558 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_560 cored01_562
+  cored10_564 cored11_566 cored20_568 cored21_570 cored30_572 cored31_574
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_576 ncored01_578 ncored10_580
+  ncored11_582 ncored20_584 ncored21_586 ncored30_588 ncored31_590 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_592 cored01_594
+  cored10_596 cored11_598 cored20_600 cored21_602 cored30_604 cored31_606
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_608 ncored01_610 ncored10_612
+  ncored11_614 ncored20_616 ncored21_618 ncored30_620 ncored31_622 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] rf64x128cchs4
.ends rf64x128mem_r_test13row
****
.subckt rf64x128mem_r_test14row vpw_33 vnwc_33 bl[3]_31 nbl[3]_31 nbl[2]_31
+  bl[2]_31 vnwc_32 vddc_31 bl[3]_30 nbl[3]_30 nbl[2]_30 bl[2]_30 vddpe_30
+  bl[1]_30 nbl[3]_29 nbl[2]_29 bl[2]_29 vddpe_29 bl[1]_29 nbl[3]_28 nbl[2]_28
+  bl[2]_28 vddpe_28 bl[1]_28 nbl[2]_27 bl[2]_27 vddpe_27 bl[1]_27 nbl[2]_26
+  bl[2]_26 vddpe_26 bl[1]_26 bl[0]_26 nbl[3]_25 nbl[2]_25 vnwc_26 vddce_25
+  vddpe_25 bl[1]_25 nbl[1]_25 bl[0]_25 nbl[2]_24 bl[2]_24 vssc vpw_25 vnwc_25
+  vddce_24 vddpe_24 bl[1]_24 nbl[1]_24 nbl[0]_24 bl[0]_24 nbl[3]_23 nbl[2]_23
+  bl[2]_23 vpw_24 vnwc_24 vddce_23 vddpe_23 bl[1]_23 nbl[1]_23 nbl[0]_23
+  bl[0]_23 nbl[2]_22 bl[2]_22 vpw_23 vnwc_23 vddce_22 vddpe_22 bl[1]_22
+  nbl[1]_22 nbl[0]_22 bl[0]_22 nbl[2]_21 bl[2]_21 vpw_22 vnwc_22 vddc_21
+  vddce_21 vddpe_21 bl[1]_21 nbl[1]_21 nbl[0]_21 bl[0]_21 nbl[2]_20 vpw_21
+  vnwc_21 vddc_20 vddce_20 vddpe_20 bl[1]_20 nbl[1]_20 nbl[0]_20 bl[0]_20
+  nbl[2]_19 vpw_20 vnwc_20 vddc_19 vddce_19 vddpe_19 bl[1]_19 nbl[1]_19
+  nbl[0]_19 bl[0]_19 nbl[2]_18 vpw_19 vnwc_19 vddce_18 vddpe_18 bl[1]_18
+  nbl[1]_18 nbl[0]_18 bl[0]_18 nbl[2]_17 bl[2]_17 vpw_18 vnwc_18 vddce_17
+  vddpe_17 bl[1]_17 nbl[1]_17 nbl[0]_17 bl[0]_17 nbl[2]_16 bl[2]_16 vpw_17
+  vnwc_17 vddc_16 vddce_16 vddpe_16 bl[1]_16 nbl[1]_16 nbl[0]_16 bl[0]_16
+  nbl[2]_15 bl[2]_15 vpw_16 vnwc_16 vddc_15 vddce_15 vddpe_15 bl[1]_15
+  nbl[1]_15 nbl[0]_15 bl[0]_15 nbl[2]_14 vpw_15 vnwc_15 vddc_14 vddce_14
+  vddpe_14 bl[1]_14 nbl[1]_14 nbl[0]_14 bl[0]_14 nbl[2]_13 vpw_14 vnwc_14
+  vddc_13 vddce_13 vddpe_13 bl[1]_13 nbl[1]_13 nbl[0]_13 bl[0]_13 vpw_13
+  vnwc_13 vddc_12 vddce_12 vddpe_12 bl[1]_12 nbl[1]_12 nbl[0]_12 bl[0]_12
+  vpw_12 vnwc_12 vddc_11 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11
+  bl[0]_11 nbl[2]_10 bl[2]_10 vpw_11 vnwc_11 vddc_10 vddce_10 vddpe_10
+  bl[1]_10 nbl[1]_10 nbl[0]_10 bl[0]_10 nbl[2]_9 vpw_10 vnwc_10 vddc_9
+  vddce_9 vddpe_9 bl[1]_9 nbl[1]_9 nbl[0]_9 bl[0]_9 nbl[2]_8 vpw_9 vnwc_9
+  vddc_8 vddce_8 vddpe_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 vpw_8 vnwc_8
+  vddc_7 vddce_7 vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 vpw_7 vnwc_7
+  vddc_6 vddce_6 vddpe_6 bl[1]_6 nbl[1]_6 nbl[0]_6 bl[0]_6 bl[3]_5 vpw_6
+  vnwc_6 vddc_5 vddce_5 vddpe_5 bl[1]_5 nbl[1]_5 nbl[0]_5 bl[0]_5 vpw_5
+  vnwc_5 vddc_4 vddce_4 vddpe_4 bl[1]_4 nbl[1]_4 nbl[0]_4 bl[0]_4 nbl[2]_3
+  vpw_4 vnwc_4 vddc_3 vddce_3 vddpe_3 bl[1]_3 nbl[1]_3 nbl[0]_3 bl[0]_3
+  nbl[2]_2 vpw_3 vnwc_3 vddc_2 vddce_2 vddpe_2 bl[1]_2 nbl[1]_2 nbl[0]_2
+  bl[0]_2 vpw_2 vnwc_2 vddc_1 vddce_1 vddpe_1 bl[1]_1 nbl[1]_1 nbl[0]_1
+  bl[0]_1 vpw_1 vnwc_1 vddc_0 vddce_0 vddpe_0 bl[1]_0 nbl[1]_0 nbl[0]_0
+  bl[0]_0 vnwp_0 vnwc_0 vpw_0 vnwp_1 vpw_32 vddce_31 vddpe_31 bl[1]_31
+  nbl[1]_31 nbl[0]_31 bl[0]_31 vpw_31 vnwc_31 vddc_30 vddce_30 nbl[1]_30
+  nbl[0]_30 bl[0]_30 bl[3]_29 vpw_30 vnwc_30 vddc_29 vddce_29 nbl[1]_29
+  nbl[0]_29 bl[0]_29 bl[3]_28 vpw_29 vnwc_29 vddc_28 vddce_28 nbl[1]_28
+  nbl[0]_28 bl[0]_28 bl[3]_27 nbl[3]_27 vpw_28 vnwc_28 vddc_27 vddce_27
+  nbl[1]_27 nbl[0]_27 bl[0]_27 bl[3]_26 nbl[3]_26 vpw_27 vnwc_27 vddc_26
+  vddce_26 nbl[1]_26 nbl[0]_26 bl[3]_25 bl[2]_25 vpw_26 vddc_25 nbl[0]_25
+  bl[3]_24 nbl[3]_24 vddc_24 bl[3]_23 vddc_23 bl[3]_22 nbl[3]_22 vddc_22
+  bl[3]_21 nbl[3]_21 bl[3]_20 nbl[3]_20 bl[2]_20 bl[3]_19 nbl[3]_19 bl[2]_19
+  bl[3]_18 nbl[3]_18 bl[2]_18 vddc_18 bl[3]_17 nbl[3]_17 vddc_17 bl[3]_16
+  nbl[3]_16 bl[3]_15 nbl[3]_15 bl[3]_14 nbl[3]_14 bl[2]_14 bl[3]_13 nbl[3]_13
+  bl[2]_13 bl[3]_12 nbl[3]_12 nbl[2]_12 bl[2]_12 bl[3]_11 nbl[3]_11 nbl[2]_11
+  bl[2]_11 bl[3]_10 nbl[3]_10 bl[3]_9 nbl[3]_9 bl[2]_9 bl[3]_8 nbl[3]_8
+  bl[2]_8 bl[3]_7 nbl[3]_7 nbl[2]_7 bl[2]_7 bl[3]_6 nbl[3]_6 nbl[2]_6 bl[2]_6
+  nbl[3]_5 nbl[2]_5 bl[2]_5 bl[3]_4 nbl[3]_4 nbl[2]_4 bl[2]_4 bl[3]_3
+  nbl[3]_3 bl[2]_3 bl[3]_2 nbl[3]_2 bl[2]_2 bl[3]_1 nbl[3]_1 nbl[2]_1 bl[2]_1
+  bl[3]_0 nbl[3]_0 nbl[2]_0 bl[2]_0 wl[1] wl[0]
** rf64x128mem_r_test14row: 1536 flat devices **
xmem_r_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0 ncored00_320 ncored01_322 ncored10_324
+  ncored11_326 ncored20_328 ncored21_330 ncored30_332 ncored31_334 vddc_0
+  vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_1 nbl[1]_1 nbl[2]_1 nbl[3]_1 ncored00_352 ncored01_354 ncored10_356
+  ncored11_358 ncored20_360 ncored21_362 ncored30_364 ncored31_366 vddc_1
+  vddce_1 vddpe_1 vnwc_2 vpw_2 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_624 cored01_626
+  cored10_628 cored11_630 cored20_632 cored21_634 cored30_636 cored31_638
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_640 ncored01_642
+  ncored10_644 ncored11_646 ncored20_648 ncored21_650 ncored30_652
+  ncored31_654 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_656 cored01_658
+  cored10_660 cored11_662 cored20_664 cored21_666 cored30_668 cored31_670
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_672 ncored01_674
+  ncored10_676 ncored11_678 ncored20_680 ncored21_682 ncored30_684
+  ncored31_686 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_12 bl[0]_12 bl[1]_12 bl[2]_12 bl[3]_12 cored00_688 cored01_690
+  cored10_692 cored11_694 cored20_696 cored21_698 cored30_700 cored31_702
+  nbl[0]_12 nbl[1]_12 nbl[2]_12 nbl[3]_12 ncored00_704 ncored01_706
+  ncored10_708 ncored11_710 ncored20_712 ncored21_714 ncored30_716
+  ncored31_718 vddc_12 vddce_12 vddpe_12 vnwc_13 vpw_13 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_13 bl[0]_13 bl[1]_13 bl[2]_13 bl[3]_13 cored00_752 cored01_754
+  cored10_756 cored11_758 cored20_760 cored21_762 cored30_764 cored31_766
+  nbl[0]_13 nbl[1]_13 nbl[2]_13 nbl[3]_13 ncored00_768 ncored01_770
+  ncored10_772 ncored11_774 ncored20_776 ncored21_778 ncored30_780
+  ncored31_782 vddc_13 vddce_13 vddpe_13 vnwc_14 vpw_14 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_14 bl[0]_14 bl[1]_14 bl[2]_14 bl[3]_14 cored00_816 cored01_818
+  cored10_820 cored11_822 cored20_824 cored21_826 cored30_828 cored31_830
+  nbl[0]_14 nbl[1]_14 nbl[2]_14 nbl[3]_14 ncored00_832 ncored01_834
+  ncored10_836 ncored11_838 ncored20_840 ncored21_842 ncored30_844
+  ncored31_846 vddc_14 vddce_14 vddpe_14 vnwc_15 vpw_15 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_15 bl[0]_15 bl[1]_15 bl[2]_15 bl[3]_15 cored00_848 cored01_850
+  cored10_852 cored11_854 cored20_856 cored21_858 cored30_860 cored31_862
+  nbl[0]_15 nbl[1]_15 nbl[2]_15 nbl[3]_15 ncored00_864 ncored01_866
+  ncored10_868 ncored11_870 ncored20_872 ncored21_874 ncored30_876
+  ncored31_878 vddc_15 vddce_15 vddpe_15 vnwc_16 vpw_16 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_16 bl[0]_16 bl[1]_16 bl[2]_16 bl[3]_16 cored00_880 cored01_882
+  cored10_884 cored11_886 cored20_888 cored21_890 cored30_892 cored31_894
+  nbl[0]_16 nbl[1]_16 nbl[2]_16 nbl[3]_16 ncored00_896 ncored01_898
+  ncored10_900 ncored11_902 ncored20_904 ncored21_906 ncored30_908
+  ncored31_910 vddc_16 vddce_16 vddpe_16 vnwc_17 vpw_17 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_17 bl[0]_17 bl[1]_17 bl[2]_17 bl[3]_17 cored00_912 cored01_914
+  cored10_916 cored11_918 cored20_920 cored21_922 cored30_924 cored31_926
+  nbl[0]_17 nbl[1]_17 nbl[2]_17 nbl[3]_17 ncored00_928 ncored01_930
+  ncored10_932 ncored11_934 ncored20_936 ncored21_938 ncored30_940
+  ncored31_942 vddc_17 vddce_17 vddpe_17 vnwc_18 vpw_18 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_18 bl[0]_18 bl[1]_18 bl[2]_18 bl[3]_18 cored00_944 cored01_946
+  cored10_948 cored11_950 cored20_952 cored21_954 cored30_956 cored31_958
+  nbl[0]_18 nbl[1]_18 nbl[2]_18 nbl[3]_18 ncored00_960 ncored01_962
+  ncored10_964 ncored11_966 ncored20_968 ncored21_970 ncored30_972
+  ncored31_974 vddc_18 vddce_18 vddpe_18 vnwc_19 vpw_19 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_19 bl[0]_19 bl[1]_19 bl[2]_19 bl[3]_19 cored00_976 cored01_978
+  cored10_980 cored11_982 cored20_984 cored21_986 cored30_988 cored31_990
+  nbl[0]_19 nbl[1]_19 nbl[2]_19 nbl[3]_19 ncored00_992 ncored01_994
+  ncored10_996 ncored11_998 ncored20_1000 ncored21_1002 ncored30_1004
+  ncored31_1006 vddc_19 vddce_19 vddpe_19 vnwc_20 vpw_20 vssc vssc wl[0]
+  wl[1] rf64x128cchs4
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_368 cored01_370
+  cored10_372 cored11_374 cored20_376 cored21_378 cored30_380 cored31_382
+  nbl[0]_2 nbl[1]_2 nbl[2]_2 nbl[3]_2 ncored00_384 ncored01_386 ncored10_388
+  ncored11_390 ncored20_392 ncored21_394 ncored30_396 ncored31_398 vddc_2
+  vddce_2 vddpe_2 vnwc_3 vpw_3 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_20 bl[0]_20 bl[1]_20 bl[2]_20 bl[3]_20 cored00 cored01 cored10
+  cored11 cored20 cored21 cored30 cored31 nbl[0]_20 nbl[1]_20 nbl[2]_20
+  nbl[3]_20 ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30
+  ncored31 vddc_20 vddce_20 vddpe_20 vnwc_21 vpw_21 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_21 bl[0]_21 bl[1]_21 bl[2]_21 bl[3]_21 cored00_16 cored01_18
+  cored10_20 cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_21
+  nbl[1]_21 nbl[2]_21 nbl[3]_21 ncored00_32 ncored01_34 ncored10_36
+  ncored11_38 ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_21
+  vddce_21 vddpe_21 vnwc_22 vpw_22 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_22 bl[0]_22 bl[1]_22 bl[2]_22 bl[3]_22 cored00_48 cored01_50
+  cored10_52 cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_22
+  nbl[1]_22 nbl[2]_22 nbl[3]_22 ncored00_64 ncored01_66 ncored10_68
+  ncored11_70 ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_22
+  vddce_22 vddpe_22 vnwc_23 vpw_23 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_23 bl[0]_23 bl[1]_23 bl[2]_23 bl[3]_23 cored00_80 cored01_82
+  cored10_84 cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_23
+  nbl[1]_23 nbl[2]_23 nbl[3]_23 ncored00_96 ncored01_98 ncored10_100
+  ncored11_102 ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_23
+  vddce_23 vddpe_23 vnwc_24 vpw_24 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_24 bl[0]_24 bl[1]_24 bl[2]_24 bl[3]_24 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_24 nbl[1]_24 nbl[2]_24 nbl[3]_24 ncored00_128 ncored01_130
+  ncored10_132 ncored11_134 ncored20_136 ncored21_138 ncored30_140
+  ncored31_142 vddc_24 vddce_24 vddpe_24 vnwc_25 vpw_25 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_25 bl[0]_25 bl[1]_25 bl[2]_25 bl[3]_25 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_25 nbl[1]_25 nbl[2]_25 nbl[3]_25 ncored00_160 ncored01_162
+  ncored10_164 ncored11_166 ncored20_168 ncored21_170 ncored30_172
+  ncored31_174 vddc_25 vddce_25 vddpe_25 vnwc_26 vpw_26 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_26 bl[0]_26 bl[1]_26 bl[2]_26 bl[3]_26 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_26 nbl[1]_26 nbl[2]_26 nbl[3]_26 ncored00_192 ncored01_194
+  ncored10_196 ncored11_198 ncored20_200 ncored21_202 ncored30_204
+  ncored31_206 vddc_26 vddce_26 vddpe_26 vnwc_27 vpw_27 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_27 bl[0]_27 bl[1]_27 bl[2]_27 bl[3]_27 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_27 nbl[1]_27 nbl[2]_27 nbl[3]_27 ncored00_224 ncored01_226
+  ncored10_228 ncored11_230 ncored20_232 ncored21_234 ncored30_236
+  ncored31_238 vddc_27 vddce_27 vddpe_27 vnwc_28 vpw_28 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_28 bl[0]_28 bl[1]_28 bl[2]_28 bl[3]_28 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_28 nbl[1]_28 nbl[2]_28 nbl[3]_28 ncored00_256 ncored01_258
+  ncored10_260 ncored11_262 ncored20_264 ncored21_266 ncored30_268
+  ncored31_270 vddc_28 vddce_28 vddpe_28 vnwc_29 vpw_29 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_29 bl[0]_29 bl[1]_29 bl[2]_29 bl[3]_29 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_29 nbl[1]_29 nbl[2]_29 nbl[3]_29 ncored00_288 ncored01_290
+  ncored10_292 ncored11_294 ncored20_296 ncored21_298 ncored30_300
+  ncored31_302 vddc_29 vddce_29 vddpe_29 vnwc_30 vpw_30 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_400 cored01_402
+  cored10_404 cored11_406 cored20_408 cored21_410 cored30_412 cored31_414
+  nbl[0]_3 nbl[1]_3 nbl[2]_3 nbl[3]_3 ncored00_416 ncored01_418 ncored10_420
+  ncored11_422 ncored20_424 ncored21_426 ncored30_428 ncored31_430 vddc_3
+  vddce_3 vddpe_3 vnwc_4 vpw_4 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_30 bl[0]_30 bl[1]_30 bl[2]_30 bl[3]_30 cored00_720 cored01_722
+  cored10_724 cored11_726 cored20_728 cored21_730 cored30_732 cored31_734
+  nbl[0]_30 nbl[1]_30 nbl[2]_30 nbl[3]_30 ncored00_736 ncored01_738
+  ncored10_740 ncored11_742 ncored20_744 ncored21_746 ncored30_748
+  ncored31_750 vddc_30 vddce_30 vddpe_30 vnwc_31 vpw_31 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_31 bl[0]_31 bl[1]_31 bl[2]_31 bl[3]_31 cored00_784 cored01_786
+  cored10_788 cored11_790 cored20_792 cored21_794 cored30_796 cored31_798
+  nbl[0]_31 nbl[1]_31 nbl[2]_31 nbl[3]_31 ncored00_800 ncored01_802
+  ncored10_804 ncored11_806 ncored20_808 ncored21_810 ncored30_812
+  ncored31_814 vddc_31 vddce_31 vddpe_31 vnwc_32 vpw_32 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_432 cored01_434
+  cored10_436 cored11_438 cored20_440 cored21_442 cored30_444 cored31_446
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_448 ncored01_450 ncored10_452
+  ncored11_454 ncored20_456 ncored21_458 ncored30_460 ncored31_462 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_464 cored01_466
+  cored10_468 cored11_470 cored20_472 cored21_474 cored30_476 cored31_478
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_480 ncored01_482 ncored10_484
+  ncored11_486 ncored20_488 ncored21_490 ncored30_492 ncored31_494 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_496 cored01_498
+  cored10_500 cored11_502 cored20_504 cored21_506 cored30_508 cored31_510
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_512 ncored01_514 ncored10_516
+  ncored11_518 ncored20_520 ncored21_522 ncored30_524 ncored31_526 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_528 cored01_530
+  cored10_532 cored11_534 cored20_536 cored21_538 cored30_540 cored31_542
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_544 ncored01_546 ncored10_548
+  ncored11_550 ncored20_552 ncored21_554 ncored30_556 ncored31_558 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_560 cored01_562
+  cored10_564 cored11_566 cored20_568 cored21_570 cored30_572 cored31_574
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_576 ncored01_578 ncored10_580
+  ncored11_582 ncored20_584 ncored21_586 ncored30_588 ncored31_590 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_592 cored01_594
+  cored10_596 cored11_598 cored20_600 cored21_602 cored30_604 cored31_606
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_608 ncored01_610 ncored10_612
+  ncored11_614 ncored20_616 ncored21_618 ncored30_620 ncored31_622 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] rf64x128cchs4
.ends rf64x128mem_r_test14row
****
.subckt rf64x128mem_r_midt_row vpw_33 vnwc_33 bl[3]_31 nbl[3]_31 nbl[2]_31
+  bl[2]_31 vnwc_32 vddc_31 bl[3]_30 nbl[3]_30 nbl[2]_30 bl[2]_30 vddpe_30
+  bl[1]_30 nbl[3]_29 nbl[2]_29 bl[2]_29 vddpe_29 bl[1]_29 nbl[3]_28 nbl[2]_28
+  bl[2]_28 vddpe_28 bl[1]_28 nbl[2]_27 bl[2]_27 vddpe_27 bl[1]_27 nbl[2]_26
+  bl[2]_26 vddpe_26 bl[1]_26 bl[0]_26 nbl[3]_25 nbl[2]_25 vnwc_26 vddce_25
+  vddpe_25 bl[1]_25 nbl[1]_25 bl[0]_25 nbl[2]_24 bl[2]_24 vssc vpw_25 vnwc_25
+  vddce_24 vddpe_24 bl[1]_24 nbl[1]_24 nbl[0]_24 bl[0]_24 nbl[3]_23 nbl[2]_23
+  bl[2]_23 vpw_24 vnwc_24 vddce_23 vddpe_23 bl[1]_23 nbl[1]_23 nbl[0]_23
+  bl[0]_23 nbl[2]_22 bl[2]_22 vpw_23 vnwc_23 vddce_22 vddpe_22 bl[1]_22
+  nbl[1]_22 nbl[0]_22 bl[0]_22 nbl[2]_21 bl[2]_21 vpw_22 vnwc_22 vddc_21
+  vddce_21 vddpe_21 bl[1]_21 nbl[1]_21 nbl[0]_21 bl[0]_21 nbl[2]_20 vpw_21
+  vnwc_21 vddc_20 vddce_20 vddpe_20 bl[1]_20 nbl[1]_20 nbl[0]_20 bl[0]_20
+  nbl[2]_19 vpw_20 vnwc_20 vddc_19 vddce_19 vddpe_19 bl[1]_19 nbl[1]_19
+  nbl[0]_19 bl[0]_19 nbl[2]_18 vpw_19 vnwc_19 vddce_18 vddpe_18 bl[1]_18
+  nbl[1]_18 nbl[0]_18 bl[0]_18 nbl[2]_17 bl[2]_17 vpw_18 vnwc_18 vddce_17
+  vddpe_17 bl[1]_17 nbl[1]_17 nbl[0]_17 bl[0]_17 nbl[2]_16 bl[2]_16 vpw_17
+  vnwc_17 vddc_16 vddce_16 vddpe_16 bl[1]_16 nbl[1]_16 nbl[0]_16 bl[0]_16
+  nbl[2]_15 bl[2]_15 vpw_16 vnwc_16 vddc_15 vddce_15 vddpe_15 bl[1]_15
+  nbl[1]_15 nbl[0]_15 bl[0]_15 nbl[2]_14 vpw_15 vnwc_15 vddc_14 vddce_14
+  vddpe_14 bl[1]_14 nbl[1]_14 nbl[0]_14 bl[0]_14 nbl[2]_13 vpw_14 vnwc_14
+  vddc_13 vddce_13 vddpe_13 bl[1]_13 nbl[1]_13 nbl[0]_13 bl[0]_13 vpw_13
+  vnwc_13 vddc_12 vddce_12 vddpe_12 bl[1]_12 nbl[1]_12 nbl[0]_12 bl[0]_12
+  vpw_12 vnwc_12 vddc_11 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11
+  bl[0]_11 nbl[2]_10 bl[2]_10 vpw_11 vnwc_11 vddc_10 vddce_10 vddpe_10
+  bl[1]_10 nbl[1]_10 nbl[0]_10 bl[0]_10 nbl[2]_9 vpw_10 vnwc_10 vddc_9
+  vddce_9 vddpe_9 bl[1]_9 nbl[1]_9 nbl[0]_9 bl[0]_9 nbl[2]_8 vpw_9 vnwc_9
+  vddc_8 vddce_8 vddpe_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 vpw_8 vnwc_8
+  vddc_7 vddce_7 vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 vpw_7 vnwc_7
+  vddc_6 vddce_6 vddpe_6 bl[1]_6 nbl[1]_6 nbl[0]_6 bl[0]_6 bl[3]_5 vpw_6
+  vnwc_6 vddc_5 vddce_5 vddpe_5 bl[1]_5 nbl[1]_5 nbl[0]_5 bl[0]_5 vpw_5
+  vnwc_5 vddc_4 vddce_4 vddpe_4 bl[1]_4 nbl[1]_4 nbl[0]_4 bl[0]_4 nbl[2]_3
+  vpw_4 vnwc_4 vddc_3 vddce_3 vddpe_3 bl[1]_3 nbl[1]_3 nbl[0]_3 bl[0]_3
+  nbl[2]_2 vpw_3 vnwc_3 vddc_2 vddce_2 vddpe_2 bl[1]_2 nbl[1]_2 nbl[0]_2
+  bl[0]_2 vpw_2 vnwc_2 vddc_1 vddce_1 vddpe_1 bl[1]_1 nbl[1]_1 nbl[0]_1
+  bl[0]_1 vpw_1 vnwc_1 vddc_0 vddce_0 vddpe_0 bl[1]_0 nbl[1]_0 nbl[0]_0
+  bl[0]_0 vnwp_0 vnwc_0 vpw_0 vnwp_1 vpw_32 vddce_31 vddpe_31 bl[1]_31
+  nbl[1]_31 nbl[0]_31 bl[0]_31 vpw_31 vnwc_31 vddc_30 vddce_30 nbl[1]_30
+  nbl[0]_30 bl[0]_30 bl[3]_29 vpw_30 vnwc_30 vddc_29 vddce_29 nbl[1]_29
+  nbl[0]_29 bl[0]_29 bl[3]_28 vpw_29 vnwc_29 vddc_28 vddce_28 nbl[1]_28
+  nbl[0]_28 bl[0]_28 bl[3]_27 nbl[3]_27 vpw_28 vnwc_28 vddc_27 vddce_27
+  nbl[1]_27 nbl[0]_27 bl[0]_27 bl[3]_26 nbl[3]_26 vpw_27 vnwc_27 vddc_26
+  vddce_26 nbl[1]_26 nbl[0]_26 bl[3]_25 bl[2]_25 vpw_26 vddc_25 nbl[0]_25
+  bl[3]_24 nbl[3]_24 vddc_24 bl[3]_23 vddc_23 bl[3]_22 nbl[3]_22 vddc_22
+  bl[3]_21 nbl[3]_21 bl[3]_20 nbl[3]_20 bl[2]_20 bl[3]_19 nbl[3]_19 bl[2]_19
+  bl[3]_18 nbl[3]_18 bl[2]_18 vddc_18 bl[3]_17 nbl[3]_17 vddc_17 bl[3]_16
+  nbl[3]_16 bl[3]_15 nbl[3]_15 bl[3]_14 nbl[3]_14 bl[2]_14 bl[3]_13 nbl[3]_13
+  bl[2]_13 bl[3]_12 nbl[3]_12 nbl[2]_12 bl[2]_12 bl[3]_11 nbl[3]_11 nbl[2]_11
+  bl[2]_11 bl[3]_10 nbl[3]_10 bl[3]_9 nbl[3]_9 bl[2]_9 bl[3]_8 nbl[3]_8
+  bl[2]_8 bl[3]_7 nbl[3]_7 nbl[2]_7 bl[2]_7 bl[3]_6 nbl[3]_6 nbl[2]_6 bl[2]_6
+  nbl[3]_5 nbl[2]_5 bl[2]_5 bl[3]_4 nbl[3]_4 nbl[2]_4 bl[2]_4 bl[3]_3
+  nbl[3]_3 bl[2]_3 bl[3]_2 nbl[3]_2 bl[2]_2 bl[3]_1 nbl[3]_1 nbl[2]_1 bl[2]_1
+  bl[3]_0 nbl[3]_0 nbl[2]_0 bl[2]_0 wl[1] wl[0]
** rf64x128mem_r_midt_row: 1536 flat devices **
xmem_r_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0 ncored00_320 ncored01_322 ncored10_324
+  ncored11_326 ncored20_328 ncored21_330 ncored30_332 ncored31_334 vddc_0
+  vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_1 nbl[1]_1 nbl[2]_1 nbl[3]_1 ncored00_352 ncored01_354 ncored10_356
+  ncored11_358 ncored20_360 ncored21_362 ncored30_364 ncored31_366 vddc_1
+  vddce_1 vddpe_1 vnwc_2 vpw_2 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_624 cored01_626
+  cored10_628 cored11_630 cored20_632 cored21_634 cored30_636 cored31_638
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_640 ncored01_642
+  ncored10_644 ncored11_646 ncored20_648 ncored21_650 ncored30_652
+  ncored31_654 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_656 cored01_658
+  cored10_660 cored11_662 cored20_664 cored21_666 cored30_668 cored31_670
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_672 ncored01_674
+  ncored10_676 ncored11_678 ncored20_680 ncored21_682 ncored30_684
+  ncored31_686 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_12 bl[0]_12 bl[1]_12 bl[2]_12 bl[3]_12 cored00_688 cored01_690
+  cored10_692 cored11_694 cored20_696 cored21_698 cored30_700 cored31_702
+  nbl[0]_12 nbl[1]_12 nbl[2]_12 nbl[3]_12 ncored00_704 ncored01_706
+  ncored10_708 ncored11_710 ncored20_712 ncored21_714 ncored30_716
+  ncored31_718 vddc_12 vddce_12 vddpe_12 vnwc_13 vpw_13 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_13 bl[0]_13 bl[1]_13 bl[2]_13 bl[3]_13 cored00_752 cored01_754
+  cored10_756 cored11_758 cored20_760 cored21_762 cored30_764 cored31_766
+  nbl[0]_13 nbl[1]_13 nbl[2]_13 nbl[3]_13 ncored00_768 ncored01_770
+  ncored10_772 ncored11_774 ncored20_776 ncored21_778 ncored30_780
+  ncored31_782 vddc_13 vddce_13 vddpe_13 vnwc_14 vpw_14 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_14 bl[0]_14 bl[1]_14 bl[2]_14 bl[3]_14 cored00_816 cored01_818
+  cored10_820 cored11_822 cored20_824 cored21_826 cored30_828 cored31_830
+  nbl[0]_14 nbl[1]_14 nbl[2]_14 nbl[3]_14 ncored00_832 ncored01_834
+  ncored10_836 ncored11_838 ncored20_840 ncored21_842 ncored30_844
+  ncored31_846 vddc_14 vddce_14 vddpe_14 vnwc_15 vpw_15 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_15 bl[0]_15 bl[1]_15 bl[2]_15 bl[3]_15 cored00_848 cored01_850
+  cored10_852 cored11_854 cored20_856 cored21_858 cored30_860 cored31_862
+  nbl[0]_15 nbl[1]_15 nbl[2]_15 nbl[3]_15 ncored00_864 ncored01_866
+  ncored10_868 ncored11_870 ncored20_872 ncored21_874 ncored30_876
+  ncored31_878 vddc_15 vddce_15 vddpe_15 vnwc_16 vpw_16 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_16 bl[0]_16 bl[1]_16 bl[2]_16 bl[3]_16 cored00_880 cored01_882
+  cored10_884 cored11_886 cored20_888 cored21_890 cored30_892 cored31_894
+  nbl[0]_16 nbl[1]_16 nbl[2]_16 nbl[3]_16 ncored00_896 ncored01_898
+  ncored10_900 ncored11_902 ncored20_904 ncored21_906 ncored30_908
+  ncored31_910 vddc_16 vddce_16 vddpe_16 vnwc_17 vpw_17 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_17 bl[0]_17 bl[1]_17 bl[2]_17 bl[3]_17 cored00_912 cored01_914
+  cored10_916 cored11_918 cored20_920 cored21_922 cored30_924 cored31_926
+  nbl[0]_17 nbl[1]_17 nbl[2]_17 nbl[3]_17 ncored00_928 ncored01_930
+  ncored10_932 ncored11_934 ncored20_936 ncored21_938 ncored30_940
+  ncored31_942 vddc_17 vddce_17 vddpe_17 vnwc_18 vpw_18 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_18 bl[0]_18 bl[1]_18 bl[2]_18 bl[3]_18 cored00_944 cored01_946
+  cored10_948 cored11_950 cored20_952 cored21_954 cored30_956 cored31_958
+  nbl[0]_18 nbl[1]_18 nbl[2]_18 nbl[3]_18 ncored00_960 ncored01_962
+  ncored10_964 ncored11_966 ncored20_968 ncored21_970 ncored30_972
+  ncored31_974 vddc_18 vddce_18 vddpe_18 vnwc_19 vpw_19 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_19 bl[0]_19 bl[1]_19 bl[2]_19 bl[3]_19 cored00_976 cored01_978
+  cored10_980 cored11_982 cored20_984 cored21_986 cored30_988 cored31_990
+  nbl[0]_19 nbl[1]_19 nbl[2]_19 nbl[3]_19 ncored00_992 ncored01_994
+  ncored10_996 ncored11_998 ncored20_1000 ncored21_1002 ncored30_1004
+  ncored31_1006 vddc_19 vddce_19 vddpe_19 vnwc_20 vpw_20 vssc vssc wl[0]
+  wl[1] rf64x128cchs4
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_368 cored01_370
+  cored10_372 cored11_374 cored20_376 cored21_378 cored30_380 cored31_382
+  nbl[0]_2 nbl[1]_2 nbl[2]_2 nbl[3]_2 ncored00_384 ncored01_386 ncored10_388
+  ncored11_390 ncored20_392 ncored21_394 ncored30_396 ncored31_398 vddc_2
+  vddce_2 vddpe_2 vnwc_3 vpw_3 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_20 bl[0]_20 bl[1]_20 bl[2]_20 bl[3]_20 cored00 cored01 cored10
+  cored11 cored20 cored21 cored30 cored31 nbl[0]_20 nbl[1]_20 nbl[2]_20
+  nbl[3]_20 ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30
+  ncored31 vddc_20 vddce_20 vddpe_20 vnwc_21 vpw_21 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_21 bl[0]_21 bl[1]_21 bl[2]_21 bl[3]_21 cored00_16 cored01_18
+  cored10_20 cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_21
+  nbl[1]_21 nbl[2]_21 nbl[3]_21 ncored00_32 ncored01_34 ncored10_36
+  ncored11_38 ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_21
+  vddce_21 vddpe_21 vnwc_22 vpw_22 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_22 bl[0]_22 bl[1]_22 bl[2]_22 bl[3]_22 cored00_48 cored01_50
+  cored10_52 cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_22
+  nbl[1]_22 nbl[2]_22 nbl[3]_22 ncored00_64 ncored01_66 ncored10_68
+  ncored11_70 ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_22
+  vddce_22 vddpe_22 vnwc_23 vpw_23 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_23 bl[0]_23 bl[1]_23 bl[2]_23 bl[3]_23 cored00_80 cored01_82
+  cored10_84 cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_23
+  nbl[1]_23 nbl[2]_23 nbl[3]_23 ncored00_96 ncored01_98 ncored10_100
+  ncored11_102 ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_23
+  vddce_23 vddpe_23 vnwc_24 vpw_24 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_24 bl[0]_24 bl[1]_24 bl[2]_24 bl[3]_24 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_24 nbl[1]_24 nbl[2]_24 nbl[3]_24 ncored00_128 ncored01_130
+  ncored10_132 ncored11_134 ncored20_136 ncored21_138 ncored30_140
+  ncored31_142 vddc_24 vddce_24 vddpe_24 vnwc_25 vpw_25 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_25 bl[0]_25 bl[1]_25 bl[2]_25 bl[3]_25 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_25 nbl[1]_25 nbl[2]_25 nbl[3]_25 ncored00_160 ncored01_162
+  ncored10_164 ncored11_166 ncored20_168 ncored21_170 ncored30_172
+  ncored31_174 vddc_25 vddce_25 vddpe_25 vnwc_26 vpw_26 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_26 bl[0]_26 bl[1]_26 bl[2]_26 bl[3]_26 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_26 nbl[1]_26 nbl[2]_26 nbl[3]_26 ncored00_192 ncored01_194
+  ncored10_196 ncored11_198 ncored20_200 ncored21_202 ncored30_204
+  ncored31_206 vddc_26 vddce_26 vddpe_26 vnwc_27 vpw_27 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_27 bl[0]_27 bl[1]_27 bl[2]_27 bl[3]_27 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_27 nbl[1]_27 nbl[2]_27 nbl[3]_27 ncored00_224 ncored01_226
+  ncored10_228 ncored11_230 ncored20_232 ncored21_234 ncored30_236
+  ncored31_238 vddc_27 vddce_27 vddpe_27 vnwc_28 vpw_28 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_28 bl[0]_28 bl[1]_28 bl[2]_28 bl[3]_28 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_28 nbl[1]_28 nbl[2]_28 nbl[3]_28 ncored00_256 ncored01_258
+  ncored10_260 ncored11_262 ncored20_264 ncored21_266 ncored30_268
+  ncored31_270 vddc_28 vddce_28 vddpe_28 vnwc_29 vpw_29 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_29 bl[0]_29 bl[1]_29 bl[2]_29 bl[3]_29 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_29 nbl[1]_29 nbl[2]_29 nbl[3]_29 ncored00_288 ncored01_290
+  ncored10_292 ncored11_294 ncored20_296 ncored21_298 ncored30_300
+  ncored31_302 vddc_29 vddce_29 vddpe_29 vnwc_30 vpw_30 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_400 cored01_402
+  cored10_404 cored11_406 cored20_408 cored21_410 cored30_412 cored31_414
+  nbl[0]_3 nbl[1]_3 nbl[2]_3 nbl[3]_3 ncored00_416 ncored01_418 ncored10_420
+  ncored11_422 ncored20_424 ncored21_426 ncored30_428 ncored31_430 vddc_3
+  vddce_3 vddpe_3 vnwc_4 vpw_4 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_30 bl[0]_30 bl[1]_30 bl[2]_30 bl[3]_30 cored00_720 cored01_722
+  cored10_724 cored11_726 cored20_728 cored21_730 cored30_732 cored31_734
+  nbl[0]_30 nbl[1]_30 nbl[2]_30 nbl[3]_30 ncored00_736 ncored01_738
+  ncored10_740 ncored11_742 ncored20_744 ncored21_746 ncored30_748
+  ncored31_750 vddc_30 vddce_30 vddpe_30 vnwc_31 vpw_31 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_31 bl[0]_31 bl[1]_31 bl[2]_31 bl[3]_31 cored00_784 cored01_786
+  cored10_788 cored11_790 cored20_792 cored21_794 cored30_796 cored31_798
+  nbl[0]_31 nbl[1]_31 nbl[2]_31 nbl[3]_31 ncored00_800 ncored01_802
+  ncored10_804 ncored11_806 ncored20_808 ncored21_810 ncored30_812
+  ncored31_814 vddc_31 vddce_31 vddpe_31 vnwc_32 vpw_32 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_432 cored01_434
+  cored10_436 cored11_438 cored20_440 cored21_442 cored30_444 cored31_446
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_448 ncored01_450 ncored10_452
+  ncored11_454 ncored20_456 ncored21_458 ncored30_460 ncored31_462 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_464 cored01_466
+  cored10_468 cored11_470 cored20_472 cored21_474 cored30_476 cored31_478
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_480 ncored01_482 ncored10_484
+  ncored11_486 ncored20_488 ncored21_490 ncored30_492 ncored31_494 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_496 cored01_498
+  cored10_500 cored11_502 cored20_504 cored21_506 cored30_508 cored31_510
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_512 ncored01_514 ncored10_516
+  ncored11_518 ncored20_520 ncored21_522 ncored30_524 ncored31_526 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_528 cored01_530
+  cored10_532 cored11_534 cored20_536 cored21_538 cored30_540 cored31_542
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_544 ncored01_546 ncored10_548
+  ncored11_550 ncored20_552 ncored21_554 ncored30_556 ncored31_558 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_560 cored01_562
+  cored10_564 cored11_566 cored20_568 cored21_570 cored30_572 cored31_574
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_576 ncored01_578 ncored10_580
+  ncored11_582 ncored20_584 ncored21_586 ncored30_588 ncored31_590 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_592 cored01_594
+  cored10_596 cored11_598 cored20_600 cored21_602 cored30_604 cored31_606
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_608 ncored01_610 ncored10_612
+  ncored11_614 ncored20_616 ncored21_618 ncored30_620 ncored31_622 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] rf64x128cchs4
.ends rf64x128mem_r_midt_row
****
.subckt rf64x128mem_r_mid_row vpw_33 vnwc_33 bl[3]_31 nbl[3]_31 nbl[2]_31
+  bl[2]_31 vnwc_32 vddc_31 bl[3]_30 nbl[3]_30 nbl[2]_30 bl[2]_30 vddpe_30
+  bl[1]_30 nbl[3]_29 nbl[2]_29 bl[2]_29 vddpe_29 bl[1]_29 nbl[3]_28 nbl[2]_28
+  bl[2]_28 vddpe_28 bl[1]_28 nbl[2]_27 bl[2]_27 vddpe_27 bl[1]_27 nbl[2]_26
+  bl[2]_26 vddpe_26 bl[1]_26 bl[0]_26 nbl[3]_25 nbl[2]_25 vnwc_26 vddce_25
+  vddpe_25 bl[1]_25 nbl[1]_25 bl[0]_25 nbl[2]_24 bl[2]_24 vssc vpw_25 vnwc_25
+  vddce_24 vddpe_24 bl[1]_24 nbl[1]_24 nbl[0]_24 bl[0]_24 nbl[3]_23 nbl[2]_23
+  bl[2]_23 vpw_24 vnwc_24 vddce_23 vddpe_23 bl[1]_23 nbl[1]_23 nbl[0]_23
+  bl[0]_23 nbl[2]_22 bl[2]_22 vpw_23 vnwc_23 vddce_22 vddpe_22 bl[1]_22
+  nbl[1]_22 nbl[0]_22 bl[0]_22 nbl[2]_21 bl[2]_21 vpw_22 vnwc_22 vddc_21
+  vddce_21 vddpe_21 bl[1]_21 nbl[1]_21 nbl[0]_21 bl[0]_21 nbl[2]_20 vpw_21
+  vnwc_21 vddc_20 vddce_20 vddpe_20 bl[1]_20 nbl[1]_20 nbl[0]_20 bl[0]_20
+  nbl[2]_19 vpw_20 vnwc_20 vddc_19 vddce_19 vddpe_19 bl[1]_19 nbl[1]_19
+  nbl[0]_19 bl[0]_19 nbl[2]_18 vpw_19 vnwc_19 vddce_18 vddpe_18 bl[1]_18
+  nbl[1]_18 nbl[0]_18 bl[0]_18 nbl[2]_17 bl[2]_17 vpw_18 vnwc_18 vddce_17
+  vddpe_17 bl[1]_17 nbl[1]_17 nbl[0]_17 bl[0]_17 nbl[2]_16 bl[2]_16 vpw_17
+  vnwc_17 vddc_16 vddce_16 vddpe_16 bl[1]_16 nbl[1]_16 nbl[0]_16 bl[0]_16
+  nbl[2]_15 bl[2]_15 vpw_16 vnwc_16 vddc_15 vddce_15 vddpe_15 bl[1]_15
+  nbl[1]_15 nbl[0]_15 bl[0]_15 nbl[2]_14 vpw_15 vnwc_15 vddc_14 vddce_14
+  vddpe_14 bl[1]_14 nbl[1]_14 nbl[0]_14 bl[0]_14 nbl[2]_13 vpw_14 vnwc_14
+  vddc_13 vddce_13 vddpe_13 bl[1]_13 nbl[1]_13 nbl[0]_13 bl[0]_13 vpw_13
+  vnwc_13 vddc_12 vddce_12 vddpe_12 bl[1]_12 nbl[1]_12 nbl[0]_12 bl[0]_12
+  vpw_12 vnwc_12 vddc_11 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11
+  bl[0]_11 nbl[2]_10 bl[2]_10 vpw_11 vnwc_11 vddc_10 vddce_10 vddpe_10
+  bl[1]_10 nbl[1]_10 nbl[0]_10 bl[0]_10 nbl[2]_9 vpw_10 vnwc_10 vddc_9
+  vddce_9 vddpe_9 bl[1]_9 nbl[1]_9 nbl[0]_9 bl[0]_9 nbl[2]_8 vpw_9 vnwc_9
+  vddc_8 vddce_8 vddpe_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 vpw_8 vnwc_8
+  vddc_7 vddce_7 vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 vpw_7 vnwc_7
+  vddc_6 vddce_6 vddpe_6 bl[1]_6 nbl[1]_6 nbl[0]_6 bl[0]_6 bl[3]_5 vpw_6
+  vnwc_6 vddc_5 vddce_5 vddpe_5 bl[1]_5 nbl[1]_5 nbl[0]_5 bl[0]_5 vpw_5
+  vnwc_5 vddc_4 vddce_4 vddpe_4 bl[1]_4 nbl[1]_4 nbl[0]_4 bl[0]_4 nbl[2]_3
+  vpw_4 vnwc_4 vddc_3 vddce_3 vddpe_3 bl[1]_3 nbl[1]_3 nbl[0]_3 bl[0]_3
+  nbl[2]_2 vpw_3 vnwc_3 vddc_2 vddce_2 vddpe_2 bl[1]_2 nbl[1]_2 nbl[0]_2
+  bl[0]_2 vpw_2 vnwc_2 vddc_1 vddce_1 vddpe_1 bl[1]_1 nbl[1]_1 nbl[0]_1
+  bl[0]_1 vpw_1 vnwc_1 vddc_0 vddce_0 vddpe_0 bl[1]_0 nbl[1]_0 nbl[0]_0
+  bl[0]_0 vnwp_0 vnwc_0 vpw_0 vnwp_1 vpw_32 vddce_31 vddpe_31 bl[1]_31
+  nbl[1]_31 nbl[0]_31 bl[0]_31 vpw_31 vnwc_31 vddc_30 vddce_30 nbl[1]_30
+  nbl[0]_30 bl[0]_30 bl[3]_29 vpw_30 vnwc_30 vddc_29 vddce_29 nbl[1]_29
+  nbl[0]_29 bl[0]_29 bl[3]_28 vpw_29 vnwc_29 vddc_28 vddce_28 nbl[1]_28
+  nbl[0]_28 bl[0]_28 bl[3]_27 nbl[3]_27 vpw_28 vnwc_28 vddc_27 vddce_27
+  nbl[1]_27 nbl[0]_27 bl[0]_27 bl[3]_26 nbl[3]_26 vpw_27 vnwc_27 vddc_26
+  vddce_26 nbl[1]_26 nbl[0]_26 bl[3]_25 bl[2]_25 vpw_26 vddc_25 nbl[0]_25
+  bl[3]_24 nbl[3]_24 vddc_24 bl[3]_23 vddc_23 bl[3]_22 nbl[3]_22 vddc_22
+  bl[3]_21 nbl[3]_21 bl[3]_20 nbl[3]_20 bl[2]_20 bl[3]_19 nbl[3]_19 bl[2]_19
+  bl[3]_18 nbl[3]_18 bl[2]_18 vddc_18 bl[3]_17 nbl[3]_17 vddc_17 bl[3]_16
+  nbl[3]_16 bl[3]_15 nbl[3]_15 bl[3]_14 nbl[3]_14 bl[2]_14 bl[3]_13 nbl[3]_13
+  bl[2]_13 bl[3]_12 nbl[3]_12 nbl[2]_12 bl[2]_12 bl[3]_11 nbl[3]_11 nbl[2]_11
+  bl[2]_11 bl[3]_10 nbl[3]_10 bl[3]_9 nbl[3]_9 bl[2]_9 bl[3]_8 nbl[3]_8
+  bl[2]_8 bl[3]_7 nbl[3]_7 nbl[2]_7 bl[2]_7 bl[3]_6 nbl[3]_6 nbl[2]_6 bl[2]_6
+  nbl[3]_5 nbl[2]_5 bl[2]_5 bl[3]_4 nbl[3]_4 nbl[2]_4 bl[2]_4 bl[3]_3
+  nbl[3]_3 bl[2]_3 bl[3]_2 nbl[3]_2 bl[2]_2 bl[3]_1 nbl[3]_1 nbl[2]_1 bl[2]_1
+  bl[3]_0 nbl[3]_0 nbl[2]_0 bl[2]_0 wl[1] wl[0]
** rf64x128mem_r_mid_row: 1536 flat devices **
xmem_r_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0 ncored00_320 ncored01_322 ncored10_324
+  ncored11_326 ncored20_328 ncored21_330 ncored30_332 ncored31_334 vddc_0
+  vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_1 nbl[1]_1 nbl[2]_1 nbl[3]_1 ncored00_352 ncored01_354 ncored10_356
+  ncored11_358 ncored20_360 ncored21_362 ncored30_364 ncored31_366 vddc_1
+  vddce_1 vddpe_1 vnwc_2 vpw_2 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_624 cored01_626
+  cored10_628 cored11_630 cored20_632 cored21_634 cored30_636 cored31_638
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_640 ncored01_642
+  ncored10_644 ncored11_646 ncored20_648 ncored21_650 ncored30_652
+  ncored31_654 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_656 cored01_658
+  cored10_660 cored11_662 cored20_664 cored21_666 cored30_668 cored31_670
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_672 ncored01_674
+  ncored10_676 ncored11_678 ncored20_680 ncored21_682 ncored30_684
+  ncored31_686 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_12 bl[0]_12 bl[1]_12 bl[2]_12 bl[3]_12 cored00_688 cored01_690
+  cored10_692 cored11_694 cored20_696 cored21_698 cored30_700 cored31_702
+  nbl[0]_12 nbl[1]_12 nbl[2]_12 nbl[3]_12 ncored00_704 ncored01_706
+  ncored10_708 ncored11_710 ncored20_712 ncored21_714 ncored30_716
+  ncored31_718 vddc_12 vddce_12 vddpe_12 vnwc_13 vpw_13 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_13 bl[0]_13 bl[1]_13 bl[2]_13 bl[3]_13 cored00_752 cored01_754
+  cored10_756 cored11_758 cored20_760 cored21_762 cored30_764 cored31_766
+  nbl[0]_13 nbl[1]_13 nbl[2]_13 nbl[3]_13 ncored00_768 ncored01_770
+  ncored10_772 ncored11_774 ncored20_776 ncored21_778 ncored30_780
+  ncored31_782 vddc_13 vddce_13 vddpe_13 vnwc_14 vpw_14 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_14 bl[0]_14 bl[1]_14 bl[2]_14 bl[3]_14 cored00_816 cored01_818
+  cored10_820 cored11_822 cored20_824 cored21_826 cored30_828 cored31_830
+  nbl[0]_14 nbl[1]_14 nbl[2]_14 nbl[3]_14 ncored00_832 ncored01_834
+  ncored10_836 ncored11_838 ncored20_840 ncored21_842 ncored30_844
+  ncored31_846 vddc_14 vddce_14 vddpe_14 vnwc_15 vpw_15 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_15 bl[0]_15 bl[1]_15 bl[2]_15 bl[3]_15 cored00_848 cored01_850
+  cored10_852 cored11_854 cored20_856 cored21_858 cored30_860 cored31_862
+  nbl[0]_15 nbl[1]_15 nbl[2]_15 nbl[3]_15 ncored00_864 ncored01_866
+  ncored10_868 ncored11_870 ncored20_872 ncored21_874 ncored30_876
+  ncored31_878 vddc_15 vddce_15 vddpe_15 vnwc_16 vpw_16 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_16 bl[0]_16 bl[1]_16 bl[2]_16 bl[3]_16 cored00_880 cored01_882
+  cored10_884 cored11_886 cored20_888 cored21_890 cored30_892 cored31_894
+  nbl[0]_16 nbl[1]_16 nbl[2]_16 nbl[3]_16 ncored00_896 ncored01_898
+  ncored10_900 ncored11_902 ncored20_904 ncored21_906 ncored30_908
+  ncored31_910 vddc_16 vddce_16 vddpe_16 vnwc_17 vpw_17 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_17 bl[0]_17 bl[1]_17 bl[2]_17 bl[3]_17 cored00_912 cored01_914
+  cored10_916 cored11_918 cored20_920 cored21_922 cored30_924 cored31_926
+  nbl[0]_17 nbl[1]_17 nbl[2]_17 nbl[3]_17 ncored00_928 ncored01_930
+  ncored10_932 ncored11_934 ncored20_936 ncored21_938 ncored30_940
+  ncored31_942 vddc_17 vddce_17 vddpe_17 vnwc_18 vpw_18 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_18 bl[0]_18 bl[1]_18 bl[2]_18 bl[3]_18 cored00_944 cored01_946
+  cored10_948 cored11_950 cored20_952 cored21_954 cored30_956 cored31_958
+  nbl[0]_18 nbl[1]_18 nbl[2]_18 nbl[3]_18 ncored00_960 ncored01_962
+  ncored10_964 ncored11_966 ncored20_968 ncored21_970 ncored30_972
+  ncored31_974 vddc_18 vddce_18 vddpe_18 vnwc_19 vpw_19 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_19 bl[0]_19 bl[1]_19 bl[2]_19 bl[3]_19 cored00_976 cored01_978
+  cored10_980 cored11_982 cored20_984 cored21_986 cored30_988 cored31_990
+  nbl[0]_19 nbl[1]_19 nbl[2]_19 nbl[3]_19 ncored00_992 ncored01_994
+  ncored10_996 ncored11_998 ncored20_1000 ncored21_1002 ncored30_1004
+  ncored31_1006 vddc_19 vddce_19 vddpe_19 vnwc_20 vpw_20 vssc vssc wl[0]
+  wl[1] rf64x128cchs4
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_368 cored01_370
+  cored10_372 cored11_374 cored20_376 cored21_378 cored30_380 cored31_382
+  nbl[0]_2 nbl[1]_2 nbl[2]_2 nbl[3]_2 ncored00_384 ncored01_386 ncored10_388
+  ncored11_390 ncored20_392 ncored21_394 ncored30_396 ncored31_398 vddc_2
+  vddce_2 vddpe_2 vnwc_3 vpw_3 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_20 bl[0]_20 bl[1]_20 bl[2]_20 bl[3]_20 cored00 cored01 cored10
+  cored11 cored20 cored21 cored30 cored31 nbl[0]_20 nbl[1]_20 nbl[2]_20
+  nbl[3]_20 ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30
+  ncored31 vddc_20 vddce_20 vddpe_20 vnwc_21 vpw_21 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_21 bl[0]_21 bl[1]_21 bl[2]_21 bl[3]_21 cored00_16 cored01_18
+  cored10_20 cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_21
+  nbl[1]_21 nbl[2]_21 nbl[3]_21 ncored00_32 ncored01_34 ncored10_36
+  ncored11_38 ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_21
+  vddce_21 vddpe_21 vnwc_22 vpw_22 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_22 bl[0]_22 bl[1]_22 bl[2]_22 bl[3]_22 cored00_48 cored01_50
+  cored10_52 cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_22
+  nbl[1]_22 nbl[2]_22 nbl[3]_22 ncored00_64 ncored01_66 ncored10_68
+  ncored11_70 ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_22
+  vddce_22 vddpe_22 vnwc_23 vpw_23 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_23 bl[0]_23 bl[1]_23 bl[2]_23 bl[3]_23 cored00_80 cored01_82
+  cored10_84 cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_23
+  nbl[1]_23 nbl[2]_23 nbl[3]_23 ncored00_96 ncored01_98 ncored10_100
+  ncored11_102 ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_23
+  vddce_23 vddpe_23 vnwc_24 vpw_24 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_24 bl[0]_24 bl[1]_24 bl[2]_24 bl[3]_24 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_24 nbl[1]_24 nbl[2]_24 nbl[3]_24 ncored00_128 ncored01_130
+  ncored10_132 ncored11_134 ncored20_136 ncored21_138 ncored30_140
+  ncored31_142 vddc_24 vddce_24 vddpe_24 vnwc_25 vpw_25 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_25 bl[0]_25 bl[1]_25 bl[2]_25 bl[3]_25 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_25 nbl[1]_25 nbl[2]_25 nbl[3]_25 ncored00_160 ncored01_162
+  ncored10_164 ncored11_166 ncored20_168 ncored21_170 ncored30_172
+  ncored31_174 vddc_25 vddce_25 vddpe_25 vnwc_26 vpw_26 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_26 bl[0]_26 bl[1]_26 bl[2]_26 bl[3]_26 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_26 nbl[1]_26 nbl[2]_26 nbl[3]_26 ncored00_192 ncored01_194
+  ncored10_196 ncored11_198 ncored20_200 ncored21_202 ncored30_204
+  ncored31_206 vddc_26 vddce_26 vddpe_26 vnwc_27 vpw_27 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_27 bl[0]_27 bl[1]_27 bl[2]_27 bl[3]_27 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_27 nbl[1]_27 nbl[2]_27 nbl[3]_27 ncored00_224 ncored01_226
+  ncored10_228 ncored11_230 ncored20_232 ncored21_234 ncored30_236
+  ncored31_238 vddc_27 vddce_27 vddpe_27 vnwc_28 vpw_28 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_28 bl[0]_28 bl[1]_28 bl[2]_28 bl[3]_28 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_28 nbl[1]_28 nbl[2]_28 nbl[3]_28 ncored00_256 ncored01_258
+  ncored10_260 ncored11_262 ncored20_264 ncored21_266 ncored30_268
+  ncored31_270 vddc_28 vddce_28 vddpe_28 vnwc_29 vpw_29 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_29 bl[0]_29 bl[1]_29 bl[2]_29 bl[3]_29 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_29 nbl[1]_29 nbl[2]_29 nbl[3]_29 ncored00_288 ncored01_290
+  ncored10_292 ncored11_294 ncored20_296 ncored21_298 ncored30_300
+  ncored31_302 vddc_29 vddce_29 vddpe_29 vnwc_30 vpw_30 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_400 cored01_402
+  cored10_404 cored11_406 cored20_408 cored21_410 cored30_412 cored31_414
+  nbl[0]_3 nbl[1]_3 nbl[2]_3 nbl[3]_3 ncored00_416 ncored01_418 ncored10_420
+  ncored11_422 ncored20_424 ncored21_426 ncored30_428 ncored31_430 vddc_3
+  vddce_3 vddpe_3 vnwc_4 vpw_4 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_30 bl[0]_30 bl[1]_30 bl[2]_30 bl[3]_30 cored00_720 cored01_722
+  cored10_724 cored11_726 cored20_728 cored21_730 cored30_732 cored31_734
+  nbl[0]_30 nbl[1]_30 nbl[2]_30 nbl[3]_30 ncored00_736 ncored01_738
+  ncored10_740 ncored11_742 ncored20_744 ncored21_746 ncored30_748
+  ncored31_750 vddc_30 vddce_30 vddpe_30 vnwc_31 vpw_31 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_31 bl[0]_31 bl[1]_31 bl[2]_31 bl[3]_31 cored00_784 cored01_786
+  cored10_788 cored11_790 cored20_792 cored21_794 cored30_796 cored31_798
+  nbl[0]_31 nbl[1]_31 nbl[2]_31 nbl[3]_31 ncored00_800 ncored01_802
+  ncored10_804 ncored11_806 ncored20_808 ncored21_810 ncored30_812
+  ncored31_814 vddc_31 vddce_31 vddpe_31 vnwc_32 vpw_32 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_432 cored01_434
+  cored10_436 cored11_438 cored20_440 cored21_442 cored30_444 cored31_446
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_448 ncored01_450 ncored10_452
+  ncored11_454 ncored20_456 ncored21_458 ncored30_460 ncored31_462 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_464 cored01_466
+  cored10_468 cored11_470 cored20_472 cored21_474 cored30_476 cored31_478
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_480 ncored01_482 ncored10_484
+  ncored11_486 ncored20_488 ncored21_490 ncored30_492 ncored31_494 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_496 cored01_498
+  cored10_500 cored11_502 cored20_504 cored21_506 cored30_508 cored31_510
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_512 ncored01_514 ncored10_516
+  ncored11_518 ncored20_520 ncored21_522 ncored30_524 ncored31_526 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_528 cored01_530
+  cored10_532 cored11_534 cored20_536 cored21_538 cored30_540 cored31_542
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_544 ncored01_546 ncored10_548
+  ncored11_550 ncored20_552 ncored21_554 ncored30_556 ncored31_558 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_560 cored01_562
+  cored10_564 cored11_566 cored20_568 cored21_570 cored30_572 cored31_574
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_576 ncored01_578 ncored10_580
+  ncored11_582 ncored20_584 ncored21_586 ncored30_588 ncored31_590 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_592 cored01_594
+  cored10_596 cored11_598 cored20_600 cored21_602 cored30_604 cored31_606
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_608 ncored01_610 ncored10_612
+  ncored11_614 ncored20_616 ncored21_618 ncored30_620 ncored31_622 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] rf64x128cchs4
.ends rf64x128mem_r_mid_row
****
.subckt rf64x128mem_r_bot_row vpw_33 vnwc_33 bl[3]_31 nbl[3]_31 nbl[2]_31
+  bl[2]_31 vnwc_32 vddc_31 bl[3]_30 nbl[3]_30 nbl[2]_30 bl[2]_30 vddpe_30
+  bl[1]_30 nbl[3]_29 nbl[2]_29 bl[2]_29 vddpe_29 bl[1]_29 nbl[3]_28 nbl[2]_28
+  bl[2]_28 vddpe_28 bl[1]_28 nbl[2]_27 bl[2]_27 vddpe_27 bl[1]_27 nbl[2]_26
+  bl[2]_26 vddpe_26 bl[1]_26 bl[0]_26 nbl[3]_25 nbl[2]_25 vnwc_26 vddce_25
+  vddpe_25 bl[1]_25 nbl[1]_25 bl[0]_25 nbl[2]_24 bl[2]_24 vssc vpw_25 vnwc_25
+  vddce_24 vddpe_24 bl[1]_24 nbl[1]_24 nbl[0]_24 bl[0]_24 nbl[3]_23 nbl[2]_23
+  bl[2]_23 vpw_24 vnwc_24 vddce_23 vddpe_23 bl[1]_23 nbl[1]_23 nbl[0]_23
+  bl[0]_23 nbl[2]_22 bl[2]_22 vpw_23 vnwc_23 vddce_22 vddpe_22 bl[1]_22
+  nbl[1]_22 nbl[0]_22 bl[0]_22 nbl[2]_21 bl[2]_21 vpw_22 vnwc_22 vddc_21
+  vddce_21 vddpe_21 bl[1]_21 nbl[1]_21 nbl[0]_21 bl[0]_21 nbl[2]_20 vpw_21
+  vnwc_21 vddc_20 vddce_20 vddpe_20 bl[1]_20 nbl[1]_20 nbl[0]_20 bl[0]_20
+  nbl[2]_19 vpw_20 vnwc_20 vddc_19 vddce_19 vddpe_19 bl[1]_19 nbl[1]_19
+  nbl[0]_19 bl[0]_19 nbl[2]_18 vpw_19 vnwc_19 vddce_18 vddpe_18 bl[1]_18
+  nbl[1]_18 nbl[0]_18 bl[0]_18 nbl[2]_17 bl[2]_17 vpw_18 vnwc_18 vddce_17
+  vddpe_17 bl[1]_17 nbl[1]_17 nbl[0]_17 bl[0]_17 nbl[2]_16 bl[2]_16 vpw_17
+  vnwc_17 vddc_16 vddce_16 vddpe_16 bl[1]_16 nbl[1]_16 nbl[0]_16 bl[0]_16
+  nbl[2]_15 bl[2]_15 vpw_16 vnwc_16 vddc_15 vddce_15 vddpe_15 bl[1]_15
+  nbl[1]_15 nbl[0]_15 bl[0]_15 nbl[2]_14 vpw_15 vnwc_15 vddc_14 vddce_14
+  vddpe_14 bl[1]_14 nbl[1]_14 nbl[0]_14 bl[0]_14 nbl[2]_13 vpw_14 vnwc_14
+  vddc_13 vddce_13 vddpe_13 bl[1]_13 nbl[1]_13 nbl[0]_13 bl[0]_13 vpw_13
+  vnwc_13 vddc_12 vddce_12 vddpe_12 bl[1]_12 nbl[1]_12 nbl[0]_12 bl[0]_12
+  vpw_12 vnwc_12 vddc_11 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11
+  bl[0]_11 nbl[2]_10 bl[2]_10 vpw_11 vnwc_11 vddc_10 vddce_10 vddpe_10
+  bl[1]_10 nbl[1]_10 nbl[0]_10 bl[0]_10 nbl[2]_9 vpw_10 vnwc_10 vddc_9
+  vddce_9 vddpe_9 bl[1]_9 nbl[1]_9 nbl[0]_9 bl[0]_9 nbl[2]_8 vpw_9 vnwc_9
+  vddc_8 vddce_8 vddpe_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 vpw_8 vnwc_8
+  vddc_7 vddce_7 vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 vpw_7 vnwc_7
+  vddc_6 vddce_6 vddpe_6 bl[1]_6 nbl[1]_6 nbl[0]_6 bl[0]_6 bl[3]_5 vpw_6
+  vnwc_6 vddc_5 vddce_5 vddpe_5 bl[1]_5 nbl[1]_5 nbl[0]_5 bl[0]_5 vpw_5
+  vnwc_5 vddc_4 vddce_4 vddpe_4 bl[1]_4 nbl[1]_4 nbl[0]_4 bl[0]_4 nbl[2]_3
+  vpw_4 vnwc_4 vddc_3 vddce_3 vddpe_3 bl[1]_3 nbl[1]_3 nbl[0]_3 bl[0]_3
+  nbl[2]_2 vpw_3 vnwc_3 vddc_2 vddce_2 vddpe_2 bl[1]_2 nbl[1]_2 nbl[0]_2
+  bl[0]_2 vpw_2 vnwc_2 vddc_1 vddce_1 vddpe_1 bl[1]_1 nbl[1]_1 nbl[0]_1
+  bl[0]_1 vpw_1 vsse_0 vnwc_1 vddc_0 vddce_0 vddpe_0 bl[1]_0 nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc_0 vpw_0 vnwp_1 vpw_32 vsse_1 vddce_31 vddpe_31
+  bl[1]_31 nbl[1]_31 nbl[0]_31 bl[0]_31 vpw_31 vnwc_31 vddc_30 vddce_30
+  nbl[1]_30 nbl[0]_30 bl[0]_30 bl[3]_29 vpw_30 vnwc_30 vddc_29 vddce_29
+  nbl[1]_29 nbl[0]_29 bl[0]_29 bl[3]_28 vpw_29 vnwc_29 vddc_28 vddce_28
+  nbl[1]_28 nbl[0]_28 bl[0]_28 bl[3]_27 nbl[3]_27 vpw_28 vnwc_28 vddc_27
+  vddce_27 nbl[1]_27 nbl[0]_27 bl[0]_27 bl[3]_26 nbl[3]_26 vpw_27 vnwc_27
+  vddc_26 vddce_26 nbl[1]_26 nbl[0]_26 bl[3]_25 bl[2]_25 vpw_26 vddc_25
+  nbl[0]_25 bl[3]_24 nbl[3]_24 vddc_24 bl[3]_23 vddc_23 bl[3]_22 nbl[3]_22
+  vddc_22 bl[3]_21 nbl[3]_21 bl[3]_20 nbl[3]_20 bl[2]_20 bl[3]_19 nbl[3]_19
+  bl[2]_19 bl[3]_18 nbl[3]_18 bl[2]_18 vddc_18 bl[3]_17 nbl[3]_17 vddc_17
+  bl[3]_16 nbl[3]_16 bl[3]_15 nbl[3]_15 bl[3]_14 nbl[3]_14 bl[2]_14 bl[3]_13
+  nbl[3]_13 bl[2]_13 bl[3]_12 nbl[3]_12 nbl[2]_12 bl[2]_12 bl[3]_11 nbl[3]_11
+  nbl[2]_11 bl[2]_11 bl[3]_10 nbl[3]_10 bl[3]_9 nbl[3]_9 bl[2]_9 bl[3]_8
+  nbl[3]_8 bl[2]_8 bl[3]_7 nbl[3]_7 nbl[2]_7 bl[2]_7 bl[3]_6 nbl[3]_6
+  nbl[2]_6 bl[2]_6 nbl[3]_5 nbl[2]_5 bl[2]_5 bl[3]_4 nbl[3]_4 nbl[2]_4
+  bl[2]_4 bl[3]_3 nbl[3]_3 bl[2]_3 bl[3]_2 nbl[3]_2 bl[2]_2 bl[3]_1 nbl[3]_1
+  nbl[2]_1 bl[2]_1 bl[3]_0 nbl[3]_0 nbl[2]_0 bl[2]_0 wl[1] wl[0]
** rf64x128mem_r_bot_row: 1536 flat devices **
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_1 nbl[1]_1 nbl[2]_1 nbl[3]_1 ncored00_352 ncored01_354 ncored10_356
+  ncored11_358 ncored20_360 ncored21_362 ncored30_364 ncored31_366 vddc_1
+  vddce_1 vddpe_1 vnwc_2 vpw_2 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_624 cored01_626
+  cored10_628 cored11_630 cored20_632 cored21_634 cored30_636 cored31_638
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_640 ncored01_642
+  ncored10_644 ncored11_646 ncored20_648 ncored21_650 ncored30_652
+  ncored31_654 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_656 cored01_658
+  cored10_660 cored11_662 cored20_664 cored21_666 cored30_668 cored31_670
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_672 ncored01_674
+  ncored10_676 ncored11_678 ncored20_680 ncored21_682 ncored30_684
+  ncored31_686 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_12 bl[0]_12 bl[1]_12 bl[2]_12 bl[3]_12 cored00_688 cored01_690
+  cored10_692 cored11_694 cored20_696 cored21_698 cored30_700 cored31_702
+  nbl[0]_12 nbl[1]_12 nbl[2]_12 nbl[3]_12 ncored00_704 ncored01_706
+  ncored10_708 ncored11_710 ncored20_712 ncored21_714 ncored30_716
+  ncored31_718 vddc_12 vddce_12 vddpe_12 vnwc_13 vpw_13 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_13 bl[0]_13 bl[1]_13 bl[2]_13 bl[3]_13 cored00_752 cored01_754
+  cored10_756 cored11_758 cored20_760 cored21_762 cored30_764 cored31_766
+  nbl[0]_13 nbl[1]_13 nbl[2]_13 nbl[3]_13 ncored00_768 ncored01_770
+  ncored10_772 ncored11_774 ncored20_776 ncored21_778 ncored30_780
+  ncored31_782 vddc_13 vddce_13 vddpe_13 vnwc_14 vpw_14 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_14 bl[0]_14 bl[1]_14 bl[2]_14 bl[3]_14 cored00_784 cored01_786
+  cored10_788 cored11_790 cored20_792 cored21_794 cored30_796 cored31_798
+  nbl[0]_14 nbl[1]_14 nbl[2]_14 nbl[3]_14 ncored00_800 ncored01_802
+  ncored10_804 ncored11_806 ncored20_808 ncored21_810 ncored30_812
+  ncored31_814 vddc_14 vddce_14 vddpe_14 vnwc_15 vpw_15 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_15 bl[0]_15 bl[1]_15 bl[2]_15 bl[3]_15 cored00_816 cored01_818
+  cored10_820 cored11_822 cored20_824 cored21_826 cored30_828 cored31_830
+  nbl[0]_15 nbl[1]_15 nbl[2]_15 nbl[3]_15 ncored00_832 ncored01_834
+  ncored10_836 ncored11_838 ncored20_840 ncored21_842 ncored30_844
+  ncored31_846 vddc_15 vddce_15 vddpe_15 vnwc_16 vpw_16 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_16 bl[0]_16 bl[1]_16 bl[2]_16 bl[3]_16 cored00_848 cored01_850
+  cored10_852 cored11_854 cored20_856 cored21_858 cored30_860 cored31_862
+  nbl[0]_16 nbl[1]_16 nbl[2]_16 nbl[3]_16 ncored00_864 ncored01_866
+  ncored10_868 ncored11_870 ncored20_872 ncored21_874 ncored30_876
+  ncored31_878 vddc_16 vddce_16 vddpe_16 vnwc_17 vpw_17 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_17 bl[0]_17 bl[1]_17 bl[2]_17 bl[3]_17 cored00_880 cored01_882
+  cored10_884 cored11_886 cored20_888 cored21_890 cored30_892 cored31_894
+  nbl[0]_17 nbl[1]_17 nbl[2]_17 nbl[3]_17 ncored00_896 ncored01_898
+  ncored10_900 ncored11_902 ncored20_904 ncored21_906 ncored30_908
+  ncored31_910 vddc_17 vddce_17 vddpe_17 vnwc_18 vpw_18 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_18 bl[0]_18 bl[1]_18 bl[2]_18 bl[3]_18 cored00_912 cored01_914
+  cored10_916 cored11_918 cored20_920 cored21_922 cored30_924 cored31_926
+  nbl[0]_18 nbl[1]_18 nbl[2]_18 nbl[3]_18 ncored00_928 ncored01_930
+  ncored10_932 ncored11_934 ncored20_936 ncored21_938 ncored30_940
+  ncored31_942 vddc_18 vddce_18 vddpe_18 vnwc_19 vpw_19 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_19 bl[0]_19 bl[1]_19 bl[2]_19 bl[3]_19 cored00_944 cored01_946
+  cored10_948 cored11_950 cored20_952 cored21_954 cored30_956 cored31_958
+  nbl[0]_19 nbl[1]_19 nbl[2]_19 nbl[3]_19 ncored00_960 ncored01_962
+  ncored10_964 ncored11_966 ncored20_968 ncored21_970 ncored30_972
+  ncored31_974 vddc_19 vddce_19 vddpe_19 vnwc_20 vpw_20 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_368 cored01_370
+  cored10_372 cored11_374 cored20_376 cored21_378 cored30_380 cored31_382
+  nbl[0]_2 nbl[1]_2 nbl[2]_2 nbl[3]_2 ncored00_384 ncored01_386 ncored10_388
+  ncored11_390 ncored20_392 ncored21_394 ncored30_396 ncored31_398 vddc_2
+  vddce_2 vddpe_2 vnwc_3 vpw_3 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_20 bl[0]_20 bl[1]_20 bl[2]_20 bl[3]_20 cored00_16 cored01_18
+  cored10_20 cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_20
+  nbl[1]_20 nbl[2]_20 nbl[3]_20 ncored00_32 ncored01_34 ncored10_36
+  ncored11_38 ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_20
+  vddce_20 vddpe_20 vnwc_21 vpw_21 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_21 bl[0]_21 bl[1]_21 bl[2]_21 bl[3]_21 cored00_48 cored01_50
+  cored10_52 cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_21
+  nbl[1]_21 nbl[2]_21 nbl[3]_21 ncored00_64 ncored01_66 ncored10_68
+  ncored11_70 ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_21
+  vddce_21 vddpe_21 vnwc_22 vpw_22 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_22 bl[0]_22 bl[1]_22 bl[2]_22 bl[3]_22 cored00_80 cored01_82
+  cored10_84 cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_22
+  nbl[1]_22 nbl[2]_22 nbl[3]_22 ncored00_96 ncored01_98 ncored10_100
+  ncored11_102 ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_22
+  vddce_22 vddpe_22 vnwc_23 vpw_23 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_23 bl[0]_23 bl[1]_23 bl[2]_23 bl[3]_23 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_23 nbl[1]_23 nbl[2]_23 nbl[3]_23 ncored00_128 ncored01_130
+  ncored10_132 ncored11_134 ncored20_136 ncored21_138 ncored30_140
+  ncored31_142 vddc_23 vddce_23 vddpe_23 vnwc_24 vpw_24 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_24 bl[0]_24 bl[1]_24 bl[2]_24 bl[3]_24 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_24 nbl[1]_24 nbl[2]_24 nbl[3]_24 ncored00_160 ncored01_162
+  ncored10_164 ncored11_166 ncored20_168 ncored21_170 ncored30_172
+  ncored31_174 vddc_24 vddce_24 vddpe_24 vnwc_25 vpw_25 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_25 bl[0]_25 bl[1]_25 bl[2]_25 bl[3]_25 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_25 nbl[1]_25 nbl[2]_25 nbl[3]_25 ncored00_192 ncored01_194
+  ncored10_196 ncored11_198 ncored20_200 ncored21_202 ncored30_204
+  ncored31_206 vddc_25 vddce_25 vddpe_25 vnwc_26 vpw_26 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_26 bl[0]_26 bl[1]_26 bl[2]_26 bl[3]_26 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_26 nbl[1]_26 nbl[2]_26 nbl[3]_26 ncored00_224 ncored01_226
+  ncored10_228 ncored11_230 ncored20_232 ncored21_234 ncored30_236
+  ncored31_238 vddc_26 vddce_26 vddpe_26 vnwc_27 vpw_27 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_27 bl[0]_27 bl[1]_27 bl[2]_27 bl[3]_27 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_27 nbl[1]_27 nbl[2]_27 nbl[3]_27 ncored00_256 ncored01_258
+  ncored10_260 ncored11_262 ncored20_264 ncored21_266 ncored30_268
+  ncored31_270 vddc_27 vddce_27 vddpe_27 vnwc_28 vpw_28 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_28 bl[0]_28 bl[1]_28 bl[2]_28 bl[3]_28 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_28 nbl[1]_28 nbl[2]_28 nbl[3]_28 ncored00_288 ncored01_290
+  ncored10_292 ncored11_294 ncored20_296 ncored21_298 ncored30_300
+  ncored31_302 vddc_28 vddce_28 vddpe_28 vnwc_29 vpw_29 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_29 bl[0]_29 bl[1]_29 bl[2]_29 bl[3]_29 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_29 nbl[1]_29 nbl[2]_29 nbl[3]_29 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_29 vddce_29 vddpe_29 vnwc_30 vpw_30 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_400 cored01_402
+  cored10_404 cored11_406 cored20_408 cored21_410 cored30_412 cored31_414
+  nbl[0]_3 nbl[1]_3 nbl[2]_3 nbl[3]_3 ncored00_416 ncored01_418 ncored10_420
+  ncored11_422 ncored20_424 ncored21_426 ncored30_428 ncored31_430 vddc_3
+  vddce_3 vddpe_3 vnwc_4 vpw_4 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_30 bl[0]_30 bl[1]_30 bl[2]_30 bl[3]_30 cored00_720 cored01_722
+  cored10_724 cored11_726 cored20_728 cored21_730 cored30_732 cored31_734
+  nbl[0]_30 nbl[1]_30 nbl[2]_30 nbl[3]_30 ncored00_736 ncored01_738
+  ncored10_740 ncored11_742 ncored20_744 ncored21_746 ncored30_748
+  ncored31_750 vddc_30 vddce_30 vddpe_30 vnwc_31 vpw_31 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_432 cored01_434
+  cored10_436 cored11_438 cored20_440 cored21_442 cored30_444 cored31_446
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_448 ncored01_450 ncored10_452
+  ncored11_454 ncored20_456 ncored21_458 ncored30_460 ncored31_462 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_464 cored01_466
+  cored10_468 cored11_470 cored20_472 cored21_474 cored30_476 cored31_478
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_480 ncored01_482 ncored10_484
+  ncored11_486 ncored20_488 ncored21_490 ncored30_492 ncored31_494 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_496 cored01_498
+  cored10_500 cored11_502 cored20_504 cored21_506 cored30_508 cored31_510
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_512 ncored01_514 ncored10_516
+  ncored11_518 ncored20_520 ncored21_522 ncored30_524 ncored31_526 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_528 cored01_530
+  cored10_532 cored11_534 cored20_536 cored21_538 cored30_540 cored31_542
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_544 ncored01_546 ncored10_548
+  ncored11_550 ncored20_552 ncored21_554 ncored30_556 ncored31_558 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_560 cored01_562
+  cored10_564 cored11_566 cored20_568 cored21_570 cored30_572 cored31_574
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_576 ncored01_578 ncored10_580
+  ncored11_582 ncored20_584 ncored21_586 ncored30_588 ncored31_590 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_592 cored01_594
+  cored10_596 cored11_598 cored20_600 cored21_602 cored30_604 cored31_606
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_608 ncored01_610 ncored10_612
+  ncored11_614 ncored20_616 ncored21_618 ncored30_620 ncored31_622 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_bot_l bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00_976 cored01_978
+  cored10_980 cored11_982 cored20_984 cored21_986 cored30_988 cored31_990
+  nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0 ncored00_992 ncored01_994 ncored10_996
+  ncored11_998 ncored20_1000 ncored21_1002 ncored30_1004 ncored31_1006 vddc_0
+  vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vsse_0 wl[0] wl[1] rf64x128cchs4
xmem_r_col_bot_r bl[0]_31 bl[1]_31 bl[2]_31 bl[3]_31 cored00 cored01 cored10
+  cored11 cored20 cored21 cored30 cored31 nbl[0]_31 nbl[1]_31 nbl[2]_31
+  nbl[3]_31 ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30
+  ncored31 vddc_31 vddce_31 vddpe_31 vnwc_32 vpw_32 vssc vsse_1 wl[0] wl[1]
+  rf64x128cchs4
.ends rf64x128mem_r_bot_row
****
.subckt rf64x128mem_r_test1row vpw_33 vnwc_33 bl[3]_31 nbl[3]_31 nbl[2]_31
+  bl[2]_31 vnwc_32 vddc_31 bl[3]_30 nbl[3]_30 nbl[2]_30 bl[2]_30 vddpe_30
+  bl[1]_30 nbl[3]_29 nbl[2]_29 bl[2]_29 vddpe_29 bl[1]_29 nbl[3]_28 nbl[2]_28
+  bl[2]_28 vddpe_28 bl[1]_28 nbl[2]_27 bl[2]_27 vddpe_27 bl[1]_27 nbl[2]_26
+  bl[2]_26 vddpe_26 bl[1]_26 bl[0]_26 nbl[3]_25 nbl[2]_25 vnwc_26 vddce_25
+  vddpe_25 bl[1]_25 nbl[1]_25 bl[0]_25 nbl[2]_24 bl[2]_24 vssc vpw_25 vnwc_25
+  vddce_24 vddpe_24 bl[1]_24 nbl[1]_24 nbl[0]_24 bl[0]_24 nbl[3]_23 nbl[2]_23
+  bl[2]_23 vpw_24 vnwc_24 vddce_23 vddpe_23 bl[1]_23 nbl[1]_23 nbl[0]_23
+  bl[0]_23 nbl[2]_22 bl[2]_22 vpw_23 vnwc_23 vddce_22 vddpe_22 bl[1]_22
+  nbl[1]_22 nbl[0]_22 bl[0]_22 nbl[2]_21 bl[2]_21 vpw_22 vnwc_22 vddc_21
+  vddce_21 vddpe_21 bl[1]_21 nbl[1]_21 nbl[0]_21 bl[0]_21 nbl[2]_20 vpw_21
+  vnwc_21 vddc_20 vddce_20 vddpe_20 bl[1]_20 nbl[1]_20 nbl[0]_20 bl[0]_20
+  nbl[2]_19 vpw_20 vnwc_20 vddc_19 vddce_19 vddpe_19 bl[1]_19 nbl[1]_19
+  nbl[0]_19 bl[0]_19 nbl[2]_18 vpw_19 vnwc_19 vddce_18 vddpe_18 bl[1]_18
+  nbl[1]_18 nbl[0]_18 bl[0]_18 nbl[2]_17 bl[2]_17 vpw_18 vnwc_18 vddce_17
+  vddpe_17 bl[1]_17 nbl[1]_17 nbl[0]_17 bl[0]_17 nbl[2]_16 bl[2]_16 vpw_17
+  vnwc_17 vddc_16 vddce_16 vddpe_16 bl[1]_16 nbl[1]_16 nbl[0]_16 bl[0]_16
+  nbl[2]_15 bl[2]_15 vpw_16 vnwc_16 vddc_15 vddce_15 vddpe_15 bl[1]_15
+  nbl[1]_15 nbl[0]_15 bl[0]_15 nbl[2]_14 vpw_15 vnwc_15 vddc_14 vddce_14
+  vddpe_14 bl[1]_14 nbl[1]_14 nbl[0]_14 bl[0]_14 nbl[2]_13 vpw_14 vnwc_14
+  vddc_13 vddce_13 vddpe_13 bl[1]_13 nbl[1]_13 nbl[0]_13 bl[0]_13 vpw_13
+  vnwc_13 vddc_12 vddce_12 vddpe_12 bl[1]_12 nbl[1]_12 nbl[0]_12 bl[0]_12
+  vpw_12 vnwc_12 vddc_11 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11
+  bl[0]_11 nbl[2]_10 bl[2]_10 vpw_11 vnwc_11 vddc_10 vddce_10 vddpe_10
+  bl[1]_10 nbl[1]_10 nbl[0]_10 bl[0]_10 nbl[2]_9 vpw_10 vnwc_10 vddc_9
+  vddce_9 vddpe_9 bl[1]_9 nbl[1]_9 nbl[0]_9 bl[0]_9 nbl[2]_8 vpw_9 vnwc_9
+  vddc_8 vddce_8 vddpe_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 vpw_8 vnwc_8
+  vddc_7 vddce_7 vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 vpw_7 vnwc_7
+  vddc_6 vddce_6 vddpe_6 bl[1]_6 nbl[1]_6 nbl[0]_6 bl[0]_6 bl[3]_5 vpw_6
+  vnwc_6 vddc_5 vddce_5 vddpe_5 bl[1]_5 nbl[1]_5 nbl[0]_5 bl[0]_5 vpw_5
+  vnwc_5 vddc_4 vddce_4 vddpe_4 bl[1]_4 nbl[1]_4 nbl[0]_4 bl[0]_4 nbl[2]_3
+  vpw_4 vnwc_4 vddc_3 vddce_3 vddpe_3 bl[1]_3 nbl[1]_3 nbl[0]_3 bl[0]_3
+  nbl[2]_2 vpw_3 vnwc_3 vddc_2 vddce_2 vddpe_2 bl[1]_2 nbl[1]_2 nbl[0]_2
+  bl[0]_2 vpw_2 vnwc_2 vddc_1 vddce_1 vddpe_1 bl[1]_1 nbl[1]_1 nbl[0]_1
+  bl[0]_1 vpw_1 vnwc_1 vddc_0 vddce_0 vddpe_0 bl[1]_0 nbl[1]_0 nbl[0]_0
+  bl[0]_0 vnwp_0 vnwc_0 vpw_0 vnwp_1 vpw_32 vddce_31 vddpe_31 bl[1]_31
+  nbl[1]_31 nbl[0]_31 bl[0]_31 vpw_31 vnwc_31 vddc_30 vddce_30 nbl[1]_30
+  nbl[0]_30 bl[0]_30 bl[3]_29 vpw_30 vnwc_30 vddc_29 vddce_29 nbl[1]_29
+  nbl[0]_29 bl[0]_29 bl[3]_28 vpw_29 vnwc_29 vddc_28 vddce_28 nbl[1]_28
+  nbl[0]_28 bl[0]_28 bl[3]_27 nbl[3]_27 vpw_28 vnwc_28 vddc_27 vddce_27
+  nbl[1]_27 nbl[0]_27 bl[0]_27 bl[3]_26 nbl[3]_26 vpw_27 vnwc_27 vddc_26
+  vddce_26 nbl[1]_26 nbl[0]_26 bl[3]_25 bl[2]_25 vpw_26 vddc_25 nbl[0]_25
+  bl[3]_24 nbl[3]_24 vddc_24 bl[3]_23 vddc_23 bl[3]_22 nbl[3]_22 vddc_22
+  bl[3]_21 nbl[3]_21 bl[3]_20 nbl[3]_20 bl[2]_20 bl[3]_19 nbl[3]_19 bl[2]_19
+  bl[3]_18 nbl[3]_18 bl[2]_18 vddc_18 bl[3]_17 nbl[3]_17 vddc_17 bl[3]_16
+  nbl[3]_16 bl[3]_15 nbl[3]_15 bl[3]_14 nbl[3]_14 bl[2]_14 bl[3]_13 nbl[3]_13
+  bl[2]_13 bl[3]_12 nbl[3]_12 nbl[2]_12 bl[2]_12 bl[3]_11 nbl[3]_11 nbl[2]_11
+  bl[2]_11 bl[3]_10 nbl[3]_10 bl[3]_9 nbl[3]_9 bl[2]_9 bl[3]_8 nbl[3]_8
+  bl[2]_8 bl[3]_7 nbl[3]_7 nbl[2]_7 bl[2]_7 bl[3]_6 nbl[3]_6 nbl[2]_6 bl[2]_6
+  nbl[3]_5 nbl[2]_5 bl[2]_5 bl[3]_4 nbl[3]_4 nbl[2]_4 bl[2]_4 bl[3]_3
+  nbl[3]_3 bl[2]_3 bl[3]_2 nbl[3]_2 bl[2]_2 bl[3]_1 nbl[3]_1 nbl[2]_1 bl[2]_1
+  bl[3]_0 nbl[3]_0 nbl[2]_0 bl[2]_0 wl[1] wl[0]
** rf64x128mem_r_test1row: 1536 flat devices **
xmem_r_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0 ncored00_320 ncored01_322 ncored10_324
+  ncored11_326 ncored20_328 ncored21_330 ncored30_332 ncored31_334 vddc_0
+  vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_1 nbl[1]_1 nbl[2]_1 nbl[3]_1 ncored00_352 ncored01_354 ncored10_356
+  ncored11_358 ncored20_360 ncored21_362 ncored30_364 ncored31_366 vddc_1
+  vddce_1 vddpe_1 vnwc_2 vpw_2 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_624 cored01_626
+  cored10_628 cored11_630 cored20_632 cored21_634 cored30_636 cored31_638
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_640 ncored01_642
+  ncored10_644 ncored11_646 ncored20_648 ncored21_650 ncored30_652
+  ncored31_654 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_656 cored01_658
+  cored10_660 cored11_662 cored20_664 cored21_666 cored30_668 cored31_670
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_672 ncored01_674
+  ncored10_676 ncored11_678 ncored20_680 ncored21_682 ncored30_684
+  ncored31_686 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_12 bl[0]_12 bl[1]_12 bl[2]_12 bl[3]_12 cored00_688 cored01_690
+  cored10_692 cored11_694 cored20_696 cored21_698 cored30_700 cored31_702
+  nbl[0]_12 nbl[1]_12 nbl[2]_12 nbl[3]_12 ncored00_704 ncored01_706
+  ncored10_708 ncored11_710 ncored20_712 ncored21_714 ncored30_716
+  ncored31_718 vddc_12 vddce_12 vddpe_12 vnwc_13 vpw_13 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_13 bl[0]_13 bl[1]_13 bl[2]_13 bl[3]_13 cored00_752 cored01_754
+  cored10_756 cored11_758 cored20_760 cored21_762 cored30_764 cored31_766
+  nbl[0]_13 nbl[1]_13 nbl[2]_13 nbl[3]_13 ncored00_768 ncored01_770
+  ncored10_772 ncored11_774 ncored20_776 ncored21_778 ncored30_780
+  ncored31_782 vddc_13 vddce_13 vddpe_13 vnwc_14 vpw_14 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_14 bl[0]_14 bl[1]_14 bl[2]_14 bl[3]_14 cored00_816 cored01_818
+  cored10_820 cored11_822 cored20_824 cored21_826 cored30_828 cored31_830
+  nbl[0]_14 nbl[1]_14 nbl[2]_14 nbl[3]_14 ncored00_832 ncored01_834
+  ncored10_836 ncored11_838 ncored20_840 ncored21_842 ncored30_844
+  ncored31_846 vddc_14 vddce_14 vddpe_14 vnwc_15 vpw_15 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_15 bl[0]_15 bl[1]_15 bl[2]_15 bl[3]_15 cored00_848 cored01_850
+  cored10_852 cored11_854 cored20_856 cored21_858 cored30_860 cored31_862
+  nbl[0]_15 nbl[1]_15 nbl[2]_15 nbl[3]_15 ncored00_864 ncored01_866
+  ncored10_868 ncored11_870 ncored20_872 ncored21_874 ncored30_876
+  ncored31_878 vddc_15 vddce_15 vddpe_15 vnwc_16 vpw_16 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_16 bl[0]_16 bl[1]_16 bl[2]_16 bl[3]_16 cored00_880 cored01_882
+  cored10_884 cored11_886 cored20_888 cored21_890 cored30_892 cored31_894
+  nbl[0]_16 nbl[1]_16 nbl[2]_16 nbl[3]_16 ncored00_896 ncored01_898
+  ncored10_900 ncored11_902 ncored20_904 ncored21_906 ncored30_908
+  ncored31_910 vddc_16 vddce_16 vddpe_16 vnwc_17 vpw_17 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_17 bl[0]_17 bl[1]_17 bl[2]_17 bl[3]_17 cored00_912 cored01_914
+  cored10_916 cored11_918 cored20_920 cored21_922 cored30_924 cored31_926
+  nbl[0]_17 nbl[1]_17 nbl[2]_17 nbl[3]_17 ncored00_928 ncored01_930
+  ncored10_932 ncored11_934 ncored20_936 ncored21_938 ncored30_940
+  ncored31_942 vddc_17 vddce_17 vddpe_17 vnwc_18 vpw_18 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_18 bl[0]_18 bl[1]_18 bl[2]_18 bl[3]_18 cored00_944 cored01_946
+  cored10_948 cored11_950 cored20_952 cored21_954 cored30_956 cored31_958
+  nbl[0]_18 nbl[1]_18 nbl[2]_18 nbl[3]_18 ncored00_960 ncored01_962
+  ncored10_964 ncored11_966 ncored20_968 ncored21_970 ncored30_972
+  ncored31_974 vddc_18 vddce_18 vddpe_18 vnwc_19 vpw_19 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_19 bl[0]_19 bl[1]_19 bl[2]_19 bl[3]_19 cored00_976 cored01_978
+  cored10_980 cored11_982 cored20_984 cored21_986 cored30_988 cored31_990
+  nbl[0]_19 nbl[1]_19 nbl[2]_19 nbl[3]_19 ncored00_992 ncored01_994
+  ncored10_996 ncored11_998 ncored20_1000 ncored21_1002 ncored30_1004
+  ncored31_1006 vddc_19 vddce_19 vddpe_19 vnwc_20 vpw_20 vssc vssc wl[0]
+  wl[1] rf64x128cchs4
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_368 cored01_370
+  cored10_372 cored11_374 cored20_376 cored21_378 cored30_380 cored31_382
+  nbl[0]_2 nbl[1]_2 nbl[2]_2 nbl[3]_2 ncored00_384 ncored01_386 ncored10_388
+  ncored11_390 ncored20_392 ncored21_394 ncored30_396 ncored31_398 vddc_2
+  vddce_2 vddpe_2 vnwc_3 vpw_3 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_20 bl[0]_20 bl[1]_20 bl[2]_20 bl[3]_20 cored00 cored01 cored10
+  cored11 cored20 cored21 cored30 cored31 nbl[0]_20 nbl[1]_20 nbl[2]_20
+  nbl[3]_20 ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30
+  ncored31 vddc_20 vddce_20 vddpe_20 vnwc_21 vpw_21 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_21 bl[0]_21 bl[1]_21 bl[2]_21 bl[3]_21 cored00_16 cored01_18
+  cored10_20 cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_21
+  nbl[1]_21 nbl[2]_21 nbl[3]_21 ncored00_32 ncored01_34 ncored10_36
+  ncored11_38 ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_21
+  vddce_21 vddpe_21 vnwc_22 vpw_22 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_22 bl[0]_22 bl[1]_22 bl[2]_22 bl[3]_22 cored00_48 cored01_50
+  cored10_52 cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_22
+  nbl[1]_22 nbl[2]_22 nbl[3]_22 ncored00_64 ncored01_66 ncored10_68
+  ncored11_70 ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_22
+  vddce_22 vddpe_22 vnwc_23 vpw_23 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_23 bl[0]_23 bl[1]_23 bl[2]_23 bl[3]_23 cored00_80 cored01_82
+  cored10_84 cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_23
+  nbl[1]_23 nbl[2]_23 nbl[3]_23 ncored00_96 ncored01_98 ncored10_100
+  ncored11_102 ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_23
+  vddce_23 vddpe_23 vnwc_24 vpw_24 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_24 bl[0]_24 bl[1]_24 bl[2]_24 bl[3]_24 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_24 nbl[1]_24 nbl[2]_24 nbl[3]_24 ncored00_128 ncored01_130
+  ncored10_132 ncored11_134 ncored20_136 ncored21_138 ncored30_140
+  ncored31_142 vddc_24 vddce_24 vddpe_24 vnwc_25 vpw_25 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_25 bl[0]_25 bl[1]_25 bl[2]_25 bl[3]_25 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_25 nbl[1]_25 nbl[2]_25 nbl[3]_25 ncored00_160 ncored01_162
+  ncored10_164 ncored11_166 ncored20_168 ncored21_170 ncored30_172
+  ncored31_174 vddc_25 vddce_25 vddpe_25 vnwc_26 vpw_26 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_26 bl[0]_26 bl[1]_26 bl[2]_26 bl[3]_26 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_26 nbl[1]_26 nbl[2]_26 nbl[3]_26 ncored00_192 ncored01_194
+  ncored10_196 ncored11_198 ncored20_200 ncored21_202 ncored30_204
+  ncored31_206 vddc_26 vddce_26 vddpe_26 vnwc_27 vpw_27 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_27 bl[0]_27 bl[1]_27 bl[2]_27 bl[3]_27 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_27 nbl[1]_27 nbl[2]_27 nbl[3]_27 ncored00_224 ncored01_226
+  ncored10_228 ncored11_230 ncored20_232 ncored21_234 ncored30_236
+  ncored31_238 vddc_27 vddce_27 vddpe_27 vnwc_28 vpw_28 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_28 bl[0]_28 bl[1]_28 bl[2]_28 bl[3]_28 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_28 nbl[1]_28 nbl[2]_28 nbl[3]_28 ncored00_256 ncored01_258
+  ncored10_260 ncored11_262 ncored20_264 ncored21_266 ncored30_268
+  ncored31_270 vddc_28 vddce_28 vddpe_28 vnwc_29 vpw_29 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_29 bl[0]_29 bl[1]_29 bl[2]_29 bl[3]_29 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_29 nbl[1]_29 nbl[2]_29 nbl[3]_29 ncored00_288 ncored01_290
+  ncored10_292 ncored11_294 ncored20_296 ncored21_298 ncored30_300
+  ncored31_302 vddc_29 vddce_29 vddpe_29 vnwc_30 vpw_30 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_400 cored01_402
+  cored10_404 cored11_406 cored20_408 cored21_410 cored30_412 cored31_414
+  nbl[0]_3 nbl[1]_3 nbl[2]_3 nbl[3]_3 ncored00_416 ncored01_418 ncored10_420
+  ncored11_422 ncored20_424 ncored21_426 ncored30_428 ncored31_430 vddc_3
+  vddce_3 vddpe_3 vnwc_4 vpw_4 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_30 bl[0]_30 bl[1]_30 bl[2]_30 bl[3]_30 cored00_720 cored01_722
+  cored10_724 cored11_726 cored20_728 cored21_730 cored30_732 cored31_734
+  nbl[0]_30 nbl[1]_30 nbl[2]_30 nbl[3]_30 ncored00_736 ncored01_738
+  ncored10_740 ncored11_742 ncored20_744 ncored21_746 ncored30_748
+  ncored31_750 vddc_30 vddce_30 vddpe_30 vnwc_31 vpw_31 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_31 bl[0]_31 bl[1]_31 bl[2]_31 bl[3]_31 cored00_784 cored01_786
+  cored10_788 cored11_790 cored20_792 cored21_794 cored30_796 cored31_798
+  nbl[0]_31 nbl[1]_31 nbl[2]_31 nbl[3]_31 ncored00_800 ncored01_802
+  ncored10_804 ncored11_806 ncored20_808 ncored21_810 ncored30_812
+  ncored31_814 vddc_31 vddce_31 vddpe_31 vnwc_32 vpw_32 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_432 cored01_434
+  cored10_436 cored11_438 cored20_440 cored21_442 cored30_444 cored31_446
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_448 ncored01_450 ncored10_452
+  ncored11_454 ncored20_456 ncored21_458 ncored30_460 ncored31_462 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_464 cored01_466
+  cored10_468 cored11_470 cored20_472 cored21_474 cored30_476 cored31_478
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_480 ncored01_482 ncored10_484
+  ncored11_486 ncored20_488 ncored21_490 ncored30_492 ncored31_494 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_496 cored01_498
+  cored10_500 cored11_502 cored20_504 cored21_506 cored30_508 cored31_510
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_512 ncored01_514 ncored10_516
+  ncored11_518 ncored20_520 ncored21_522 ncored30_524 ncored31_526 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_528 cored01_530
+  cored10_532 cored11_534 cored20_536 cored21_538 cored30_540 cored31_542
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_544 ncored01_546 ncored10_548
+  ncored11_550 ncored20_552 ncored21_554 ncored30_556 ncored31_558 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_560 cored01_562
+  cored10_564 cored11_566 cored20_568 cored21_570 cored30_572 cored31_574
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_576 ncored01_578 ncored10_580
+  ncored11_582 ncored20_584 ncored21_586 ncored30_588 ncored31_590 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_592 cored01_594
+  cored10_596 cored11_598 cored20_600 cored21_602 cored30_604 cored31_606
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_608 ncored01_610 ncored10_612
+  ncored11_614 ncored20_616 ncored21_618 ncored30_620 ncored31_622 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] rf64x128cchs4
.ends rf64x128mem_r_test1row
****
.subckt rf64x128mem_r_test2row vpw_33 vnwc_33 bl[3]_31 nbl[3]_31 nbl[2]_31
+  bl[2]_31 vnwc_32 vddc_31 bl[3]_30 nbl[3]_30 nbl[2]_30 bl[2]_30 vddpe_30
+  bl[1]_30 nbl[3]_29 nbl[2]_29 bl[2]_29 vddpe_29 bl[1]_29 nbl[3]_28 nbl[2]_28
+  bl[2]_28 vddpe_28 bl[1]_28 nbl[2]_27 bl[2]_27 vddpe_27 bl[1]_27 nbl[2]_26
+  bl[2]_26 vddpe_26 bl[1]_26 bl[0]_26 nbl[3]_25 nbl[2]_25 vnwc_26 vddce_25
+  vddpe_25 bl[1]_25 nbl[1]_25 bl[0]_25 nbl[2]_24 bl[2]_24 vssc vpw_25 vnwc_25
+  vddce_24 vddpe_24 bl[1]_24 nbl[1]_24 nbl[0]_24 bl[0]_24 nbl[3]_23 nbl[2]_23
+  bl[2]_23 vpw_24 vnwc_24 vddce_23 vddpe_23 bl[1]_23 nbl[1]_23 nbl[0]_23
+  bl[0]_23 nbl[2]_22 bl[2]_22 vpw_23 vnwc_23 vddce_22 vddpe_22 bl[1]_22
+  nbl[1]_22 nbl[0]_22 bl[0]_22 nbl[2]_21 bl[2]_21 vpw_22 vnwc_22 vddc_21
+  vddce_21 vddpe_21 bl[1]_21 nbl[1]_21 nbl[0]_21 bl[0]_21 nbl[2]_20 vpw_21
+  vnwc_21 vddc_20 vddce_20 vddpe_20 bl[1]_20 nbl[1]_20 nbl[0]_20 bl[0]_20
+  nbl[2]_19 vpw_20 vnwc_20 vddc_19 vddce_19 vddpe_19 bl[1]_19 nbl[1]_19
+  nbl[0]_19 bl[0]_19 nbl[2]_18 vpw_19 vnwc_19 vddce_18 vddpe_18 bl[1]_18
+  nbl[1]_18 nbl[0]_18 bl[0]_18 nbl[2]_17 bl[2]_17 vpw_18 vnwc_18 vddce_17
+  vddpe_17 bl[1]_17 nbl[1]_17 nbl[0]_17 bl[0]_17 nbl[2]_16 bl[2]_16 vpw_17
+  vnwc_17 vddc_16 vddce_16 vddpe_16 bl[1]_16 nbl[1]_16 nbl[0]_16 bl[0]_16
+  nbl[2]_15 bl[2]_15 vpw_16 vnwc_16 vddc_15 vddce_15 vddpe_15 bl[1]_15
+  nbl[1]_15 nbl[0]_15 bl[0]_15 nbl[2]_14 vpw_15 vnwc_15 vddc_14 vddce_14
+  vddpe_14 bl[1]_14 nbl[1]_14 nbl[0]_14 bl[0]_14 nbl[2]_13 vpw_14 vnwc_14
+  vddc_13 vddce_13 vddpe_13 bl[1]_13 nbl[1]_13 nbl[0]_13 bl[0]_13 vpw_13
+  vnwc_13 vddc_12 vddce_12 vddpe_12 bl[1]_12 nbl[1]_12 nbl[0]_12 bl[0]_12
+  vpw_12 vnwc_12 vddc_11 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11
+  bl[0]_11 nbl[2]_10 bl[2]_10 vpw_11 vnwc_11 vddc_10 vddce_10 vddpe_10
+  bl[1]_10 nbl[1]_10 nbl[0]_10 bl[0]_10 nbl[2]_9 vpw_10 vnwc_10 vddc_9
+  vddce_9 vddpe_9 bl[1]_9 nbl[1]_9 nbl[0]_9 bl[0]_9 nbl[2]_8 vpw_9 vnwc_9
+  vddc_8 vddce_8 vddpe_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 vpw_8 vnwc_8
+  vddc_7 vddce_7 vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 vpw_7 vnwc_7
+  vddc_6 vddce_6 vddpe_6 bl[1]_6 nbl[1]_6 nbl[0]_6 bl[0]_6 bl[3]_5 vpw_6
+  vnwc_6 vddc_5 vddce_5 vddpe_5 bl[1]_5 nbl[1]_5 nbl[0]_5 bl[0]_5 vpw_5
+  vnwc_5 vddc_4 vddce_4 vddpe_4 bl[1]_4 nbl[1]_4 nbl[0]_4 bl[0]_4 nbl[2]_3
+  vpw_4 vnwc_4 vddc_3 vddce_3 vddpe_3 bl[1]_3 nbl[1]_3 nbl[0]_3 bl[0]_3
+  nbl[2]_2 vpw_3 vnwc_3 vddc_2 vddce_2 vddpe_2 bl[1]_2 nbl[1]_2 nbl[0]_2
+  bl[0]_2 vpw_2 vnwc_2 vddc_1 vddce_1 vddpe_1 bl[1]_1 nbl[1]_1 nbl[0]_1
+  bl[0]_1 vpw_1 vnwc_1 vddc_0 vddce_0 vddpe_0 bl[1]_0 nbl[1]_0 nbl[0]_0
+  bl[0]_0 vnwp_0 vnwc_0 vpw_0 vnwp_1 vpw_32 vddce_31 vddpe_31 bl[1]_31
+  nbl[1]_31 nbl[0]_31 bl[0]_31 vpw_31 vnwc_31 vddc_30 vddce_30 nbl[1]_30
+  nbl[0]_30 bl[0]_30 bl[3]_29 vpw_30 vnwc_30 vddc_29 vddce_29 nbl[1]_29
+  nbl[0]_29 bl[0]_29 bl[3]_28 vpw_29 vnwc_29 vddc_28 vddce_28 nbl[1]_28
+  nbl[0]_28 bl[0]_28 bl[3]_27 nbl[3]_27 vpw_28 vnwc_28 vddc_27 vddce_27
+  nbl[1]_27 nbl[0]_27 bl[0]_27 bl[3]_26 nbl[3]_26 vpw_27 vnwc_27 vddc_26
+  vddce_26 nbl[1]_26 nbl[0]_26 bl[3]_25 bl[2]_25 vpw_26 vddc_25 nbl[0]_25
+  bl[3]_24 nbl[3]_24 vddc_24 bl[3]_23 vddc_23 bl[3]_22 nbl[3]_22 vddc_22
+  bl[3]_21 nbl[3]_21 bl[3]_20 nbl[3]_20 bl[2]_20 bl[3]_19 nbl[3]_19 bl[2]_19
+  bl[3]_18 nbl[3]_18 bl[2]_18 vddc_18 bl[3]_17 nbl[3]_17 vddc_17 bl[3]_16
+  nbl[3]_16 bl[3]_15 nbl[3]_15 bl[3]_14 nbl[3]_14 bl[2]_14 bl[3]_13 nbl[3]_13
+  bl[2]_13 bl[3]_12 nbl[3]_12 nbl[2]_12 bl[2]_12 bl[3]_11 nbl[3]_11 nbl[2]_11
+  bl[2]_11 bl[3]_10 nbl[3]_10 bl[3]_9 nbl[3]_9 bl[2]_9 bl[3]_8 nbl[3]_8
+  bl[2]_8 bl[3]_7 nbl[3]_7 nbl[2]_7 bl[2]_7 bl[3]_6 nbl[3]_6 nbl[2]_6 bl[2]_6
+  nbl[3]_5 nbl[2]_5 bl[2]_5 bl[3]_4 nbl[3]_4 nbl[2]_4 bl[2]_4 bl[3]_3
+  nbl[3]_3 bl[2]_3 bl[3]_2 nbl[3]_2 bl[2]_2 bl[3]_1 nbl[3]_1 nbl[2]_1 bl[2]_1
+  bl[3]_0 nbl[3]_0 nbl[2]_0 bl[2]_0 wl[1] wl[0]
** rf64x128mem_r_test2row: 1536 flat devices **
xmem_r_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0 ncored00_320 ncored01_322 ncored10_324
+  ncored11_326 ncored20_328 ncored21_330 ncored30_332 ncored31_334 vddc_0
+  vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_1 nbl[1]_1 nbl[2]_1 nbl[3]_1 ncored00_352 ncored01_354 ncored10_356
+  ncored11_358 ncored20_360 ncored21_362 ncored30_364 ncored31_366 vddc_1
+  vddce_1 vddpe_1 vnwc_2 vpw_2 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_624 cored01_626
+  cored10_628 cored11_630 cored20_632 cored21_634 cored30_636 cored31_638
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_640 ncored01_642
+  ncored10_644 ncored11_646 ncored20_648 ncored21_650 ncored30_652
+  ncored31_654 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_656 cored01_658
+  cored10_660 cored11_662 cored20_664 cored21_666 cored30_668 cored31_670
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_672 ncored01_674
+  ncored10_676 ncored11_678 ncored20_680 ncored21_682 ncored30_684
+  ncored31_686 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_12 bl[0]_12 bl[1]_12 bl[2]_12 bl[3]_12 cored00_688 cored01_690
+  cored10_692 cored11_694 cored20_696 cored21_698 cored30_700 cored31_702
+  nbl[0]_12 nbl[1]_12 nbl[2]_12 nbl[3]_12 ncored00_704 ncored01_706
+  ncored10_708 ncored11_710 ncored20_712 ncored21_714 ncored30_716
+  ncored31_718 vddc_12 vddce_12 vddpe_12 vnwc_13 vpw_13 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_13 bl[0]_13 bl[1]_13 bl[2]_13 bl[3]_13 cored00_752 cored01_754
+  cored10_756 cored11_758 cored20_760 cored21_762 cored30_764 cored31_766
+  nbl[0]_13 nbl[1]_13 nbl[2]_13 nbl[3]_13 ncored00_768 ncored01_770
+  ncored10_772 ncored11_774 ncored20_776 ncored21_778 ncored30_780
+  ncored31_782 vddc_13 vddce_13 vddpe_13 vnwc_14 vpw_14 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_14 bl[0]_14 bl[1]_14 bl[2]_14 bl[3]_14 cored00_816 cored01_818
+  cored10_820 cored11_822 cored20_824 cored21_826 cored30_828 cored31_830
+  nbl[0]_14 nbl[1]_14 nbl[2]_14 nbl[3]_14 ncored00_832 ncored01_834
+  ncored10_836 ncored11_838 ncored20_840 ncored21_842 ncored30_844
+  ncored31_846 vddc_14 vddce_14 vddpe_14 vnwc_15 vpw_15 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_15 bl[0]_15 bl[1]_15 bl[2]_15 bl[3]_15 cored00_848 cored01_850
+  cored10_852 cored11_854 cored20_856 cored21_858 cored30_860 cored31_862
+  nbl[0]_15 nbl[1]_15 nbl[2]_15 nbl[3]_15 ncored00_864 ncored01_866
+  ncored10_868 ncored11_870 ncored20_872 ncored21_874 ncored30_876
+  ncored31_878 vddc_15 vddce_15 vddpe_15 vnwc_16 vpw_16 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_16 bl[0]_16 bl[1]_16 bl[2]_16 bl[3]_16 cored00_880 cored01_882
+  cored10_884 cored11_886 cored20_888 cored21_890 cored30_892 cored31_894
+  nbl[0]_16 nbl[1]_16 nbl[2]_16 nbl[3]_16 ncored00_896 ncored01_898
+  ncored10_900 ncored11_902 ncored20_904 ncored21_906 ncored30_908
+  ncored31_910 vddc_16 vddce_16 vddpe_16 vnwc_17 vpw_17 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_17 bl[0]_17 bl[1]_17 bl[2]_17 bl[3]_17 cored00_912 cored01_914
+  cored10_916 cored11_918 cored20_920 cored21_922 cored30_924 cored31_926
+  nbl[0]_17 nbl[1]_17 nbl[2]_17 nbl[3]_17 ncored00_928 ncored01_930
+  ncored10_932 ncored11_934 ncored20_936 ncored21_938 ncored30_940
+  ncored31_942 vddc_17 vddce_17 vddpe_17 vnwc_18 vpw_18 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_18 bl[0]_18 bl[1]_18 bl[2]_18 bl[3]_18 cored00_944 cored01_946
+  cored10_948 cored11_950 cored20_952 cored21_954 cored30_956 cored31_958
+  nbl[0]_18 nbl[1]_18 nbl[2]_18 nbl[3]_18 ncored00_960 ncored01_962
+  ncored10_964 ncored11_966 ncored20_968 ncored21_970 ncored30_972
+  ncored31_974 vddc_18 vddce_18 vddpe_18 vnwc_19 vpw_19 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_19 bl[0]_19 bl[1]_19 bl[2]_19 bl[3]_19 cored00_976 cored01_978
+  cored10_980 cored11_982 cored20_984 cored21_986 cored30_988 cored31_990
+  nbl[0]_19 nbl[1]_19 nbl[2]_19 nbl[3]_19 ncored00_992 ncored01_994
+  ncored10_996 ncored11_998 ncored20_1000 ncored21_1002 ncored30_1004
+  ncored31_1006 vddc_19 vddce_19 vddpe_19 vnwc_20 vpw_20 vssc vssc wl[0]
+  wl[1] rf64x128cchs4
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_368 cored01_370
+  cored10_372 cored11_374 cored20_376 cored21_378 cored30_380 cored31_382
+  nbl[0]_2 nbl[1]_2 nbl[2]_2 nbl[3]_2 ncored00_384 ncored01_386 ncored10_388
+  ncored11_390 ncored20_392 ncored21_394 ncored30_396 ncored31_398 vddc_2
+  vddce_2 vddpe_2 vnwc_3 vpw_3 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_20 bl[0]_20 bl[1]_20 bl[2]_20 bl[3]_20 cored00 cored01 cored10
+  cored11 cored20 cored21 cored30 cored31 nbl[0]_20 nbl[1]_20 nbl[2]_20
+  nbl[3]_20 ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30
+  ncored31 vddc_20 vddce_20 vddpe_20 vnwc_21 vpw_21 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_21 bl[0]_21 bl[1]_21 bl[2]_21 bl[3]_21 cored00_16 cored01_18
+  cored10_20 cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_21
+  nbl[1]_21 nbl[2]_21 nbl[3]_21 ncored00_32 ncored01_34 ncored10_36
+  ncored11_38 ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_21
+  vddce_21 vddpe_21 vnwc_22 vpw_22 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_22 bl[0]_22 bl[1]_22 bl[2]_22 bl[3]_22 cored00_48 cored01_50
+  cored10_52 cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_22
+  nbl[1]_22 nbl[2]_22 nbl[3]_22 ncored00_64 ncored01_66 ncored10_68
+  ncored11_70 ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_22
+  vddce_22 vddpe_22 vnwc_23 vpw_23 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_23 bl[0]_23 bl[1]_23 bl[2]_23 bl[3]_23 cored00_80 cored01_82
+  cored10_84 cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_23
+  nbl[1]_23 nbl[2]_23 nbl[3]_23 ncored00_96 ncored01_98 ncored10_100
+  ncored11_102 ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_23
+  vddce_23 vddpe_23 vnwc_24 vpw_24 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_24 bl[0]_24 bl[1]_24 bl[2]_24 bl[3]_24 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_24 nbl[1]_24 nbl[2]_24 nbl[3]_24 ncored00_128 ncored01_130
+  ncored10_132 ncored11_134 ncored20_136 ncored21_138 ncored30_140
+  ncored31_142 vddc_24 vddce_24 vddpe_24 vnwc_25 vpw_25 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_25 bl[0]_25 bl[1]_25 bl[2]_25 bl[3]_25 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_25 nbl[1]_25 nbl[2]_25 nbl[3]_25 ncored00_160 ncored01_162
+  ncored10_164 ncored11_166 ncored20_168 ncored21_170 ncored30_172
+  ncored31_174 vddc_25 vddce_25 vddpe_25 vnwc_26 vpw_26 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_26 bl[0]_26 bl[1]_26 bl[2]_26 bl[3]_26 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_26 nbl[1]_26 nbl[2]_26 nbl[3]_26 ncored00_192 ncored01_194
+  ncored10_196 ncored11_198 ncored20_200 ncored21_202 ncored30_204
+  ncored31_206 vddc_26 vddce_26 vddpe_26 vnwc_27 vpw_27 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_27 bl[0]_27 bl[1]_27 bl[2]_27 bl[3]_27 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_27 nbl[1]_27 nbl[2]_27 nbl[3]_27 ncored00_224 ncored01_226
+  ncored10_228 ncored11_230 ncored20_232 ncored21_234 ncored30_236
+  ncored31_238 vddc_27 vddce_27 vddpe_27 vnwc_28 vpw_28 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_28 bl[0]_28 bl[1]_28 bl[2]_28 bl[3]_28 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_28 nbl[1]_28 nbl[2]_28 nbl[3]_28 ncored00_256 ncored01_258
+  ncored10_260 ncored11_262 ncored20_264 ncored21_266 ncored30_268
+  ncored31_270 vddc_28 vddce_28 vddpe_28 vnwc_29 vpw_29 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_29 bl[0]_29 bl[1]_29 bl[2]_29 bl[3]_29 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_29 nbl[1]_29 nbl[2]_29 nbl[3]_29 ncored00_288 ncored01_290
+  ncored10_292 ncored11_294 ncored20_296 ncored21_298 ncored30_300
+  ncored31_302 vddc_29 vddce_29 vddpe_29 vnwc_30 vpw_30 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_400 cored01_402
+  cored10_404 cored11_406 cored20_408 cored21_410 cored30_412 cored31_414
+  nbl[0]_3 nbl[1]_3 nbl[2]_3 nbl[3]_3 ncored00_416 ncored01_418 ncored10_420
+  ncored11_422 ncored20_424 ncored21_426 ncored30_428 ncored31_430 vddc_3
+  vddce_3 vddpe_3 vnwc_4 vpw_4 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_30 bl[0]_30 bl[1]_30 bl[2]_30 bl[3]_30 cored00_720 cored01_722
+  cored10_724 cored11_726 cored20_728 cored21_730 cored30_732 cored31_734
+  nbl[0]_30 nbl[1]_30 nbl[2]_30 nbl[3]_30 ncored00_736 ncored01_738
+  ncored10_740 ncored11_742 ncored20_744 ncored21_746 ncored30_748
+  ncored31_750 vddc_30 vddce_30 vddpe_30 vnwc_31 vpw_31 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_31 bl[0]_31 bl[1]_31 bl[2]_31 bl[3]_31 cored00_784 cored01_786
+  cored10_788 cored11_790 cored20_792 cored21_794 cored30_796 cored31_798
+  nbl[0]_31 nbl[1]_31 nbl[2]_31 nbl[3]_31 ncored00_800 ncored01_802
+  ncored10_804 ncored11_806 ncored20_808 ncored21_810 ncored30_812
+  ncored31_814 vddc_31 vddce_31 vddpe_31 vnwc_32 vpw_32 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_432 cored01_434
+  cored10_436 cored11_438 cored20_440 cored21_442 cored30_444 cored31_446
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_448 ncored01_450 ncored10_452
+  ncored11_454 ncored20_456 ncored21_458 ncored30_460 ncored31_462 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_464 cored01_466
+  cored10_468 cored11_470 cored20_472 cored21_474 cored30_476 cored31_478
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_480 ncored01_482 ncored10_484
+  ncored11_486 ncored20_488 ncored21_490 ncored30_492 ncored31_494 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_496 cored01_498
+  cored10_500 cored11_502 cored20_504 cored21_506 cored30_508 cored31_510
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_512 ncored01_514 ncored10_516
+  ncored11_518 ncored20_520 ncored21_522 ncored30_524 ncored31_526 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_528 cored01_530
+  cored10_532 cored11_534 cored20_536 cored21_538 cored30_540 cored31_542
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_544 ncored01_546 ncored10_548
+  ncored11_550 ncored20_552 ncored21_554 ncored30_556 ncored31_558 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_560 cored01_562
+  cored10_564 cored11_566 cored20_568 cored21_570 cored30_572 cored31_574
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_576 ncored01_578 ncored10_580
+  ncored11_582 ncored20_584 ncored21_586 ncored30_588 ncored31_590 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_592 cored01_594
+  cored10_596 cored11_598 cored20_600 cored21_602 cored30_604 cored31_606
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_608 ncored01_610 ncored10_612
+  ncored11_614 ncored20_616 ncored21_618 ncored30_620 ncored31_622 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] rf64x128cchs4
.ends rf64x128mem_r_test2row
****
.subckt rf64x128mem_r_top_row vpw_33 vnwc_33 bl[3]_31 nbl[3]_31 nbl[2]_31
+  bl[2]_31 vnwc_32 vddc_31 bl[3]_30 nbl[3]_30 nbl[2]_30 bl[2]_30 vddpe_30
+  bl[1]_30 nbl[3]_29 nbl[2]_29 bl[2]_29 vddpe_29 bl[1]_29 nbl[3]_28 nbl[2]_28
+  bl[2]_28 vddpe_28 bl[1]_28 nbl[2]_27 bl[2]_27 vddpe_27 bl[1]_27 nbl[2]_26
+  bl[2]_26 vddpe_26 bl[1]_26 bl[0]_26 nbl[3]_25 nbl[2]_25 vnwc_26 vddce_25
+  vddpe_25 bl[1]_25 nbl[1]_25 bl[0]_25 nbl[2]_24 bl[2]_24 vssc vpw_25 vnwc_25
+  vddce_24 vddpe_24 bl[1]_24 nbl[1]_24 nbl[0]_24 bl[0]_24 nbl[3]_23 nbl[2]_23
+  bl[2]_23 vpw_24 vnwc_24 vddce_23 vddpe_23 bl[1]_23 nbl[1]_23 nbl[0]_23
+  bl[0]_23 nbl[2]_22 bl[2]_22 vpw_23 vnwc_23 vddce_22 vddpe_22 bl[1]_22
+  nbl[1]_22 nbl[0]_22 bl[0]_22 nbl[2]_21 bl[2]_21 vpw_22 vnwc_22 vddc_21
+  vddce_21 vddpe_21 bl[1]_21 nbl[1]_21 nbl[0]_21 bl[0]_21 nbl[2]_20 vpw_21
+  vnwc_21 vddc_20 vddce_20 vddpe_20 bl[1]_20 nbl[1]_20 nbl[0]_20 bl[0]_20
+  nbl[2]_19 vpw_20 vnwc_20 vddc_19 vddce_19 vddpe_19 bl[1]_19 nbl[1]_19
+  nbl[0]_19 bl[0]_19 nbl[2]_18 vpw_19 vnwc_19 vddce_18 vddpe_18 bl[1]_18
+  nbl[1]_18 nbl[0]_18 bl[0]_18 nbl[2]_17 bl[2]_17 vpw_18 vnwc_18 vddce_17
+  vddpe_17 bl[1]_17 nbl[1]_17 nbl[0]_17 bl[0]_17 nbl[2]_16 bl[2]_16 vpw_17
+  vnwc_17 vddc_16 vddce_16 vddpe_16 bl[1]_16 nbl[1]_16 nbl[0]_16 bl[0]_16
+  nbl[2]_15 bl[2]_15 vpw_16 vnwc_16 vddc_15 vddce_15 vddpe_15 bl[1]_15
+  nbl[1]_15 nbl[0]_15 bl[0]_15 nbl[2]_14 vpw_15 vnwc_15 vddc_14 vddce_14
+  vddpe_14 bl[1]_14 nbl[1]_14 nbl[0]_14 bl[0]_14 nbl[2]_13 vpw_14 vnwc_14
+  vddc_13 vddce_13 vddpe_13 bl[1]_13 nbl[1]_13 nbl[0]_13 bl[0]_13 vpw_13
+  vnwc_13 vddc_12 vddce_12 vddpe_12 bl[1]_12 nbl[1]_12 nbl[0]_12 bl[0]_12
+  vpw_12 vnwc_12 vddc_11 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11
+  bl[0]_11 nbl[2]_10 bl[2]_10 vpw_11 vnwc_11 vddc_10 vddce_10 vddpe_10
+  bl[1]_10 nbl[1]_10 nbl[0]_10 bl[0]_10 nbl[2]_9 vpw_10 vnwc_10 vddc_9
+  vddce_9 vddpe_9 bl[1]_9 nbl[1]_9 nbl[0]_9 bl[0]_9 nbl[2]_8 vpw_9 vnwc_9
+  vddc_8 vddce_8 vddpe_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 vpw_8 vnwc_8
+  vddc_7 vddce_7 vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 vpw_7 vnwc_7
+  vddc_6 vddce_6 vddpe_6 bl[1]_6 nbl[1]_6 nbl[0]_6 bl[0]_6 bl[3]_5 vpw_6
+  vnwc_6 vddc_5 vddce_5 vddpe_5 bl[1]_5 nbl[1]_5 nbl[0]_5 bl[0]_5 vpw_5
+  vnwc_5 vddc_4 vddce_4 vddpe_4 bl[1]_4 nbl[1]_4 nbl[0]_4 bl[0]_4 nbl[2]_3
+  vpw_4 vnwc_4 vddc_3 vddce_3 vddpe_3 bl[1]_3 nbl[1]_3 nbl[0]_3 bl[0]_3
+  nbl[2]_2 vpw_3 vnwc_3 vddc_2 vddce_2 vddpe_2 bl[1]_2 nbl[1]_2 nbl[0]_2
+  bl[0]_2 vpw_2 vnwc_2 vddc_1 vddce_1 vddpe_1 bl[1]_1 nbl[1]_1 nbl[0]_1
+  bl[0]_1 vpw_1 vsse_0 vnwc_1 vddc_0 vddce_0 vddpe_0 bl[1]_0 nbl[1]_0
+  nbl[0]_0 bl[0]_0 vnwp_0 vnwc_0 vpw_0 vnwp_1 vpw_32 vsse_1 vddce_31 vddpe_31
+  bl[1]_31 nbl[1]_31 nbl[0]_31 bl[0]_31 vpw_31 vnwc_31 vddc_30 vddce_30
+  nbl[1]_30 nbl[0]_30 bl[0]_30 bl[3]_29 vpw_30 vnwc_30 vddc_29 vddce_29
+  nbl[1]_29 nbl[0]_29 bl[0]_29 bl[3]_28 vpw_29 vnwc_29 vddc_28 vddce_28
+  nbl[1]_28 nbl[0]_28 bl[0]_28 bl[3]_27 nbl[3]_27 vpw_28 vnwc_28 vddc_27
+  vddce_27 nbl[1]_27 nbl[0]_27 bl[0]_27 bl[3]_26 nbl[3]_26 vpw_27 vnwc_27
+  vddc_26 vddce_26 nbl[1]_26 nbl[0]_26 bl[3]_25 bl[2]_25 vpw_26 vddc_25
+  nbl[0]_25 bl[3]_24 nbl[3]_24 vddc_24 bl[3]_23 vddc_23 bl[3]_22 nbl[3]_22
+  vddc_22 bl[3]_21 nbl[3]_21 bl[3]_20 nbl[3]_20 bl[2]_20 bl[3]_19 nbl[3]_19
+  bl[2]_19 bl[3]_18 nbl[3]_18 bl[2]_18 vddc_18 bl[3]_17 nbl[3]_17 vddc_17
+  bl[3]_16 nbl[3]_16 bl[3]_15 nbl[3]_15 bl[3]_14 nbl[3]_14 bl[2]_14 bl[3]_13
+  nbl[3]_13 bl[2]_13 bl[3]_12 nbl[3]_12 nbl[2]_12 bl[2]_12 bl[3]_11 nbl[3]_11
+  nbl[2]_11 bl[2]_11 bl[3]_10 nbl[3]_10 bl[3]_9 nbl[3]_9 bl[2]_9 bl[3]_8
+  nbl[3]_8 bl[2]_8 bl[3]_7 nbl[3]_7 nbl[2]_7 bl[2]_7 bl[3]_6 nbl[3]_6
+  nbl[2]_6 bl[2]_6 nbl[3]_5 nbl[2]_5 bl[2]_5 bl[3]_4 nbl[3]_4 nbl[2]_4
+  bl[2]_4 bl[3]_3 nbl[3]_3 bl[2]_3 bl[3]_2 nbl[3]_2 bl[2]_2 bl[3]_1 nbl[3]_1
+  nbl[2]_1 bl[2]_1 bl[3]_0 nbl[3]_0 nbl[2]_0 bl[2]_0 wl[1] wl[0]
** rf64x128mem_r_top_row: 1536 flat devices **
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_368 cored01_370
+  cored10_372 cored11_374 cored20_376 cored21_378 cored30_380 cored31_382
+  nbl[0]_1 nbl[1]_1 nbl[2]_1 nbl[3]_1 ncored00_384 ncored01_386 ncored10_388
+  ncored11_390 ncored20_392 ncored21_394 ncored30_396 ncored31_398 vddc_1
+  vddce_1 vddpe_1 vnwc_2 vpw_2 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_656 cored01_658
+  cored10_660 cored11_662 cored20_664 cored21_666 cored30_668 cored31_670
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_672 ncored01_674
+  ncored10_676 ncored11_678 ncored20_680 ncored21_682 ncored30_684
+  ncored31_686 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_688 cored01_690
+  cored10_692 cored11_694 cored20_696 cored21_698 cored30_700 cored31_702
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_704 ncored01_706
+  ncored10_708 ncored11_710 ncored20_712 ncored21_714 ncored30_716
+  ncored31_718 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_12 bl[0]_12 bl[1]_12 bl[2]_12 bl[3]_12 cored00_720 cored01_722
+  cored10_724 cored11_726 cored20_728 cored21_730 cored30_732 cored31_734
+  nbl[0]_12 nbl[1]_12 nbl[2]_12 nbl[3]_12 ncored00_736 ncored01_738
+  ncored10_740 ncored11_742 ncored20_744 ncored21_746 ncored30_748
+  ncored31_750 vddc_12 vddce_12 vddpe_12 vnwc_13 vpw_13 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_13 bl[0]_13 bl[1]_13 bl[2]_13 bl[3]_13 cored00_784 cored01_786
+  cored10_788 cored11_790 cored20_792 cored21_794 cored30_796 cored31_798
+  nbl[0]_13 nbl[1]_13 nbl[2]_13 nbl[3]_13 ncored00_800 ncored01_802
+  ncored10_804 ncored11_806 ncored20_808 ncored21_810 ncored30_812
+  ncored31_814 vddc_13 vddce_13 vddpe_13 vnwc_14 vpw_14 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_14 bl[0]_14 bl[1]_14 bl[2]_14 bl[3]_14 cored00_816 cored01_818
+  cored10_820 cored11_822 cored20_824 cored21_826 cored30_828 cored31_830
+  nbl[0]_14 nbl[1]_14 nbl[2]_14 nbl[3]_14 ncored00_832 ncored01_834
+  ncored10_836 ncored11_838 ncored20_840 ncored21_842 ncored30_844
+  ncored31_846 vddc_14 vddce_14 vddpe_14 vnwc_15 vpw_15 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_15 bl[0]_15 bl[1]_15 bl[2]_15 bl[3]_15 cored00_848 cored01_850
+  cored10_852 cored11_854 cored20_856 cored21_858 cored30_860 cored31_862
+  nbl[0]_15 nbl[1]_15 nbl[2]_15 nbl[3]_15 ncored00_864 ncored01_866
+  ncored10_868 ncored11_870 ncored20_872 ncored21_874 ncored30_876
+  ncored31_878 vddc_15 vddce_15 vddpe_15 vnwc_16 vpw_16 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_16 bl[0]_16 bl[1]_16 bl[2]_16 bl[3]_16 cored00_880 cored01_882
+  cored10_884 cored11_886 cored20_888 cored21_890 cored30_892 cored31_894
+  nbl[0]_16 nbl[1]_16 nbl[2]_16 nbl[3]_16 ncored00_896 ncored01_898
+  ncored10_900 ncored11_902 ncored20_904 ncored21_906 ncored30_908
+  ncored31_910 vddc_16 vddce_16 vddpe_16 vnwc_17 vpw_17 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_17 bl[0]_17 bl[1]_17 bl[2]_17 bl[3]_17 cored00_912 cored01_914
+  cored10_916 cored11_918 cored20_920 cored21_922 cored30_924 cored31_926
+  nbl[0]_17 nbl[1]_17 nbl[2]_17 nbl[3]_17 ncored00_928 ncored01_930
+  ncored10_932 ncored11_934 ncored20_936 ncored21_938 ncored30_940
+  ncored31_942 vddc_17 vddce_17 vddpe_17 vnwc_18 vpw_18 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_18 bl[0]_18 bl[1]_18 bl[2]_18 bl[3]_18 cored00_944 cored01_946
+  cored10_948 cored11_950 cored20_952 cored21_954 cored30_956 cored31_958
+  nbl[0]_18 nbl[1]_18 nbl[2]_18 nbl[3]_18 ncored00_960 ncored01_962
+  ncored10_964 ncored11_966 ncored20_968 ncored21_970 ncored30_972
+  ncored31_974 vddc_18 vddce_18 vddpe_18 vnwc_19 vpw_19 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_19 bl[0]_19 bl[1]_19 bl[2]_19 bl[3]_19 cored00_976 cored01_978
+  cored10_980 cored11_982 cored20_984 cored21_986 cored30_988 cored31_990
+  nbl[0]_19 nbl[1]_19 nbl[2]_19 nbl[3]_19 ncored00_992 ncored01_994
+  ncored10_996 ncored11_998 ncored20_1000 ncored21_1002 ncored30_1004
+  ncored31_1006 vddc_19 vddce_19 vddpe_19 vnwc_20 vpw_20 vssc vssc wl[0]
+  wl[1] rf64x128cchs4
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_400 cored01_402
+  cored10_404 cored11_406 cored20_408 cored21_410 cored30_412 cored31_414
+  nbl[0]_2 nbl[1]_2 nbl[2]_2 nbl[3]_2 ncored00_416 ncored01_418 ncored10_420
+  ncored11_422 ncored20_424 ncored21_426 ncored30_428 ncored31_430 vddc_2
+  vddce_2 vddpe_2 vnwc_3 vpw_3 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_20 bl[0]_20 bl[1]_20 bl[2]_20 bl[3]_20 cored00_16 cored01_18
+  cored10_20 cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_20
+  nbl[1]_20 nbl[2]_20 nbl[3]_20 ncored00_32 ncored01_34 ncored10_36
+  ncored11_38 ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_20
+  vddce_20 vddpe_20 vnwc_21 vpw_21 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_21 bl[0]_21 bl[1]_21 bl[2]_21 bl[3]_21 cored00_48 cored01_50
+  cored10_52 cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_21
+  nbl[1]_21 nbl[2]_21 nbl[3]_21 ncored00_64 ncored01_66 ncored10_68
+  ncored11_70 ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_21
+  vddce_21 vddpe_21 vnwc_22 vpw_22 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_22 bl[0]_22 bl[1]_22 bl[2]_22 bl[3]_22 cored00_80 cored01_82
+  cored10_84 cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_22
+  nbl[1]_22 nbl[2]_22 nbl[3]_22 ncored00_96 ncored01_98 ncored10_100
+  ncored11_102 ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_22
+  vddce_22 vddpe_22 vnwc_23 vpw_23 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_23 bl[0]_23 bl[1]_23 bl[2]_23 bl[3]_23 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_23 nbl[1]_23 nbl[2]_23 nbl[3]_23 ncored00_160 ncored01_162
+  ncored10_164 ncored11_166 ncored20_168 ncored21_170 ncored30_172
+  ncored31_174 vddc_23 vddce_23 vddpe_23 vnwc_24 vpw_24 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_24 bl[0]_24 bl[1]_24 bl[2]_24 bl[3]_24 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_24 nbl[1]_24 nbl[2]_24 nbl[3]_24 ncored00_192 ncored01_194
+  ncored10_196 ncored11_198 ncored20_200 ncored21_202 ncored30_204
+  ncored31_206 vddc_24 vddce_24 vddpe_24 vnwc_25 vpw_25 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_25 bl[0]_25 bl[1]_25 bl[2]_25 bl[3]_25 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_25 nbl[1]_25 nbl[2]_25 nbl[3]_25 ncored00_224 ncored01_226
+  ncored10_228 ncored11_230 ncored20_232 ncored21_234 ncored30_236
+  ncored31_238 vddc_25 vddce_25 vddpe_25 vnwc_26 vpw_26 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_26 bl[0]_26 bl[1]_26 bl[2]_26 bl[3]_26 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_26 nbl[1]_26 nbl[2]_26 nbl[3]_26 ncored00_256 ncored01_258
+  ncored10_260 ncored11_262 ncored20_264 ncored21_266 ncored30_268
+  ncored31_270 vddc_26 vddce_26 vddpe_26 vnwc_27 vpw_27 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_27 bl[0]_27 bl[1]_27 bl[2]_27 bl[3]_27 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_27 nbl[1]_27 nbl[2]_27 nbl[3]_27 ncored00_288 ncored01_290
+  ncored10_292 ncored11_294 ncored20_296 ncored21_298 ncored30_300
+  ncored31_302 vddc_27 vddce_27 vddpe_27 vnwc_28 vpw_28 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_28 bl[0]_28 bl[1]_28 bl[2]_28 bl[3]_28 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_28 nbl[1]_28 nbl[2]_28 nbl[3]_28 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_28 vddce_28 vddpe_28 vnwc_29 vpw_29 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_29 bl[0]_29 bl[1]_29 bl[2]_29 bl[3]_29 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_29 nbl[1]_29 nbl[2]_29 nbl[3]_29 ncored00_352 ncored01_354
+  ncored10_356 ncored11_358 ncored20_360 ncored21_362 ncored30_364
+  ncored31_366 vddc_29 vddce_29 vddpe_29 vnwc_30 vpw_30 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_432 cored01_434
+  cored10_436 cored11_438 cored20_440 cored21_442 cored30_444 cored31_446
+  nbl[0]_3 nbl[1]_3 nbl[2]_3 nbl[3]_3 ncored00_448 ncored01_450 ncored10_452
+  ncored11_454 ncored20_456 ncored21_458 ncored30_460 ncored31_462 vddc_3
+  vddce_3 vddpe_3 vnwc_4 vpw_4 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_30 bl[0]_30 bl[1]_30 bl[2]_30 bl[3]_30 cored00_752 cored01_754
+  cored10_756 cored11_758 cored20_760 cored21_762 cored30_764 cored31_766
+  nbl[0]_30 nbl[1]_30 nbl[2]_30 nbl[3]_30 ncored00_768 ncored01_770
+  ncored10_772 ncored11_774 ncored20_776 ncored21_778 ncored30_780
+  ncored31_782 vddc_30 vddce_30 vddpe_30 vnwc_31 vpw_31 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_464 cored01_466
+  cored10_468 cored11_470 cored20_472 cored21_474 cored30_476 cored31_478
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_480 ncored01_482 ncored10_484
+  ncored11_486 ncored20_488 ncored21_490 ncored30_492 ncored31_494 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_496 cored01_498
+  cored10_500 cored11_502 cored20_504 cored21_506 cored30_508 cored31_510
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_512 ncored01_514 ncored10_516
+  ncored11_518 ncored20_520 ncored21_522 ncored30_524 ncored31_526 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_528 cored01_530
+  cored10_532 cored11_534 cored20_536 cored21_538 cored30_540 cored31_542
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_544 ncored01_546 ncored10_548
+  ncored11_550 ncored20_552 ncored21_554 ncored30_556 ncored31_558 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_560 cored01_562
+  cored10_564 cored11_566 cored20_568 cored21_570 cored30_572 cored31_574
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_576 ncored01_578 ncored10_580
+  ncored11_582 ncored20_584 ncored21_586 ncored30_588 ncored31_590 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_592 cored01_594
+  cored10_596 cored11_598 cored20_600 cored21_602 cored30_604 cored31_606
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_608 ncored01_610 ncored10_612
+  ncored11_614 ncored20_616 ncored21_618 ncored30_620 ncored31_622 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_624 cored01_626
+  cored10_628 cored11_630 cored20_632 cored21_634 cored30_636 cored31_638
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_640 ncored01_642 ncored10_644
+  ncored11_646 ncored20_648 ncored21_650 ncored30_652 ncored31_654 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_top_l bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10
+  cored11 cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vsse_0 wl[0] wl[1] rf64x128cchs4
xmem_r_col_top_r bl[0]_31 bl[1]_31 bl[2]_31 bl[3]_31 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_31 nbl[1]_31 nbl[2]_31 nbl[3]_31 ncored00_128 ncored01_130
+  ncored10_132 ncored11_134 ncored20_136 ncored21_138 ncored30_140
+  ncored31_142 vddc_31 vddce_31 vddpe_31 vnwc_32 vpw_32 vssc vsse_1 wl[0]
+  wl[1] rf64x128cchs4
.ends rf64x128mem_r_top_row
****
.subckt rf64x128mem_r_test3row vpw_33 vnwc_33 bl[3]_31 nbl[3]_31 nbl[2]_31
+  bl[2]_31 vnwc_32 vddc_31 bl[3]_30 nbl[3]_30 nbl[2]_30 bl[2]_30 vddpe_30
+  bl[1]_30 nbl[3]_29 nbl[2]_29 bl[2]_29 vddpe_29 bl[1]_29 nbl[3]_28 nbl[2]_28
+  bl[2]_28 vddpe_28 bl[1]_28 nbl[2]_27 bl[2]_27 vddpe_27 bl[1]_27 nbl[2]_26
+  bl[2]_26 vddpe_26 bl[1]_26 bl[0]_26 nbl[3]_25 nbl[2]_25 vnwc_26 vddce_25
+  vddpe_25 bl[1]_25 nbl[1]_25 bl[0]_25 nbl[2]_24 bl[2]_24 vssc vpw_25 vnwc_25
+  vddce_24 vddpe_24 bl[1]_24 nbl[1]_24 nbl[0]_24 bl[0]_24 nbl[3]_23 nbl[2]_23
+  bl[2]_23 vpw_24 vnwc_24 vddce_23 vddpe_23 bl[1]_23 nbl[1]_23 nbl[0]_23
+  bl[0]_23 nbl[2]_22 bl[2]_22 vpw_23 vnwc_23 vddce_22 vddpe_22 bl[1]_22
+  nbl[1]_22 nbl[0]_22 bl[0]_22 nbl[2]_21 bl[2]_21 vpw_22 vnwc_22 vddc_21
+  vddce_21 vddpe_21 bl[1]_21 nbl[1]_21 nbl[0]_21 bl[0]_21 nbl[2]_20 vpw_21
+  vnwc_21 vddc_20 vddce_20 vddpe_20 bl[1]_20 nbl[1]_20 nbl[0]_20 bl[0]_20
+  nbl[2]_19 vpw_20 vnwc_20 vddc_19 vddce_19 vddpe_19 bl[1]_19 nbl[1]_19
+  nbl[0]_19 bl[0]_19 nbl[2]_18 vpw_19 vnwc_19 vddce_18 vddpe_18 bl[1]_18
+  nbl[1]_18 nbl[0]_18 bl[0]_18 nbl[2]_17 bl[2]_17 vpw_18 vnwc_18 vddce_17
+  vddpe_17 bl[1]_17 nbl[1]_17 nbl[0]_17 bl[0]_17 nbl[2]_16 bl[2]_16 vpw_17
+  vnwc_17 vddc_16 vddce_16 vddpe_16 bl[1]_16 nbl[1]_16 nbl[0]_16 bl[0]_16
+  nbl[2]_15 bl[2]_15 vpw_16 vnwc_16 vddc_15 vddce_15 vddpe_15 bl[1]_15
+  nbl[1]_15 nbl[0]_15 bl[0]_15 nbl[2]_14 vpw_15 vnwc_15 vddc_14 vddce_14
+  vddpe_14 bl[1]_14 nbl[1]_14 nbl[0]_14 bl[0]_14 nbl[2]_13 vpw_14 vnwc_14
+  vddc_13 vddce_13 vddpe_13 bl[1]_13 nbl[1]_13 nbl[0]_13 bl[0]_13 vpw_13
+  vnwc_13 vddc_12 vddce_12 vddpe_12 bl[1]_12 nbl[1]_12 nbl[0]_12 bl[0]_12
+  vpw_12 vnwc_12 vddc_11 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11
+  bl[0]_11 nbl[2]_10 bl[2]_10 vpw_11 vnwc_11 vddc_10 vddce_10 vddpe_10
+  bl[1]_10 nbl[1]_10 nbl[0]_10 bl[0]_10 nbl[2]_9 vpw_10 vnwc_10 vddc_9
+  vddce_9 vddpe_9 bl[1]_9 nbl[1]_9 nbl[0]_9 bl[0]_9 nbl[2]_8 vpw_9 vnwc_9
+  vddc_8 vddce_8 vddpe_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 vpw_8 vnwc_8
+  vddc_7 vddce_7 vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 vpw_7 vnwc_7
+  vddc_6 vddce_6 vddpe_6 bl[1]_6 nbl[1]_6 nbl[0]_6 bl[0]_6 bl[3]_5 vpw_6
+  vnwc_6 vddc_5 vddce_5 vddpe_5 bl[1]_5 nbl[1]_5 nbl[0]_5 bl[0]_5 vpw_5
+  vnwc_5 vddc_4 vddce_4 vddpe_4 bl[1]_4 nbl[1]_4 nbl[0]_4 bl[0]_4 nbl[2]_3
+  vpw_4 vnwc_4 vddc_3 vddce_3 vddpe_3 bl[1]_3 nbl[1]_3 nbl[0]_3 bl[0]_3
+  nbl[2]_2 vpw_3 vnwc_3 vddc_2 vddce_2 vddpe_2 bl[1]_2 nbl[1]_2 nbl[0]_2
+  bl[0]_2 vpw_2 vnwc_2 vddc_1 vddce_1 vddpe_1 bl[1]_1 nbl[1]_1 nbl[0]_1
+  bl[0]_1 vpw_1 vnwc_1 vddc_0 vddce_0 vddpe_0 bl[1]_0 nbl[1]_0 nbl[0]_0
+  bl[0]_0 vnwp_0 vnwc_0 vpw_0 vnwp_1 vpw_32 vddce_31 vddpe_31 bl[1]_31
+  nbl[1]_31 nbl[0]_31 bl[0]_31 vpw_31 vnwc_31 vddc_30 vddce_30 nbl[1]_30
+  nbl[0]_30 bl[0]_30 bl[3]_29 vpw_30 vnwc_30 vddc_29 vddce_29 nbl[1]_29
+  nbl[0]_29 bl[0]_29 bl[3]_28 vpw_29 vnwc_29 vddc_28 vddce_28 nbl[1]_28
+  nbl[0]_28 bl[0]_28 bl[3]_27 nbl[3]_27 vpw_28 vnwc_28 vddc_27 vddce_27
+  nbl[1]_27 nbl[0]_27 bl[0]_27 bl[3]_26 nbl[3]_26 vpw_27 vnwc_27 vddc_26
+  vddce_26 nbl[1]_26 nbl[0]_26 bl[3]_25 bl[2]_25 vpw_26 vddc_25 nbl[0]_25
+  bl[3]_24 nbl[3]_24 vddc_24 bl[3]_23 vddc_23 bl[3]_22 nbl[3]_22 vddc_22
+  bl[3]_21 nbl[3]_21 bl[3]_20 nbl[3]_20 bl[2]_20 bl[3]_19 nbl[3]_19 bl[2]_19
+  bl[3]_18 nbl[3]_18 bl[2]_18 vddc_18 bl[3]_17 nbl[3]_17 vddc_17 bl[3]_16
+  nbl[3]_16 bl[3]_15 nbl[3]_15 bl[3]_14 nbl[3]_14 bl[2]_14 bl[3]_13 nbl[3]_13
+  bl[2]_13 bl[3]_12 nbl[3]_12 nbl[2]_12 bl[2]_12 bl[3]_11 nbl[3]_11 nbl[2]_11
+  bl[2]_11 bl[3]_10 nbl[3]_10 bl[3]_9 nbl[3]_9 bl[2]_9 bl[3]_8 nbl[3]_8
+  bl[2]_8 bl[3]_7 nbl[3]_7 nbl[2]_7 bl[2]_7 bl[3]_6 nbl[3]_6 nbl[2]_6 bl[2]_6
+  nbl[3]_5 nbl[2]_5 bl[2]_5 bl[3]_4 nbl[3]_4 nbl[2]_4 bl[2]_4 bl[3]_3
+  nbl[3]_3 bl[2]_3 bl[3]_2 nbl[3]_2 bl[2]_2 bl[3]_1 nbl[3]_1 nbl[2]_1 bl[2]_1
+  bl[3]_0 nbl[3]_0 nbl[2]_0 bl[2]_0 wl[1] wl[0]
** rf64x128mem_r_test3row: 1536 flat devices **
xmem_r_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0 ncored00_320 ncored01_322 ncored10_324
+  ncored11_326 ncored20_328 ncored21_330 ncored30_332 ncored31_334 vddc_0
+  vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_1 nbl[1]_1 nbl[2]_1 nbl[3]_1 ncored00_352 ncored01_354 ncored10_356
+  ncored11_358 ncored20_360 ncored21_362 ncored30_364 ncored31_366 vddc_1
+  vddce_1 vddpe_1 vnwc_2 vpw_2 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_624 cored01_626
+  cored10_628 cored11_630 cored20_632 cored21_634 cored30_636 cored31_638
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_640 ncored01_642
+  ncored10_644 ncored11_646 ncored20_648 ncored21_650 ncored30_652
+  ncored31_654 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_656 cored01_658
+  cored10_660 cored11_662 cored20_664 cored21_666 cored30_668 cored31_670
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_672 ncored01_674
+  ncored10_676 ncored11_678 ncored20_680 ncored21_682 ncored30_684
+  ncored31_686 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_12 bl[0]_12 bl[1]_12 bl[2]_12 bl[3]_12 cored00_688 cored01_690
+  cored10_692 cored11_694 cored20_696 cored21_698 cored30_700 cored31_702
+  nbl[0]_12 nbl[1]_12 nbl[2]_12 nbl[3]_12 ncored00_704 ncored01_706
+  ncored10_708 ncored11_710 ncored20_712 ncored21_714 ncored30_716
+  ncored31_718 vddc_12 vddce_12 vddpe_12 vnwc_13 vpw_13 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_13 bl[0]_13 bl[1]_13 bl[2]_13 bl[3]_13 cored00_752 cored01_754
+  cored10_756 cored11_758 cored20_760 cored21_762 cored30_764 cored31_766
+  nbl[0]_13 nbl[1]_13 nbl[2]_13 nbl[3]_13 ncored00_768 ncored01_770
+  ncored10_772 ncored11_774 ncored20_776 ncored21_778 ncored30_780
+  ncored31_782 vddc_13 vddce_13 vddpe_13 vnwc_14 vpw_14 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_14 bl[0]_14 bl[1]_14 bl[2]_14 bl[3]_14 cored00_816 cored01_818
+  cored10_820 cored11_822 cored20_824 cored21_826 cored30_828 cored31_830
+  nbl[0]_14 nbl[1]_14 nbl[2]_14 nbl[3]_14 ncored00_832 ncored01_834
+  ncored10_836 ncored11_838 ncored20_840 ncored21_842 ncored30_844
+  ncored31_846 vddc_14 vddce_14 vddpe_14 vnwc_15 vpw_15 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_15 bl[0]_15 bl[1]_15 bl[2]_15 bl[3]_15 cored00_848 cored01_850
+  cored10_852 cored11_854 cored20_856 cored21_858 cored30_860 cored31_862
+  nbl[0]_15 nbl[1]_15 nbl[2]_15 nbl[3]_15 ncored00_864 ncored01_866
+  ncored10_868 ncored11_870 ncored20_872 ncored21_874 ncored30_876
+  ncored31_878 vddc_15 vddce_15 vddpe_15 vnwc_16 vpw_16 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_16 bl[0]_16 bl[1]_16 bl[2]_16 bl[3]_16 cored00_880 cored01_882
+  cored10_884 cored11_886 cored20_888 cored21_890 cored30_892 cored31_894
+  nbl[0]_16 nbl[1]_16 nbl[2]_16 nbl[3]_16 ncored00_896 ncored01_898
+  ncored10_900 ncored11_902 ncored20_904 ncored21_906 ncored30_908
+  ncored31_910 vddc_16 vddce_16 vddpe_16 vnwc_17 vpw_17 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_17 bl[0]_17 bl[1]_17 bl[2]_17 bl[3]_17 cored00_912 cored01_914
+  cored10_916 cored11_918 cored20_920 cored21_922 cored30_924 cored31_926
+  nbl[0]_17 nbl[1]_17 nbl[2]_17 nbl[3]_17 ncored00_928 ncored01_930
+  ncored10_932 ncored11_934 ncored20_936 ncored21_938 ncored30_940
+  ncored31_942 vddc_17 vddce_17 vddpe_17 vnwc_18 vpw_18 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_18 bl[0]_18 bl[1]_18 bl[2]_18 bl[3]_18 cored00_944 cored01_946
+  cored10_948 cored11_950 cored20_952 cored21_954 cored30_956 cored31_958
+  nbl[0]_18 nbl[1]_18 nbl[2]_18 nbl[3]_18 ncored00_960 ncored01_962
+  ncored10_964 ncored11_966 ncored20_968 ncored21_970 ncored30_972
+  ncored31_974 vddc_18 vddce_18 vddpe_18 vnwc_19 vpw_19 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_19 bl[0]_19 bl[1]_19 bl[2]_19 bl[3]_19 cored00_976 cored01_978
+  cored10_980 cored11_982 cored20_984 cored21_986 cored30_988 cored31_990
+  nbl[0]_19 nbl[1]_19 nbl[2]_19 nbl[3]_19 ncored00_992 ncored01_994
+  ncored10_996 ncored11_998 ncored20_1000 ncored21_1002 ncored30_1004
+  ncored31_1006 vddc_19 vddce_19 vddpe_19 vnwc_20 vpw_20 vssc vssc wl[0]
+  wl[1] rf64x128cchs4
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_368 cored01_370
+  cored10_372 cored11_374 cored20_376 cored21_378 cored30_380 cored31_382
+  nbl[0]_2 nbl[1]_2 nbl[2]_2 nbl[3]_2 ncored00_384 ncored01_386 ncored10_388
+  ncored11_390 ncored20_392 ncored21_394 ncored30_396 ncored31_398 vddc_2
+  vddce_2 vddpe_2 vnwc_3 vpw_3 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_20 bl[0]_20 bl[1]_20 bl[2]_20 bl[3]_20 cored00 cored01 cored10
+  cored11 cored20 cored21 cored30 cored31 nbl[0]_20 nbl[1]_20 nbl[2]_20
+  nbl[3]_20 ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30
+  ncored31 vddc_20 vddce_20 vddpe_20 vnwc_21 vpw_21 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_21 bl[0]_21 bl[1]_21 bl[2]_21 bl[3]_21 cored00_16 cored01_18
+  cored10_20 cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_21
+  nbl[1]_21 nbl[2]_21 nbl[3]_21 ncored00_32 ncored01_34 ncored10_36
+  ncored11_38 ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_21
+  vddce_21 vddpe_21 vnwc_22 vpw_22 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_22 bl[0]_22 bl[1]_22 bl[2]_22 bl[3]_22 cored00_48 cored01_50
+  cored10_52 cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_22
+  nbl[1]_22 nbl[2]_22 nbl[3]_22 ncored00_64 ncored01_66 ncored10_68
+  ncored11_70 ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_22
+  vddce_22 vddpe_22 vnwc_23 vpw_23 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_23 bl[0]_23 bl[1]_23 bl[2]_23 bl[3]_23 cored00_80 cored01_82
+  cored10_84 cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_23
+  nbl[1]_23 nbl[2]_23 nbl[3]_23 ncored00_96 ncored01_98 ncored10_100
+  ncored11_102 ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_23
+  vddce_23 vddpe_23 vnwc_24 vpw_24 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_24 bl[0]_24 bl[1]_24 bl[2]_24 bl[3]_24 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_24 nbl[1]_24 nbl[2]_24 nbl[3]_24 ncored00_128 ncored01_130
+  ncored10_132 ncored11_134 ncored20_136 ncored21_138 ncored30_140
+  ncored31_142 vddc_24 vddce_24 vddpe_24 vnwc_25 vpw_25 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_25 bl[0]_25 bl[1]_25 bl[2]_25 bl[3]_25 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_25 nbl[1]_25 nbl[2]_25 nbl[3]_25 ncored00_160 ncored01_162
+  ncored10_164 ncored11_166 ncored20_168 ncored21_170 ncored30_172
+  ncored31_174 vddc_25 vddce_25 vddpe_25 vnwc_26 vpw_26 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_26 bl[0]_26 bl[1]_26 bl[2]_26 bl[3]_26 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_26 nbl[1]_26 nbl[2]_26 nbl[3]_26 ncored00_192 ncored01_194
+  ncored10_196 ncored11_198 ncored20_200 ncored21_202 ncored30_204
+  ncored31_206 vddc_26 vddce_26 vddpe_26 vnwc_27 vpw_27 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_27 bl[0]_27 bl[1]_27 bl[2]_27 bl[3]_27 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_27 nbl[1]_27 nbl[2]_27 nbl[3]_27 ncored00_224 ncored01_226
+  ncored10_228 ncored11_230 ncored20_232 ncored21_234 ncored30_236
+  ncored31_238 vddc_27 vddce_27 vddpe_27 vnwc_28 vpw_28 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_28 bl[0]_28 bl[1]_28 bl[2]_28 bl[3]_28 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_28 nbl[1]_28 nbl[2]_28 nbl[3]_28 ncored00_256 ncored01_258
+  ncored10_260 ncored11_262 ncored20_264 ncored21_266 ncored30_268
+  ncored31_270 vddc_28 vddce_28 vddpe_28 vnwc_29 vpw_29 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_29 bl[0]_29 bl[1]_29 bl[2]_29 bl[3]_29 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_29 nbl[1]_29 nbl[2]_29 nbl[3]_29 ncored00_288 ncored01_290
+  ncored10_292 ncored11_294 ncored20_296 ncored21_298 ncored30_300
+  ncored31_302 vddc_29 vddce_29 vddpe_29 vnwc_30 vpw_30 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_400 cored01_402
+  cored10_404 cored11_406 cored20_408 cored21_410 cored30_412 cored31_414
+  nbl[0]_3 nbl[1]_3 nbl[2]_3 nbl[3]_3 ncored00_416 ncored01_418 ncored10_420
+  ncored11_422 ncored20_424 ncored21_426 ncored30_428 ncored31_430 vddc_3
+  vddce_3 vddpe_3 vnwc_4 vpw_4 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_30 bl[0]_30 bl[1]_30 bl[2]_30 bl[3]_30 cored00_720 cored01_722
+  cored10_724 cored11_726 cored20_728 cored21_730 cored30_732 cored31_734
+  nbl[0]_30 nbl[1]_30 nbl[2]_30 nbl[3]_30 ncored00_736 ncored01_738
+  ncored10_740 ncored11_742 ncored20_744 ncored21_746 ncored30_748
+  ncored31_750 vddc_30 vddce_30 vddpe_30 vnwc_31 vpw_31 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_31 bl[0]_31 bl[1]_31 bl[2]_31 bl[3]_31 cored00_784 cored01_786
+  cored10_788 cored11_790 cored20_792 cored21_794 cored30_796 cored31_798
+  nbl[0]_31 nbl[1]_31 nbl[2]_31 nbl[3]_31 ncored00_800 ncored01_802
+  ncored10_804 ncored11_806 ncored20_808 ncored21_810 ncored30_812
+  ncored31_814 vddc_31 vddce_31 vddpe_31 vnwc_32 vpw_32 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_432 cored01_434
+  cored10_436 cored11_438 cored20_440 cored21_442 cored30_444 cored31_446
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_448 ncored01_450 ncored10_452
+  ncored11_454 ncored20_456 ncored21_458 ncored30_460 ncored31_462 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_464 cored01_466
+  cored10_468 cored11_470 cored20_472 cored21_474 cored30_476 cored31_478
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_480 ncored01_482 ncored10_484
+  ncored11_486 ncored20_488 ncored21_490 ncored30_492 ncored31_494 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_496 cored01_498
+  cored10_500 cored11_502 cored20_504 cored21_506 cored30_508 cored31_510
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_512 ncored01_514 ncored10_516
+  ncored11_518 ncored20_520 ncored21_522 ncored30_524 ncored31_526 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_528 cored01_530
+  cored10_532 cored11_534 cored20_536 cored21_538 cored30_540 cored31_542
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_544 ncored01_546 ncored10_548
+  ncored11_550 ncored20_552 ncored21_554 ncored30_556 ncored31_558 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_560 cored01_562
+  cored10_564 cored11_566 cored20_568 cored21_570 cored30_572 cored31_574
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_576 ncored01_578 ncored10_580
+  ncored11_582 ncored20_584 ncored21_586 ncored30_588 ncored31_590 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_592 cored01_594
+  cored10_596 cored11_598 cored20_600 cored21_602 cored30_604 cored31_606
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_608 ncored01_610 ncored10_612
+  ncored11_614 ncored20_616 ncored21_618 ncored30_620 ncored31_622 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] rf64x128cchs4
.ends rf64x128mem_r_test3row
****
.subckt rf64x128mem_r_test4row vpw_33 vnwc_33 bl[3]_31 nbl[3]_31 nbl[2]_31
+  bl[2]_31 vnwc_32 vddc_31 bl[3]_30 nbl[3]_30 nbl[2]_30 bl[2]_30 vddpe_30
+  bl[1]_30 nbl[3]_29 nbl[2]_29 bl[2]_29 vddpe_29 bl[1]_29 nbl[3]_28 nbl[2]_28
+  bl[2]_28 vddpe_28 bl[1]_28 nbl[2]_27 bl[2]_27 vddpe_27 bl[1]_27 nbl[2]_26
+  bl[2]_26 vddpe_26 bl[1]_26 bl[0]_26 nbl[3]_25 nbl[2]_25 vnwc_26 vddce_25
+  vddpe_25 bl[1]_25 nbl[1]_25 bl[0]_25 nbl[2]_24 bl[2]_24 vssc vpw_25 vnwc_25
+  vddce_24 vddpe_24 bl[1]_24 nbl[1]_24 nbl[0]_24 bl[0]_24 nbl[3]_23 nbl[2]_23
+  bl[2]_23 vpw_24 vnwc_24 vddce_23 vddpe_23 bl[1]_23 nbl[1]_23 nbl[0]_23
+  bl[0]_23 nbl[2]_22 bl[2]_22 vpw_23 vnwc_23 vddce_22 vddpe_22 bl[1]_22
+  nbl[1]_22 nbl[0]_22 bl[0]_22 nbl[2]_21 bl[2]_21 vpw_22 vnwc_22 vddc_21
+  vddce_21 vddpe_21 bl[1]_21 nbl[1]_21 nbl[0]_21 bl[0]_21 nbl[2]_20 vpw_21
+  vnwc_21 vddc_20 vddce_20 vddpe_20 bl[1]_20 nbl[1]_20 nbl[0]_20 bl[0]_20
+  nbl[2]_19 vpw_20 vnwc_20 vddc_19 vddce_19 vddpe_19 bl[1]_19 nbl[1]_19
+  nbl[0]_19 bl[0]_19 nbl[2]_18 vpw_19 vnwc_19 vddce_18 vddpe_18 bl[1]_18
+  nbl[1]_18 nbl[0]_18 bl[0]_18 nbl[2]_17 bl[2]_17 vpw_18 vnwc_18 vddce_17
+  vddpe_17 bl[1]_17 nbl[1]_17 nbl[0]_17 bl[0]_17 nbl[2]_16 bl[2]_16 vpw_17
+  vnwc_17 vddc_16 vddce_16 vddpe_16 bl[1]_16 nbl[1]_16 nbl[0]_16 bl[0]_16
+  nbl[2]_15 bl[2]_15 vpw_16 vnwc_16 vddc_15 vddce_15 vddpe_15 bl[1]_15
+  nbl[1]_15 nbl[0]_15 bl[0]_15 nbl[2]_14 vpw_15 vnwc_15 vddc_14 vddce_14
+  vddpe_14 bl[1]_14 nbl[1]_14 nbl[0]_14 bl[0]_14 nbl[2]_13 vpw_14 vnwc_14
+  vddc_13 vddce_13 vddpe_13 bl[1]_13 nbl[1]_13 nbl[0]_13 bl[0]_13 vpw_13
+  vnwc_13 vddc_12 vddce_12 vddpe_12 bl[1]_12 nbl[1]_12 nbl[0]_12 bl[0]_12
+  vpw_12 vnwc_12 vddc_11 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11
+  bl[0]_11 nbl[2]_10 bl[2]_10 vpw_11 vnwc_11 vddc_10 vddce_10 vddpe_10
+  bl[1]_10 nbl[1]_10 nbl[0]_10 bl[0]_10 nbl[2]_9 vpw_10 vnwc_10 vddc_9
+  vddce_9 vddpe_9 bl[1]_9 nbl[1]_9 nbl[0]_9 bl[0]_9 nbl[2]_8 vpw_9 vnwc_9
+  vddc_8 vddce_8 vddpe_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 vpw_8 vnwc_8
+  vddc_7 vddce_7 vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 vpw_7 vnwc_7
+  vddc_6 vddce_6 vddpe_6 bl[1]_6 nbl[1]_6 nbl[0]_6 bl[0]_6 bl[3]_5 vpw_6
+  vnwc_6 vddc_5 vddce_5 vddpe_5 bl[1]_5 nbl[1]_5 nbl[0]_5 bl[0]_5 vpw_5
+  vnwc_5 vddc_4 vddce_4 vddpe_4 bl[1]_4 nbl[1]_4 nbl[0]_4 bl[0]_4 nbl[2]_3
+  vpw_4 vnwc_4 vddc_3 vddce_3 vddpe_3 bl[1]_3 nbl[1]_3 nbl[0]_3 bl[0]_3
+  nbl[2]_2 vpw_3 vnwc_3 vddc_2 vddce_2 vddpe_2 bl[1]_2 nbl[1]_2 nbl[0]_2
+  bl[0]_2 vpw_2 vnwc_2 vddc_1 vddce_1 vddpe_1 bl[1]_1 nbl[1]_1 nbl[0]_1
+  bl[0]_1 vpw_1 vnwc_1 vddc_0 vddce_0 vddpe_0 bl[1]_0 nbl[1]_0 nbl[0]_0
+  bl[0]_0 vnwp_0 vnwc_0 vpw_0 vnwp_1 vpw_32 vddce_31 vddpe_31 bl[1]_31
+  nbl[1]_31 nbl[0]_31 bl[0]_31 vpw_31 vnwc_31 vddc_30 vddce_30 nbl[1]_30
+  nbl[0]_30 bl[0]_30 bl[3]_29 vpw_30 vnwc_30 vddc_29 vddce_29 nbl[1]_29
+  nbl[0]_29 bl[0]_29 bl[3]_28 vpw_29 vnwc_29 vddc_28 vddce_28 nbl[1]_28
+  nbl[0]_28 bl[0]_28 bl[3]_27 nbl[3]_27 vpw_28 vnwc_28 vddc_27 vddce_27
+  nbl[1]_27 nbl[0]_27 bl[0]_27 bl[3]_26 nbl[3]_26 vpw_27 vnwc_27 vddc_26
+  vddce_26 nbl[1]_26 nbl[0]_26 bl[3]_25 bl[2]_25 vpw_26 vddc_25 nbl[0]_25
+  bl[3]_24 nbl[3]_24 vddc_24 bl[3]_23 vddc_23 bl[3]_22 nbl[3]_22 vddc_22
+  bl[3]_21 nbl[3]_21 bl[3]_20 nbl[3]_20 bl[2]_20 bl[3]_19 nbl[3]_19 bl[2]_19
+  bl[3]_18 nbl[3]_18 bl[2]_18 vddc_18 bl[3]_17 nbl[3]_17 vddc_17 bl[3]_16
+  nbl[3]_16 bl[3]_15 nbl[3]_15 bl[3]_14 nbl[3]_14 bl[2]_14 bl[3]_13 nbl[3]_13
+  bl[2]_13 bl[3]_12 nbl[3]_12 nbl[2]_12 bl[2]_12 bl[3]_11 nbl[3]_11 nbl[2]_11
+  bl[2]_11 bl[3]_10 nbl[3]_10 bl[3]_9 nbl[3]_9 bl[2]_9 bl[3]_8 nbl[3]_8
+  bl[2]_8 bl[3]_7 nbl[3]_7 nbl[2]_7 bl[2]_7 bl[3]_6 nbl[3]_6 nbl[2]_6 bl[2]_6
+  nbl[3]_5 nbl[2]_5 bl[2]_5 bl[3]_4 nbl[3]_4 nbl[2]_4 bl[2]_4 bl[3]_3
+  nbl[3]_3 bl[2]_3 bl[3]_2 nbl[3]_2 bl[2]_2 bl[3]_1 nbl[3]_1 nbl[2]_1 bl[2]_1
+  bl[3]_0 nbl[3]_0 nbl[2]_0 bl[2]_0 wl[1] wl[0]
** rf64x128mem_r_test4row: 1536 flat devices **
xmem_r_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0 ncored00_320 ncored01_322 ncored10_324
+  ncored11_326 ncored20_328 ncored21_330 ncored30_332 ncored31_334 vddc_0
+  vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_1 nbl[1]_1 nbl[2]_1 nbl[3]_1 ncored00_352 ncored01_354 ncored10_356
+  ncored11_358 ncored20_360 ncored21_362 ncored30_364 ncored31_366 vddc_1
+  vddce_1 vddpe_1 vnwc_2 vpw_2 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_624 cored01_626
+  cored10_628 cored11_630 cored20_632 cored21_634 cored30_636 cored31_638
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_640 ncored01_642
+  ncored10_644 ncored11_646 ncored20_648 ncored21_650 ncored30_652
+  ncored31_654 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_656 cored01_658
+  cored10_660 cored11_662 cored20_664 cored21_666 cored30_668 cored31_670
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_672 ncored01_674
+  ncored10_676 ncored11_678 ncored20_680 ncored21_682 ncored30_684
+  ncored31_686 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_12 bl[0]_12 bl[1]_12 bl[2]_12 bl[3]_12 cored00_688 cored01_690
+  cored10_692 cored11_694 cored20_696 cored21_698 cored30_700 cored31_702
+  nbl[0]_12 nbl[1]_12 nbl[2]_12 nbl[3]_12 ncored00_704 ncored01_706
+  ncored10_708 ncored11_710 ncored20_712 ncored21_714 ncored30_716
+  ncored31_718 vddc_12 vddce_12 vddpe_12 vnwc_13 vpw_13 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_13 bl[0]_13 bl[1]_13 bl[2]_13 bl[3]_13 cored00_752 cored01_754
+  cored10_756 cored11_758 cored20_760 cored21_762 cored30_764 cored31_766
+  nbl[0]_13 nbl[1]_13 nbl[2]_13 nbl[3]_13 ncored00_768 ncored01_770
+  ncored10_772 ncored11_774 ncored20_776 ncored21_778 ncored30_780
+  ncored31_782 vddc_13 vddce_13 vddpe_13 vnwc_14 vpw_14 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_14 bl[0]_14 bl[1]_14 bl[2]_14 bl[3]_14 cored00_816 cored01_818
+  cored10_820 cored11_822 cored20_824 cored21_826 cored30_828 cored31_830
+  nbl[0]_14 nbl[1]_14 nbl[2]_14 nbl[3]_14 ncored00_832 ncored01_834
+  ncored10_836 ncored11_838 ncored20_840 ncored21_842 ncored30_844
+  ncored31_846 vddc_14 vddce_14 vddpe_14 vnwc_15 vpw_15 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_15 bl[0]_15 bl[1]_15 bl[2]_15 bl[3]_15 cored00_848 cored01_850
+  cored10_852 cored11_854 cored20_856 cored21_858 cored30_860 cored31_862
+  nbl[0]_15 nbl[1]_15 nbl[2]_15 nbl[3]_15 ncored00_864 ncored01_866
+  ncored10_868 ncored11_870 ncored20_872 ncored21_874 ncored30_876
+  ncored31_878 vddc_15 vddce_15 vddpe_15 vnwc_16 vpw_16 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_16 bl[0]_16 bl[1]_16 bl[2]_16 bl[3]_16 cored00_880 cored01_882
+  cored10_884 cored11_886 cored20_888 cored21_890 cored30_892 cored31_894
+  nbl[0]_16 nbl[1]_16 nbl[2]_16 nbl[3]_16 ncored00_896 ncored01_898
+  ncored10_900 ncored11_902 ncored20_904 ncored21_906 ncored30_908
+  ncored31_910 vddc_16 vddce_16 vddpe_16 vnwc_17 vpw_17 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_17 bl[0]_17 bl[1]_17 bl[2]_17 bl[3]_17 cored00_912 cored01_914
+  cored10_916 cored11_918 cored20_920 cored21_922 cored30_924 cored31_926
+  nbl[0]_17 nbl[1]_17 nbl[2]_17 nbl[3]_17 ncored00_928 ncored01_930
+  ncored10_932 ncored11_934 ncored20_936 ncored21_938 ncored30_940
+  ncored31_942 vddc_17 vddce_17 vddpe_17 vnwc_18 vpw_18 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_18 bl[0]_18 bl[1]_18 bl[2]_18 bl[3]_18 cored00_944 cored01_946
+  cored10_948 cored11_950 cored20_952 cored21_954 cored30_956 cored31_958
+  nbl[0]_18 nbl[1]_18 nbl[2]_18 nbl[3]_18 ncored00_960 ncored01_962
+  ncored10_964 ncored11_966 ncored20_968 ncored21_970 ncored30_972
+  ncored31_974 vddc_18 vddce_18 vddpe_18 vnwc_19 vpw_19 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_19 bl[0]_19 bl[1]_19 bl[2]_19 bl[3]_19 cored00_976 cored01_978
+  cored10_980 cored11_982 cored20_984 cored21_986 cored30_988 cored31_990
+  nbl[0]_19 nbl[1]_19 nbl[2]_19 nbl[3]_19 ncored00_992 ncored01_994
+  ncored10_996 ncored11_998 ncored20_1000 ncored21_1002 ncored30_1004
+  ncored31_1006 vddc_19 vddce_19 vddpe_19 vnwc_20 vpw_20 vssc vssc wl[0]
+  wl[1] rf64x128cchs4
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_368 cored01_370
+  cored10_372 cored11_374 cored20_376 cored21_378 cored30_380 cored31_382
+  nbl[0]_2 nbl[1]_2 nbl[2]_2 nbl[3]_2 ncored00_384 ncored01_386 ncored10_388
+  ncored11_390 ncored20_392 ncored21_394 ncored30_396 ncored31_398 vddc_2
+  vddce_2 vddpe_2 vnwc_3 vpw_3 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_20 bl[0]_20 bl[1]_20 bl[2]_20 bl[3]_20 cored00 cored01 cored10
+  cored11 cored20 cored21 cored30 cored31 nbl[0]_20 nbl[1]_20 nbl[2]_20
+  nbl[3]_20 ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30
+  ncored31 vddc_20 vddce_20 vddpe_20 vnwc_21 vpw_21 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_21 bl[0]_21 bl[1]_21 bl[2]_21 bl[3]_21 cored00_16 cored01_18
+  cored10_20 cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_21
+  nbl[1]_21 nbl[2]_21 nbl[3]_21 ncored00_32 ncored01_34 ncored10_36
+  ncored11_38 ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_21
+  vddce_21 vddpe_21 vnwc_22 vpw_22 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_22 bl[0]_22 bl[1]_22 bl[2]_22 bl[3]_22 cored00_48 cored01_50
+  cored10_52 cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_22
+  nbl[1]_22 nbl[2]_22 nbl[3]_22 ncored00_64 ncored01_66 ncored10_68
+  ncored11_70 ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_22
+  vddce_22 vddpe_22 vnwc_23 vpw_23 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_23 bl[0]_23 bl[1]_23 bl[2]_23 bl[3]_23 cored00_80 cored01_82
+  cored10_84 cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_23
+  nbl[1]_23 nbl[2]_23 nbl[3]_23 ncored00_96 ncored01_98 ncored10_100
+  ncored11_102 ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_23
+  vddce_23 vddpe_23 vnwc_24 vpw_24 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_24 bl[0]_24 bl[1]_24 bl[2]_24 bl[3]_24 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_24 nbl[1]_24 nbl[2]_24 nbl[3]_24 ncored00_128 ncored01_130
+  ncored10_132 ncored11_134 ncored20_136 ncored21_138 ncored30_140
+  ncored31_142 vddc_24 vddce_24 vddpe_24 vnwc_25 vpw_25 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_25 bl[0]_25 bl[1]_25 bl[2]_25 bl[3]_25 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_25 nbl[1]_25 nbl[2]_25 nbl[3]_25 ncored00_160 ncored01_162
+  ncored10_164 ncored11_166 ncored20_168 ncored21_170 ncored30_172
+  ncored31_174 vddc_25 vddce_25 vddpe_25 vnwc_26 vpw_26 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_26 bl[0]_26 bl[1]_26 bl[2]_26 bl[3]_26 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_26 nbl[1]_26 nbl[2]_26 nbl[3]_26 ncored00_192 ncored01_194
+  ncored10_196 ncored11_198 ncored20_200 ncored21_202 ncored30_204
+  ncored31_206 vddc_26 vddce_26 vddpe_26 vnwc_27 vpw_27 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_27 bl[0]_27 bl[1]_27 bl[2]_27 bl[3]_27 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_27 nbl[1]_27 nbl[2]_27 nbl[3]_27 ncored00_224 ncored01_226
+  ncored10_228 ncored11_230 ncored20_232 ncored21_234 ncored30_236
+  ncored31_238 vddc_27 vddce_27 vddpe_27 vnwc_28 vpw_28 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_28 bl[0]_28 bl[1]_28 bl[2]_28 bl[3]_28 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_28 nbl[1]_28 nbl[2]_28 nbl[3]_28 ncored00_256 ncored01_258
+  ncored10_260 ncored11_262 ncored20_264 ncored21_266 ncored30_268
+  ncored31_270 vddc_28 vddce_28 vddpe_28 vnwc_29 vpw_29 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_29 bl[0]_29 bl[1]_29 bl[2]_29 bl[3]_29 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_29 nbl[1]_29 nbl[2]_29 nbl[3]_29 ncored00_288 ncored01_290
+  ncored10_292 ncored11_294 ncored20_296 ncored21_298 ncored30_300
+  ncored31_302 vddc_29 vddce_29 vddpe_29 vnwc_30 vpw_30 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_400 cored01_402
+  cored10_404 cored11_406 cored20_408 cored21_410 cored30_412 cored31_414
+  nbl[0]_3 nbl[1]_3 nbl[2]_3 nbl[3]_3 ncored00_416 ncored01_418 ncored10_420
+  ncored11_422 ncored20_424 ncored21_426 ncored30_428 ncored31_430 vddc_3
+  vddce_3 vddpe_3 vnwc_4 vpw_4 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_30 bl[0]_30 bl[1]_30 bl[2]_30 bl[3]_30 cored00_720 cored01_722
+  cored10_724 cored11_726 cored20_728 cored21_730 cored30_732 cored31_734
+  nbl[0]_30 nbl[1]_30 nbl[2]_30 nbl[3]_30 ncored00_736 ncored01_738
+  ncored10_740 ncored11_742 ncored20_744 ncored21_746 ncored30_748
+  ncored31_750 vddc_30 vddce_30 vddpe_30 vnwc_31 vpw_31 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_31 bl[0]_31 bl[1]_31 bl[2]_31 bl[3]_31 cored00_784 cored01_786
+  cored10_788 cored11_790 cored20_792 cored21_794 cored30_796 cored31_798
+  nbl[0]_31 nbl[1]_31 nbl[2]_31 nbl[3]_31 ncored00_800 ncored01_802
+  ncored10_804 ncored11_806 ncored20_808 ncored21_810 ncored30_812
+  ncored31_814 vddc_31 vddce_31 vddpe_31 vnwc_32 vpw_32 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_432 cored01_434
+  cored10_436 cored11_438 cored20_440 cored21_442 cored30_444 cored31_446
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_448 ncored01_450 ncored10_452
+  ncored11_454 ncored20_456 ncored21_458 ncored30_460 ncored31_462 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_464 cored01_466
+  cored10_468 cored11_470 cored20_472 cored21_474 cored30_476 cored31_478
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_480 ncored01_482 ncored10_484
+  ncored11_486 ncored20_488 ncored21_490 ncored30_492 ncored31_494 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_496 cored01_498
+  cored10_500 cored11_502 cored20_504 cored21_506 cored30_508 cored31_510
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_512 ncored01_514 ncored10_516
+  ncored11_518 ncored20_520 ncored21_522 ncored30_524 ncored31_526 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_528 cored01_530
+  cored10_532 cored11_534 cored20_536 cored21_538 cored30_540 cored31_542
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_544 ncored01_546 ncored10_548
+  ncored11_550 ncored20_552 ncored21_554 ncored30_556 ncored31_558 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_560 cored01_562
+  cored10_564 cored11_566 cored20_568 cored21_570 cored30_572 cored31_574
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_576 ncored01_578 ncored10_580
+  ncored11_582 ncored20_584 ncored21_586 ncored30_588 ncored31_590 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_592 cored01_594
+  cored10_596 cored11_598 cored20_600 cored21_602 cored30_604 cored31_606
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_608 ncored01_610 ncored10_612
+  ncored11_614 ncored20_616 ncored21_618 ncored30_620 ncored31_622 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] rf64x128cchs4
.ends rf64x128mem_r_test4row
****
.subckt rf64x128mem_r_test5row vpw_33 vnwc_33 bl[3]_31 nbl[3]_31 nbl[2]_31
+  bl[2]_31 vnwc_32 vddc_31 bl[3]_30 nbl[3]_30 nbl[2]_30 bl[2]_30 vddpe_30
+  bl[1]_30 nbl[3]_29 nbl[2]_29 bl[2]_29 vddpe_29 bl[1]_29 nbl[3]_28 nbl[2]_28
+  bl[2]_28 vddpe_28 bl[1]_28 nbl[2]_27 bl[2]_27 vddpe_27 bl[1]_27 nbl[2]_26
+  bl[2]_26 vddpe_26 bl[1]_26 bl[0]_26 nbl[3]_25 nbl[2]_25 vnwc_26 vddce_25
+  vddpe_25 bl[1]_25 nbl[1]_25 bl[0]_25 nbl[2]_24 bl[2]_24 vssc vpw_25 vnwc_25
+  vddce_24 vddpe_24 bl[1]_24 nbl[1]_24 nbl[0]_24 bl[0]_24 nbl[3]_23 nbl[2]_23
+  bl[2]_23 vpw_24 vnwc_24 vddce_23 vddpe_23 bl[1]_23 nbl[1]_23 nbl[0]_23
+  bl[0]_23 nbl[2]_22 bl[2]_22 vpw_23 vnwc_23 vddce_22 vddpe_22 bl[1]_22
+  nbl[1]_22 nbl[0]_22 bl[0]_22 nbl[2]_21 bl[2]_21 vpw_22 vnwc_22 vddc_21
+  vddce_21 vddpe_21 bl[1]_21 nbl[1]_21 nbl[0]_21 bl[0]_21 nbl[2]_20 vpw_21
+  vnwc_21 vddc_20 vddce_20 vddpe_20 bl[1]_20 nbl[1]_20 nbl[0]_20 bl[0]_20
+  nbl[2]_19 vpw_20 vnwc_20 vddc_19 vddce_19 vddpe_19 bl[1]_19 nbl[1]_19
+  nbl[0]_19 bl[0]_19 nbl[2]_18 vpw_19 vnwc_19 vddce_18 vddpe_18 bl[1]_18
+  nbl[1]_18 nbl[0]_18 bl[0]_18 nbl[2]_17 bl[2]_17 vpw_18 vnwc_18 vddce_17
+  vddpe_17 bl[1]_17 nbl[1]_17 nbl[0]_17 bl[0]_17 nbl[2]_16 bl[2]_16 vpw_17
+  vnwc_17 vddc_16 vddce_16 vddpe_16 bl[1]_16 nbl[1]_16 nbl[0]_16 bl[0]_16
+  nbl[2]_15 bl[2]_15 vpw_16 vnwc_16 vddc_15 vddce_15 vddpe_15 bl[1]_15
+  nbl[1]_15 nbl[0]_15 bl[0]_15 nbl[2]_14 vpw_15 vnwc_15 vddc_14 vddce_14
+  vddpe_14 bl[1]_14 nbl[1]_14 nbl[0]_14 bl[0]_14 nbl[2]_13 vpw_14 vnwc_14
+  vddc_13 vddce_13 vddpe_13 bl[1]_13 nbl[1]_13 nbl[0]_13 bl[0]_13 vpw_13
+  vnwc_13 vddc_12 vddce_12 vddpe_12 bl[1]_12 nbl[1]_12 nbl[0]_12 bl[0]_12
+  vpw_12 vnwc_12 vddc_11 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11
+  bl[0]_11 nbl[2]_10 bl[2]_10 vpw_11 vnwc_11 vddc_10 vddce_10 vddpe_10
+  bl[1]_10 nbl[1]_10 nbl[0]_10 bl[0]_10 nbl[2]_9 vpw_10 vnwc_10 vddc_9
+  vddce_9 vddpe_9 bl[1]_9 nbl[1]_9 nbl[0]_9 bl[0]_9 nbl[2]_8 vpw_9 vnwc_9
+  vddc_8 vddce_8 vddpe_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 vpw_8 vnwc_8
+  vddc_7 vddce_7 vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 vpw_7 vnwc_7
+  vddc_6 vddce_6 vddpe_6 bl[1]_6 nbl[1]_6 nbl[0]_6 bl[0]_6 bl[3]_5 vpw_6
+  vnwc_6 vddc_5 vddce_5 vddpe_5 bl[1]_5 nbl[1]_5 nbl[0]_5 bl[0]_5 vpw_5
+  vnwc_5 vddc_4 vddce_4 vddpe_4 bl[1]_4 nbl[1]_4 nbl[0]_4 bl[0]_4 nbl[2]_3
+  vpw_4 vnwc_4 vddc_3 vddce_3 vddpe_3 bl[1]_3 nbl[1]_3 nbl[0]_3 bl[0]_3
+  nbl[2]_2 vpw_3 vnwc_3 vddc_2 vddce_2 vddpe_2 bl[1]_2 nbl[1]_2 nbl[0]_2
+  bl[0]_2 vpw_2 vnwc_2 vddc_1 vddce_1 vddpe_1 bl[1]_1 nbl[1]_1 nbl[0]_1
+  bl[0]_1 vpw_1 vnwc_1 vddc_0 vddce_0 vddpe_0 bl[1]_0 nbl[1]_0 nbl[0]_0
+  bl[0]_0 vnwp_0 vnwc_0 vpw_0 vnwp_1 vpw_32 vddce_31 vddpe_31 bl[1]_31
+  nbl[1]_31 nbl[0]_31 bl[0]_31 vpw_31 vnwc_31 vddc_30 vddce_30 nbl[1]_30
+  nbl[0]_30 bl[0]_30 bl[3]_29 vpw_30 vnwc_30 vddc_29 vddce_29 nbl[1]_29
+  nbl[0]_29 bl[0]_29 bl[3]_28 vpw_29 vnwc_29 vddc_28 vddce_28 nbl[1]_28
+  nbl[0]_28 bl[0]_28 bl[3]_27 nbl[3]_27 vpw_28 vnwc_28 vddc_27 vddce_27
+  nbl[1]_27 nbl[0]_27 bl[0]_27 bl[3]_26 nbl[3]_26 vpw_27 vnwc_27 vddc_26
+  vddce_26 nbl[1]_26 nbl[0]_26 bl[3]_25 bl[2]_25 vpw_26 vddc_25 nbl[0]_25
+  bl[3]_24 nbl[3]_24 vddc_24 bl[3]_23 vddc_23 bl[3]_22 nbl[3]_22 vddc_22
+  bl[3]_21 nbl[3]_21 bl[3]_20 nbl[3]_20 bl[2]_20 bl[3]_19 nbl[3]_19 bl[2]_19
+  bl[3]_18 nbl[3]_18 bl[2]_18 vddc_18 bl[3]_17 nbl[3]_17 vddc_17 bl[3]_16
+  nbl[3]_16 bl[3]_15 nbl[3]_15 bl[3]_14 nbl[3]_14 bl[2]_14 bl[3]_13 nbl[3]_13
+  bl[2]_13 bl[3]_12 nbl[3]_12 nbl[2]_12 bl[2]_12 bl[3]_11 nbl[3]_11 nbl[2]_11
+  bl[2]_11 bl[3]_10 nbl[3]_10 bl[3]_9 nbl[3]_9 bl[2]_9 bl[3]_8 nbl[3]_8
+  bl[2]_8 bl[3]_7 nbl[3]_7 nbl[2]_7 bl[2]_7 bl[3]_6 nbl[3]_6 nbl[2]_6 bl[2]_6
+  nbl[3]_5 nbl[2]_5 bl[2]_5 bl[3]_4 nbl[3]_4 nbl[2]_4 bl[2]_4 bl[3]_3
+  nbl[3]_3 bl[2]_3 bl[3]_2 nbl[3]_2 bl[2]_2 bl[3]_1 nbl[3]_1 nbl[2]_1 bl[2]_1
+  bl[3]_0 nbl[3]_0 nbl[2]_0 bl[2]_0 wl[1] wl[0]
** rf64x128mem_r_test5row: 1536 flat devices **
xmem_r_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0 ncored00_320 ncored01_322 ncored10_324
+  ncored11_326 ncored20_328 ncored21_330 ncored30_332 ncored31_334 vddc_0
+  vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_1 nbl[1]_1 nbl[2]_1 nbl[3]_1 ncored00_352 ncored01_354 ncored10_356
+  ncored11_358 ncored20_360 ncored21_362 ncored30_364 ncored31_366 vddc_1
+  vddce_1 vddpe_1 vnwc_2 vpw_2 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_624 cored01_626
+  cored10_628 cored11_630 cored20_632 cored21_634 cored30_636 cored31_638
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_640 ncored01_642
+  ncored10_644 ncored11_646 ncored20_648 ncored21_650 ncored30_652
+  ncored31_654 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_656 cored01_658
+  cored10_660 cored11_662 cored20_664 cored21_666 cored30_668 cored31_670
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_672 ncored01_674
+  ncored10_676 ncored11_678 ncored20_680 ncored21_682 ncored30_684
+  ncored31_686 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_12 bl[0]_12 bl[1]_12 bl[2]_12 bl[3]_12 cored00_688 cored01_690
+  cored10_692 cored11_694 cored20_696 cored21_698 cored30_700 cored31_702
+  nbl[0]_12 nbl[1]_12 nbl[2]_12 nbl[3]_12 ncored00_704 ncored01_706
+  ncored10_708 ncored11_710 ncored20_712 ncored21_714 ncored30_716
+  ncored31_718 vddc_12 vddce_12 vddpe_12 vnwc_13 vpw_13 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_13 bl[0]_13 bl[1]_13 bl[2]_13 bl[3]_13 cored00_752 cored01_754
+  cored10_756 cored11_758 cored20_760 cored21_762 cored30_764 cored31_766
+  nbl[0]_13 nbl[1]_13 nbl[2]_13 nbl[3]_13 ncored00_768 ncored01_770
+  ncored10_772 ncored11_774 ncored20_776 ncored21_778 ncored30_780
+  ncored31_782 vddc_13 vddce_13 vddpe_13 vnwc_14 vpw_14 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_14 bl[0]_14 bl[1]_14 bl[2]_14 bl[3]_14 cored00_816 cored01_818
+  cored10_820 cored11_822 cored20_824 cored21_826 cored30_828 cored31_830
+  nbl[0]_14 nbl[1]_14 nbl[2]_14 nbl[3]_14 ncored00_832 ncored01_834
+  ncored10_836 ncored11_838 ncored20_840 ncored21_842 ncored30_844
+  ncored31_846 vddc_14 vddce_14 vddpe_14 vnwc_15 vpw_15 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_15 bl[0]_15 bl[1]_15 bl[2]_15 bl[3]_15 cored00_848 cored01_850
+  cored10_852 cored11_854 cored20_856 cored21_858 cored30_860 cored31_862
+  nbl[0]_15 nbl[1]_15 nbl[2]_15 nbl[3]_15 ncored00_864 ncored01_866
+  ncored10_868 ncored11_870 ncored20_872 ncored21_874 ncored30_876
+  ncored31_878 vddc_15 vddce_15 vddpe_15 vnwc_16 vpw_16 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_16 bl[0]_16 bl[1]_16 bl[2]_16 bl[3]_16 cored00_880 cored01_882
+  cored10_884 cored11_886 cored20_888 cored21_890 cored30_892 cored31_894
+  nbl[0]_16 nbl[1]_16 nbl[2]_16 nbl[3]_16 ncored00_896 ncored01_898
+  ncored10_900 ncored11_902 ncored20_904 ncored21_906 ncored30_908
+  ncored31_910 vddc_16 vddce_16 vddpe_16 vnwc_17 vpw_17 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_17 bl[0]_17 bl[1]_17 bl[2]_17 bl[3]_17 cored00_912 cored01_914
+  cored10_916 cored11_918 cored20_920 cored21_922 cored30_924 cored31_926
+  nbl[0]_17 nbl[1]_17 nbl[2]_17 nbl[3]_17 ncored00_928 ncored01_930
+  ncored10_932 ncored11_934 ncored20_936 ncored21_938 ncored30_940
+  ncored31_942 vddc_17 vddce_17 vddpe_17 vnwc_18 vpw_18 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_18 bl[0]_18 bl[1]_18 bl[2]_18 bl[3]_18 cored00_944 cored01_946
+  cored10_948 cored11_950 cored20_952 cored21_954 cored30_956 cored31_958
+  nbl[0]_18 nbl[1]_18 nbl[2]_18 nbl[3]_18 ncored00_960 ncored01_962
+  ncored10_964 ncored11_966 ncored20_968 ncored21_970 ncored30_972
+  ncored31_974 vddc_18 vddce_18 vddpe_18 vnwc_19 vpw_19 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_19 bl[0]_19 bl[1]_19 bl[2]_19 bl[3]_19 cored00_976 cored01_978
+  cored10_980 cored11_982 cored20_984 cored21_986 cored30_988 cored31_990
+  nbl[0]_19 nbl[1]_19 nbl[2]_19 nbl[3]_19 ncored00_992 ncored01_994
+  ncored10_996 ncored11_998 ncored20_1000 ncored21_1002 ncored30_1004
+  ncored31_1006 vddc_19 vddce_19 vddpe_19 vnwc_20 vpw_20 vssc vssc wl[0]
+  wl[1] rf64x128cchs4
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_368 cored01_370
+  cored10_372 cored11_374 cored20_376 cored21_378 cored30_380 cored31_382
+  nbl[0]_2 nbl[1]_2 nbl[2]_2 nbl[3]_2 ncored00_384 ncored01_386 ncored10_388
+  ncored11_390 ncored20_392 ncored21_394 ncored30_396 ncored31_398 vddc_2
+  vddce_2 vddpe_2 vnwc_3 vpw_3 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_20 bl[0]_20 bl[1]_20 bl[2]_20 bl[3]_20 cored00 cored01 cored10
+  cored11 cored20 cored21 cored30 cored31 nbl[0]_20 nbl[1]_20 nbl[2]_20
+  nbl[3]_20 ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30
+  ncored31 vddc_20 vddce_20 vddpe_20 vnwc_21 vpw_21 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_21 bl[0]_21 bl[1]_21 bl[2]_21 bl[3]_21 cored00_16 cored01_18
+  cored10_20 cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_21
+  nbl[1]_21 nbl[2]_21 nbl[3]_21 ncored00_32 ncored01_34 ncored10_36
+  ncored11_38 ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_21
+  vddce_21 vddpe_21 vnwc_22 vpw_22 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_22 bl[0]_22 bl[1]_22 bl[2]_22 bl[3]_22 cored00_48 cored01_50
+  cored10_52 cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_22
+  nbl[1]_22 nbl[2]_22 nbl[3]_22 ncored00_64 ncored01_66 ncored10_68
+  ncored11_70 ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_22
+  vddce_22 vddpe_22 vnwc_23 vpw_23 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_23 bl[0]_23 bl[1]_23 bl[2]_23 bl[3]_23 cored00_80 cored01_82
+  cored10_84 cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_23
+  nbl[1]_23 nbl[2]_23 nbl[3]_23 ncored00_96 ncored01_98 ncored10_100
+  ncored11_102 ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_23
+  vddce_23 vddpe_23 vnwc_24 vpw_24 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_24 bl[0]_24 bl[1]_24 bl[2]_24 bl[3]_24 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_24 nbl[1]_24 nbl[2]_24 nbl[3]_24 ncored00_128 ncored01_130
+  ncored10_132 ncored11_134 ncored20_136 ncored21_138 ncored30_140
+  ncored31_142 vddc_24 vddce_24 vddpe_24 vnwc_25 vpw_25 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_25 bl[0]_25 bl[1]_25 bl[2]_25 bl[3]_25 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_25 nbl[1]_25 nbl[2]_25 nbl[3]_25 ncored00_160 ncored01_162
+  ncored10_164 ncored11_166 ncored20_168 ncored21_170 ncored30_172
+  ncored31_174 vddc_25 vddce_25 vddpe_25 vnwc_26 vpw_26 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_26 bl[0]_26 bl[1]_26 bl[2]_26 bl[3]_26 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_26 nbl[1]_26 nbl[2]_26 nbl[3]_26 ncored00_192 ncored01_194
+  ncored10_196 ncored11_198 ncored20_200 ncored21_202 ncored30_204
+  ncored31_206 vddc_26 vddce_26 vddpe_26 vnwc_27 vpw_27 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_27 bl[0]_27 bl[1]_27 bl[2]_27 bl[3]_27 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_27 nbl[1]_27 nbl[2]_27 nbl[3]_27 ncored00_224 ncored01_226
+  ncored10_228 ncored11_230 ncored20_232 ncored21_234 ncored30_236
+  ncored31_238 vddc_27 vddce_27 vddpe_27 vnwc_28 vpw_28 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_28 bl[0]_28 bl[1]_28 bl[2]_28 bl[3]_28 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_28 nbl[1]_28 nbl[2]_28 nbl[3]_28 ncored00_256 ncored01_258
+  ncored10_260 ncored11_262 ncored20_264 ncored21_266 ncored30_268
+  ncored31_270 vddc_28 vddce_28 vddpe_28 vnwc_29 vpw_29 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_29 bl[0]_29 bl[1]_29 bl[2]_29 bl[3]_29 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_29 nbl[1]_29 nbl[2]_29 nbl[3]_29 ncored00_288 ncored01_290
+  ncored10_292 ncored11_294 ncored20_296 ncored21_298 ncored30_300
+  ncored31_302 vddc_29 vddce_29 vddpe_29 vnwc_30 vpw_30 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_400 cored01_402
+  cored10_404 cored11_406 cored20_408 cored21_410 cored30_412 cored31_414
+  nbl[0]_3 nbl[1]_3 nbl[2]_3 nbl[3]_3 ncored00_416 ncored01_418 ncored10_420
+  ncored11_422 ncored20_424 ncored21_426 ncored30_428 ncored31_430 vddc_3
+  vddce_3 vddpe_3 vnwc_4 vpw_4 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_30 bl[0]_30 bl[1]_30 bl[2]_30 bl[3]_30 cored00_720 cored01_722
+  cored10_724 cored11_726 cored20_728 cored21_730 cored30_732 cored31_734
+  nbl[0]_30 nbl[1]_30 nbl[2]_30 nbl[3]_30 ncored00_736 ncored01_738
+  ncored10_740 ncored11_742 ncored20_744 ncored21_746 ncored30_748
+  ncored31_750 vddc_30 vddce_30 vddpe_30 vnwc_31 vpw_31 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_31 bl[0]_31 bl[1]_31 bl[2]_31 bl[3]_31 cored00_784 cored01_786
+  cored10_788 cored11_790 cored20_792 cored21_794 cored30_796 cored31_798
+  nbl[0]_31 nbl[1]_31 nbl[2]_31 nbl[3]_31 ncored00_800 ncored01_802
+  ncored10_804 ncored11_806 ncored20_808 ncored21_810 ncored30_812
+  ncored31_814 vddc_31 vddce_31 vddpe_31 vnwc_32 vpw_32 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_432 cored01_434
+  cored10_436 cored11_438 cored20_440 cored21_442 cored30_444 cored31_446
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_448 ncored01_450 ncored10_452
+  ncored11_454 ncored20_456 ncored21_458 ncored30_460 ncored31_462 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_464 cored01_466
+  cored10_468 cored11_470 cored20_472 cored21_474 cored30_476 cored31_478
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_480 ncored01_482 ncored10_484
+  ncored11_486 ncored20_488 ncored21_490 ncored30_492 ncored31_494 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_496 cored01_498
+  cored10_500 cored11_502 cored20_504 cored21_506 cored30_508 cored31_510
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_512 ncored01_514 ncored10_516
+  ncored11_518 ncored20_520 ncored21_522 ncored30_524 ncored31_526 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_528 cored01_530
+  cored10_532 cored11_534 cored20_536 cored21_538 cored30_540 cored31_542
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_544 ncored01_546 ncored10_548
+  ncored11_550 ncored20_552 ncored21_554 ncored30_556 ncored31_558 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_560 cored01_562
+  cored10_564 cored11_566 cored20_568 cored21_570 cored30_572 cored31_574
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_576 ncored01_578 ncored10_580
+  ncored11_582 ncored20_584 ncored21_586 ncored30_588 ncored31_590 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_592 cored01_594
+  cored10_596 cored11_598 cored20_600 cored21_602 cored30_604 cored31_606
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_608 ncored01_610 ncored10_612
+  ncored11_614 ncored20_616 ncored21_618 ncored30_620 ncored31_622 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] rf64x128cchs4
.ends rf64x128mem_r_test5row
****
.subckt rf64x128mem_r_test9row vpw_33 vnwc_33 bl[3]_31 nbl[3]_31 nbl[2]_31
+  bl[2]_31 vnwc_32 vddc_31 bl[3]_30 nbl[3]_30 nbl[2]_30 bl[2]_30 vddpe_30
+  bl[1]_30 nbl[3]_29 nbl[2]_29 bl[2]_29 vddpe_29 bl[1]_29 nbl[3]_28 nbl[2]_28
+  bl[2]_28 vddpe_28 bl[1]_28 nbl[2]_27 bl[2]_27 vddpe_27 bl[1]_27 nbl[2]_26
+  bl[2]_26 vddpe_26 bl[1]_26 bl[0]_26 nbl[3]_25 nbl[2]_25 vnwc_26 vddce_25
+  vddpe_25 bl[1]_25 nbl[1]_25 bl[0]_25 nbl[2]_24 bl[2]_24 vssc vpw_25 vnwc_25
+  vddce_24 vddpe_24 bl[1]_24 nbl[1]_24 nbl[0]_24 bl[0]_24 nbl[3]_23 nbl[2]_23
+  bl[2]_23 vpw_24 vnwc_24 vddce_23 vddpe_23 bl[1]_23 nbl[1]_23 nbl[0]_23
+  bl[0]_23 nbl[2]_22 bl[2]_22 vpw_23 vnwc_23 vddce_22 vddpe_22 bl[1]_22
+  nbl[1]_22 nbl[0]_22 bl[0]_22 nbl[2]_21 bl[2]_21 vpw_22 vnwc_22 vddc_21
+  vddce_21 vddpe_21 bl[1]_21 nbl[1]_21 nbl[0]_21 bl[0]_21 nbl[2]_20 vpw_21
+  vnwc_21 vddc_20 vddce_20 vddpe_20 bl[1]_20 nbl[1]_20 nbl[0]_20 bl[0]_20
+  nbl[2]_19 vpw_20 vnwc_20 vddc_19 vddce_19 vddpe_19 bl[1]_19 nbl[1]_19
+  nbl[0]_19 bl[0]_19 nbl[2]_18 vpw_19 vnwc_19 vddce_18 vddpe_18 bl[1]_18
+  nbl[1]_18 nbl[0]_18 bl[0]_18 nbl[2]_17 bl[2]_17 vpw_18 vnwc_18 vddce_17
+  vddpe_17 bl[1]_17 nbl[1]_17 nbl[0]_17 bl[0]_17 nbl[2]_16 bl[2]_16 vpw_17
+  vnwc_17 vddc_16 vddce_16 vddpe_16 bl[1]_16 nbl[1]_16 nbl[0]_16 bl[0]_16
+  nbl[2]_15 bl[2]_15 vpw_16 vnwc_16 vddc_15 vddce_15 vddpe_15 bl[1]_15
+  nbl[1]_15 nbl[0]_15 bl[0]_15 nbl[2]_14 vpw_15 vnwc_15 vddc_14 vddce_14
+  vddpe_14 bl[1]_14 nbl[1]_14 nbl[0]_14 bl[0]_14 nbl[2]_13 vpw_14 vnwc_14
+  vddc_13 vddce_13 vddpe_13 bl[1]_13 nbl[1]_13 nbl[0]_13 bl[0]_13 vpw_13
+  vnwc_13 vddc_12 vddce_12 vddpe_12 bl[1]_12 nbl[1]_12 nbl[0]_12 bl[0]_12
+  vpw_12 vnwc_12 vddc_11 vddce_11 vddpe_11 bl[1]_11 nbl[1]_11 nbl[0]_11
+  bl[0]_11 nbl[2]_10 bl[2]_10 vpw_11 vnwc_11 vddc_10 vddce_10 vddpe_10
+  bl[1]_10 nbl[1]_10 nbl[0]_10 bl[0]_10 nbl[2]_9 vpw_10 vnwc_10 vddc_9
+  vddce_9 vddpe_9 bl[1]_9 nbl[1]_9 nbl[0]_9 bl[0]_9 nbl[2]_8 vpw_9 vnwc_9
+  vddc_8 vddce_8 vddpe_8 bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 vpw_8 vnwc_8
+  vddc_7 vddce_7 vddpe_7 bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 vpw_7 vnwc_7
+  vddc_6 vddce_6 vddpe_6 bl[1]_6 nbl[1]_6 nbl[0]_6 bl[0]_6 bl[3]_5 vpw_6
+  vnwc_6 vddc_5 vddce_5 vddpe_5 bl[1]_5 nbl[1]_5 nbl[0]_5 bl[0]_5 vpw_5
+  vnwc_5 vddc_4 vddce_4 vddpe_4 bl[1]_4 nbl[1]_4 nbl[0]_4 bl[0]_4 nbl[2]_3
+  vpw_4 vnwc_4 vddc_3 vddce_3 vddpe_3 bl[1]_3 nbl[1]_3 nbl[0]_3 bl[0]_3
+  nbl[2]_2 vpw_3 vnwc_3 vddc_2 vddce_2 vddpe_2 bl[1]_2 nbl[1]_2 nbl[0]_2
+  bl[0]_2 vpw_2 vnwc_2 vddc_1 vddce_1 vddpe_1 bl[1]_1 nbl[1]_1 nbl[0]_1
+  bl[0]_1 vpw_1 vnwc_1 vddc_0 vddce_0 vddpe_0 bl[1]_0 nbl[1]_0 nbl[0]_0
+  bl[0]_0 vnwp_0 vnwc_0 vpw_0 vnwp_1 vpw_32 vddce_31 vddpe_31 bl[1]_31
+  nbl[1]_31 nbl[0]_31 bl[0]_31 vpw_31 vnwc_31 vddc_30 vddce_30 nbl[1]_30
+  nbl[0]_30 bl[0]_30 bl[3]_29 vpw_30 vnwc_30 vddc_29 vddce_29 nbl[1]_29
+  nbl[0]_29 bl[0]_29 bl[3]_28 vpw_29 vnwc_29 vddc_28 vddce_28 nbl[1]_28
+  nbl[0]_28 bl[0]_28 bl[3]_27 nbl[3]_27 vpw_28 vnwc_28 vddc_27 vddce_27
+  nbl[1]_27 nbl[0]_27 bl[0]_27 bl[3]_26 nbl[3]_26 vpw_27 vnwc_27 vddc_26
+  vddce_26 nbl[1]_26 nbl[0]_26 bl[3]_25 bl[2]_25 vpw_26 vddc_25 nbl[0]_25
+  bl[3]_24 nbl[3]_24 vddc_24 bl[3]_23 vddc_23 bl[3]_22 nbl[3]_22 vddc_22
+  bl[3]_21 nbl[3]_21 bl[3]_20 nbl[3]_20 bl[2]_20 bl[3]_19 nbl[3]_19 bl[2]_19
+  bl[3]_18 nbl[3]_18 bl[2]_18 vddc_18 bl[3]_17 nbl[3]_17 vddc_17 bl[3]_16
+  nbl[3]_16 bl[3]_15 nbl[3]_15 bl[3]_14 nbl[3]_14 bl[2]_14 bl[3]_13 nbl[3]_13
+  bl[2]_13 bl[3]_12 nbl[3]_12 nbl[2]_12 bl[2]_12 bl[3]_11 nbl[3]_11 nbl[2]_11
+  bl[2]_11 bl[3]_10 nbl[3]_10 bl[3]_9 nbl[3]_9 bl[2]_9 bl[3]_8 nbl[3]_8
+  bl[2]_8 bl[3]_7 nbl[3]_7 nbl[2]_7 bl[2]_7 bl[3]_6 nbl[3]_6 nbl[2]_6 bl[2]_6
+  nbl[3]_5 nbl[2]_5 bl[2]_5 bl[3]_4 nbl[3]_4 nbl[2]_4 bl[2]_4 bl[3]_3
+  nbl[3]_3 bl[2]_3 bl[3]_2 nbl[3]_2 bl[2]_2 bl[3]_1 nbl[3]_1 nbl[2]_1 bl[2]_1
+  bl[3]_0 nbl[3]_0 nbl[2]_0 bl[2]_0 wl[1] wl[0]
** rf64x128mem_r_test9row: 1536 flat devices **
xmem_r_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0 ncored00_320 ncored01_322 ncored10_324
+  ncored11_326 ncored20_328 ncored21_330 ncored30_332 ncored31_334 vddc_0
+  vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_1 nbl[1]_1 nbl[2]_1 nbl[3]_1 ncored00_352 ncored01_354 ncored10_356
+  ncored11_358 ncored20_360 ncored21_362 ncored30_364 ncored31_366 vddc_1
+  vddce_1 vddpe_1 vnwc_2 vpw_2 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_624 cored01_626
+  cored10_628 cored11_630 cored20_632 cored21_634 cored30_636 cored31_638
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_640 ncored01_642
+  ncored10_644 ncored11_646 ncored20_648 ncored21_650 ncored30_652
+  ncored31_654 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_656 cored01_658
+  cored10_660 cored11_662 cored20_664 cored21_666 cored30_668 cored31_670
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_672 ncored01_674
+  ncored10_676 ncored11_678 ncored20_680 ncored21_682 ncored30_684
+  ncored31_686 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_12 bl[0]_12 bl[1]_12 bl[2]_12 bl[3]_12 cored00_688 cored01_690
+  cored10_692 cored11_694 cored20_696 cored21_698 cored30_700 cored31_702
+  nbl[0]_12 nbl[1]_12 nbl[2]_12 nbl[3]_12 ncored00_704 ncored01_706
+  ncored10_708 ncored11_710 ncored20_712 ncored21_714 ncored30_716
+  ncored31_718 vddc_12 vddce_12 vddpe_12 vnwc_13 vpw_13 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_13 bl[0]_13 bl[1]_13 bl[2]_13 bl[3]_13 cored00_752 cored01_754
+  cored10_756 cored11_758 cored20_760 cored21_762 cored30_764 cored31_766
+  nbl[0]_13 nbl[1]_13 nbl[2]_13 nbl[3]_13 ncored00_768 ncored01_770
+  ncored10_772 ncored11_774 ncored20_776 ncored21_778 ncored30_780
+  ncored31_782 vddc_13 vddce_13 vddpe_13 vnwc_14 vpw_14 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_14 bl[0]_14 bl[1]_14 bl[2]_14 bl[3]_14 cored00_816 cored01_818
+  cored10_820 cored11_822 cored20_824 cored21_826 cored30_828 cored31_830
+  nbl[0]_14 nbl[1]_14 nbl[2]_14 nbl[3]_14 ncored00_832 ncored01_834
+  ncored10_836 ncored11_838 ncored20_840 ncored21_842 ncored30_844
+  ncored31_846 vddc_14 vddce_14 vddpe_14 vnwc_15 vpw_15 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_15 bl[0]_15 bl[1]_15 bl[2]_15 bl[3]_15 cored00_848 cored01_850
+  cored10_852 cored11_854 cored20_856 cored21_858 cored30_860 cored31_862
+  nbl[0]_15 nbl[1]_15 nbl[2]_15 nbl[3]_15 ncored00_864 ncored01_866
+  ncored10_868 ncored11_870 ncored20_872 ncored21_874 ncored30_876
+  ncored31_878 vddc_15 vddce_15 vddpe_15 vnwc_16 vpw_16 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_16 bl[0]_16 bl[1]_16 bl[2]_16 bl[3]_16 cored00_880 cored01_882
+  cored10_884 cored11_886 cored20_888 cored21_890 cored30_892 cored31_894
+  nbl[0]_16 nbl[1]_16 nbl[2]_16 nbl[3]_16 ncored00_896 ncored01_898
+  ncored10_900 ncored11_902 ncored20_904 ncored21_906 ncored30_908
+  ncored31_910 vddc_16 vddce_16 vddpe_16 vnwc_17 vpw_17 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_17 bl[0]_17 bl[1]_17 bl[2]_17 bl[3]_17 cored00_912 cored01_914
+  cored10_916 cored11_918 cored20_920 cored21_922 cored30_924 cored31_926
+  nbl[0]_17 nbl[1]_17 nbl[2]_17 nbl[3]_17 ncored00_928 ncored01_930
+  ncored10_932 ncored11_934 ncored20_936 ncored21_938 ncored30_940
+  ncored31_942 vddc_17 vddce_17 vddpe_17 vnwc_18 vpw_18 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_18 bl[0]_18 bl[1]_18 bl[2]_18 bl[3]_18 cored00_944 cored01_946
+  cored10_948 cored11_950 cored20_952 cored21_954 cored30_956 cored31_958
+  nbl[0]_18 nbl[1]_18 nbl[2]_18 nbl[3]_18 ncored00_960 ncored01_962
+  ncored10_964 ncored11_966 ncored20_968 ncored21_970 ncored30_972
+  ncored31_974 vddc_18 vddce_18 vddpe_18 vnwc_19 vpw_19 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_19 bl[0]_19 bl[1]_19 bl[2]_19 bl[3]_19 cored00_976 cored01_978
+  cored10_980 cored11_982 cored20_984 cored21_986 cored30_988 cored31_990
+  nbl[0]_19 nbl[1]_19 nbl[2]_19 nbl[3]_19 ncored00_992 ncored01_994
+  ncored10_996 ncored11_998 ncored20_1000 ncored21_1002 ncored30_1004
+  ncored31_1006 vddc_19 vddce_19 vddpe_19 vnwc_20 vpw_20 vssc vssc wl[0]
+  wl[1] rf64x128cchs4
xmem_r_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_368 cored01_370
+  cored10_372 cored11_374 cored20_376 cored21_378 cored30_380 cored31_382
+  nbl[0]_2 nbl[1]_2 nbl[2]_2 nbl[3]_2 ncored00_384 ncored01_386 ncored10_388
+  ncored11_390 ncored20_392 ncored21_394 ncored30_396 ncored31_398 vddc_2
+  vddce_2 vddpe_2 vnwc_3 vpw_3 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_20 bl[0]_20 bl[1]_20 bl[2]_20 bl[3]_20 cored00 cored01 cored10
+  cored11 cored20 cored21 cored30 cored31 nbl[0]_20 nbl[1]_20 nbl[2]_20
+  nbl[3]_20 ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30
+  ncored31 vddc_20 vddce_20 vddpe_20 vnwc_21 vpw_21 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_21 bl[0]_21 bl[1]_21 bl[2]_21 bl[3]_21 cored00_16 cored01_18
+  cored10_20 cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_21
+  nbl[1]_21 nbl[2]_21 nbl[3]_21 ncored00_32 ncored01_34 ncored10_36
+  ncored11_38 ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_21
+  vddce_21 vddpe_21 vnwc_22 vpw_22 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_22 bl[0]_22 bl[1]_22 bl[2]_22 bl[3]_22 cored00_48 cored01_50
+  cored10_52 cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_22
+  nbl[1]_22 nbl[2]_22 nbl[3]_22 ncored00_64 ncored01_66 ncored10_68
+  ncored11_70 ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_22
+  vddce_22 vddpe_22 vnwc_23 vpw_23 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_23 bl[0]_23 bl[1]_23 bl[2]_23 bl[3]_23 cored00_80 cored01_82
+  cored10_84 cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_23
+  nbl[1]_23 nbl[2]_23 nbl[3]_23 ncored00_96 ncored01_98 ncored10_100
+  ncored11_102 ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_23
+  vddce_23 vddpe_23 vnwc_24 vpw_24 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_24 bl[0]_24 bl[1]_24 bl[2]_24 bl[3]_24 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_24 nbl[1]_24 nbl[2]_24 nbl[3]_24 ncored00_128 ncored01_130
+  ncored10_132 ncored11_134 ncored20_136 ncored21_138 ncored30_140
+  ncored31_142 vddc_24 vddce_24 vddpe_24 vnwc_25 vpw_25 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_25 bl[0]_25 bl[1]_25 bl[2]_25 bl[3]_25 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_25 nbl[1]_25 nbl[2]_25 nbl[3]_25 ncored00_160 ncored01_162
+  ncored10_164 ncored11_166 ncored20_168 ncored21_170 ncored30_172
+  ncored31_174 vddc_25 vddce_25 vddpe_25 vnwc_26 vpw_26 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_26 bl[0]_26 bl[1]_26 bl[2]_26 bl[3]_26 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_26 nbl[1]_26 nbl[2]_26 nbl[3]_26 ncored00_192 ncored01_194
+  ncored10_196 ncored11_198 ncored20_200 ncored21_202 ncored30_204
+  ncored31_206 vddc_26 vddce_26 vddpe_26 vnwc_27 vpw_27 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_27 bl[0]_27 bl[1]_27 bl[2]_27 bl[3]_27 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_27 nbl[1]_27 nbl[2]_27 nbl[3]_27 ncored00_224 ncored01_226
+  ncored10_228 ncored11_230 ncored20_232 ncored21_234 ncored30_236
+  ncored31_238 vddc_27 vddce_27 vddpe_27 vnwc_28 vpw_28 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_28 bl[0]_28 bl[1]_28 bl[2]_28 bl[3]_28 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_28 nbl[1]_28 nbl[2]_28 nbl[3]_28 ncored00_256 ncored01_258
+  ncored10_260 ncored11_262 ncored20_264 ncored21_266 ncored30_268
+  ncored31_270 vddc_28 vddce_28 vddpe_28 vnwc_29 vpw_29 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_29 bl[0]_29 bl[1]_29 bl[2]_29 bl[3]_29 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_29 nbl[1]_29 nbl[2]_29 nbl[3]_29 ncored00_288 ncored01_290
+  ncored10_292 ncored11_294 ncored20_296 ncored21_298 ncored30_300
+  ncored31_302 vddc_29 vddce_29 vddpe_29 vnwc_30 vpw_30 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_400 cored01_402
+  cored10_404 cored11_406 cored20_408 cored21_410 cored30_412 cored31_414
+  nbl[0]_3 nbl[1]_3 nbl[2]_3 nbl[3]_3 ncored00_416 ncored01_418 ncored10_420
+  ncored11_422 ncored20_424 ncored21_426 ncored30_428 ncored31_430 vddc_3
+  vddce_3 vddpe_3 vnwc_4 vpw_4 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_30 bl[0]_30 bl[1]_30 bl[2]_30 bl[3]_30 cored00_720 cored01_722
+  cored10_724 cored11_726 cored20_728 cored21_730 cored30_732 cored31_734
+  nbl[0]_30 nbl[1]_30 nbl[2]_30 nbl[3]_30 ncored00_736 ncored01_738
+  ncored10_740 ncored11_742 ncored20_744 ncored21_746 ncored30_748
+  ncored31_750 vddc_30 vddce_30 vddpe_30 vnwc_31 vpw_31 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_31 bl[0]_31 bl[1]_31 bl[2]_31 bl[3]_31 cored00_784 cored01_786
+  cored10_788 cored11_790 cored20_792 cored21_794 cored30_796 cored31_798
+  nbl[0]_31 nbl[1]_31 nbl[2]_31 nbl[3]_31 ncored00_800 ncored01_802
+  ncored10_804 ncored11_806 ncored20_808 ncored21_810 ncored30_812
+  ncored31_814 vddc_31 vddce_31 vddpe_31 vnwc_32 vpw_32 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_r_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_432 cored01_434
+  cored10_436 cored11_438 cored20_440 cored21_442 cored30_444 cored31_446
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_448 ncored01_450 ncored10_452
+  ncored11_454 ncored20_456 ncored21_458 ncored30_460 ncored31_462 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_464 cored01_466
+  cored10_468 cored11_470 cored20_472 cored21_474 cored30_476 cored31_478
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_480 ncored01_482 ncored10_484
+  ncored11_486 ncored20_488 ncored21_490 ncored30_492 ncored31_494 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_496 cored01_498
+  cored10_500 cored11_502 cored20_504 cored21_506 cored30_508 cored31_510
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_512 ncored01_514 ncored10_516
+  ncored11_518 ncored20_520 ncored21_522 ncored30_524 ncored31_526 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_528 cored01_530
+  cored10_532 cored11_534 cored20_536 cored21_538 cored30_540 cored31_542
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_544 ncored01_546 ncored10_548
+  ncored11_550 ncored20_552 ncored21_554 ncored30_556 ncored31_558 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_560 cored01_562
+  cored10_564 cored11_566 cored20_568 cored21_570 cored30_572 cored31_574
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_576 ncored01_578 ncored10_580
+  ncored11_582 ncored20_584 ncored21_586 ncored30_588 ncored31_590 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_r_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_592 cored01_594
+  cored10_596 cored11_598 cored20_600 cored21_602 cored30_604 cored31_606
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_608 ncored01_610 ncored10_612
+  ncored11_614 ncored20_616 ncored21_618 ncored30_620 ncored31_622 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] rf64x128cchs4
.ends rf64x128mem_r_test9row
****
.subckt rf64x128memcore_r vnwc nbl[2]_31 bl[2]_31 bl[3]_30 nbl[3]_30 nbl[2]_30
+  bl[2]_30 nbl[3]_29 nbl[2]_29 bl[2]_29 nbl[2]_28 bl[2]_28 bl[1]_28 nbl[3]_27
+  nbl[2]_27 bl[2]_27 bl[1]_27 nbl[3]_26 nbl[2]_26 bl[1]_26 nbl[3]_25
+  nbl[2]_25 bl[1]_25 nbl[1]_25 nbl[3]_24 nbl[2]_24 bl[2]_24 vpw bl[1]_24
+  nbl[1]_24 nbl[2]_23 bl[2]_23 vssc bl[1]_23 nbl[1]_23 bl[0]_23 nbl[2]_22
+  bl[2]_22 bl[1]_22 nbl[1]_22 nbl[0]_22 bl[0]_22 nbl[2]_21 bl[1]_21 nbl[1]_21
+  nbl[0]_21 bl[0]_21 nbl[2]_20 bl[1]_20 nbl[1]_20 nbl[0]_20 bl[0]_20 bl[1]_19
+  nbl[1]_19 nbl[0]_19 bl[0]_19 bl[3]_18 nbl[2]_18 bl[2]_18 bl[1]_18 nbl[1]_18
+  bl[0]_18 nbl[2]_17 bl[2]_17 bl[1]_17 nbl[1]_17 bl[0]_17 nbl[2]_16 bl[1]_16
+  nbl[1]_16 nbl[0]_16 bl[0]_16 nbl[2]_15 bl[1]_15 nbl[1]_15 nbl[0]_15
+  bl[0]_15 bl[1]_14 nbl[1]_14 nbl[0]_14 bl[0]_14 bl[3]_13 nbl[2]_13 bl[2]_13
+  bl[1]_13 nbl[1]_13 nbl[0]_13 bl[0]_13 bl[3]_12 nbl[2]_12 bl[2]_12 bl[1]_12
+  nbl[1]_12 bl[0]_12 nbl[2]_11 vddc bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11
+  bl[1]_10 nbl[1]_10 nbl[0]_10 bl[0]_10 bl[1]_9 nbl[1]_9 nbl[0]_9 bl[0]_9
+  bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 bl[3]_7 nbl[2]_7 bl[1]_7 nbl[1]_7
+  nbl[0]_7 bl[0]_7 bl[3]_6 nbl[3]_6 nbl[2]_6 bl[1]_6 nbl[1]_6 nbl[0]_6
+  bl[0]_6 bl[3]_5 nbl[3]_5 bl[1]_5 nbl[1]_5 nbl[0]_5 bl[0]_5 bl[1]_4 nbl[1]_4
+  nbl[0]_4 bl[0]_4 bl[1]_3 nbl[1]_3 nbl[0]_3 bl[0]_3 bl[3]_2 bl[1]_2 nbl[1]_2
+  bl[0]_2 bl[3]_1 bl[1]_1 bl[0]_1 bl[3]_0 nbl[3]_0 bl[0]_0 vnwp_0 vnwp_1
+  bl[3]_31 nbl[3]_31 bl[1]_31 nbl[1]_31 nbl[0]_31 bl[0]_31 bl[1]_30 nbl[1]_30
+  nbl[0]_30 bl[0]_30 bl[3]_29 bl[1]_29 nbl[1]_29 nbl[0]_29 bl[0]_29 bl[3]_28
+  nbl[3]_28 nbl[1]_28 nbl[0]_28 bl[0]_28 bl[3]_27 nbl[1]_27 nbl[0]_27
+  bl[0]_27 bl[3]_26 bl[2]_26 nbl[1]_26 nbl[0]_26 bl[0]_26 bl[3]_25 bl[2]_25
+  nbl[0]_25 bl[0]_25 bl[3]_24 nbl[0]_24 bl[0]_24 bl[3]_23 nbl[3]_23 nbl[0]_23
+  bl[3]_22 nbl[3]_22 bl[3]_21 nbl[3]_21 bl[2]_21 bl[3]_20 nbl[3]_20 bl[2]_20
+  bl[3]_19 nbl[3]_19 nbl[2]_19 bl[2]_19 nbl[3]_18 nbl[0]_18 bl[3]_17
+  nbl[3]_17 nbl[0]_17 bl[3]_16 nbl[3]_16 bl[2]_16 bl[3]_15 nbl[3]_15 bl[2]_15
+  bl[3]_14 nbl[3]_14 nbl[2]_14 bl[2]_14 nbl[3]_13 nbl[3]_12 nbl[0]_12
+  bl[3]_11 nbl[3]_11 bl[2]_11 bl[3]_10 nbl[3]_10 nbl[2]_10 bl[2]_10 bl[3]_9
+  nbl[3]_9 nbl[2]_9 bl[2]_9 bl[3]_8 nbl[3]_8 nbl[2]_8 bl[2]_8 vddpe nbl[3]_7
+  bl[2]_7 bl[2]_6 nbl[2]_5 bl[2]_5 bl[3]_4 nbl[3]_4 nbl[2]_4 bl[2]_4 bl[3]_3
+  nbl[3]_3 nbl[2]_3 bl[2]_3 nbl[3]_2 nbl[2]_2 bl[2]_2 nbl[0]_2 nbl[3]_1
+  nbl[2]_1 bl[2]_1 nbl[1]_1 nbl[0]_1 nbl[2]_0 bl[2]_0 bl[1]_0 nbl[1]_0
+  nbl[0]_0 wl[1]_15 wl[0]_15 wl[1]_14 wl[0]_14 wl[1]_13 wl[0]_13 wl[1]_12
+  wl[0]_12 wl[1]_11 wl[0]_11 wl[1]_10 wl[0]_10 wl[1]_9 wl[0]_9 wl[1]_8
+  wl[0]_8 wl[1]_7 wl[0]_7 wl[1]_6 wl[0]_6 wl[1]_5 wl[0]_5 wl[1]_4 wl[0]_4
+  wl[1]_3 wl[0]_3 wl[1]_2 wl[0]_2 wl[1]_1 wl[0]_1 wl[1]_0 wl[0]_0 actp vss
** rf64x128memcore_r: 24576 flat devices **
xmem_r_row_1 vpw vnwc bl[3]_31 nbl[3]_31 nbl[2]_31 bl[2]_31 vnwc vddc bl[3]_30
+  nbl[3]_30 nbl[2]_30 bl[2]_30 vddpe bl[1]_30 nbl[3]_29 nbl[2]_29 bl[2]_29
+  vddpe bl[1]_29 nbl[3]_28 nbl[2]_28 bl[2]_28 vddpe bl[1]_28 nbl[2]_27
+  bl[2]_27 vddpe bl[1]_27 nbl[2]_26 bl[2]_26 vddpe bl[1]_26 bl[0]_26
+  nbl[3]_25 nbl[2]_25 vnwc vddc vddpe bl[1]_25 nbl[1]_25 bl[0]_25 nbl[2]_24
+  bl[2]_24 vssc vpw vnwc vddc vddpe bl[1]_24 nbl[1]_24 nbl[0]_24 bl[0]_24
+  nbl[3]_23 nbl[2]_23 bl[2]_23 vpw vnwc vddc vddpe bl[1]_23 nbl[1]_23
+  nbl[0]_23 bl[0]_23 nbl[2]_22 bl[2]_22 vpw vnwc vddc vddpe bl[1]_22
+  nbl[1]_22 nbl[0]_22 bl[0]_22 nbl[2]_21 bl[2]_21 vpw vnwc vddc vddc vddpe
+  bl[1]_21 nbl[1]_21 nbl[0]_21 bl[0]_21 nbl[2]_20 vpw vnwc vddc vddc vddpe
+  bl[1]_20 nbl[1]_20 nbl[0]_20 bl[0]_20 nbl[2]_19 vpw vnwc vddc vddc vddpe
+  bl[1]_19 nbl[1]_19 nbl[0]_19 bl[0]_19 nbl[2]_18 vpw vnwc vddc vddpe
+  bl[1]_18 nbl[1]_18 nbl[0]_18 bl[0]_18 nbl[2]_17 bl[2]_17 vpw vnwc vddc
+  vddpe bl[1]_17 nbl[1]_17 nbl[0]_17 bl[0]_17 nbl[2]_16 bl[2]_16 vpw vnwc
+  vddc vddc vddpe bl[1]_16 nbl[1]_16 nbl[0]_16 bl[0]_16 nbl[2]_15 bl[2]_15
+  vpw vnwc vddc vddc vddpe bl[1]_15 nbl[1]_15 nbl[0]_15 bl[0]_15 nbl[2]_14
+  vpw vnwc vddc vddc vddpe bl[1]_14 nbl[1]_14 nbl[0]_14 bl[0]_14 nbl[2]_13
+  vpw vnwc vddc vddc vddpe bl[1]_13 nbl[1]_13 nbl[0]_13 bl[0]_13 vpw vnwc
+  vddc vddc vddpe bl[1]_12 nbl[1]_12 nbl[0]_12 bl[0]_12 vpw vnwc vddc vddc
+  vddpe bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 nbl[2]_10 bl[2]_10 vpw vnwc
+  vddc vddc vddpe bl[1]_10 nbl[1]_10 nbl[0]_10 bl[0]_10 nbl[2]_9 vpw vnwc
+  vddc vddc vddpe bl[1]_9 nbl[1]_9 nbl[0]_9 bl[0]_9 nbl[2]_8 vpw vnwc vddc
+  vddc vddpe bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 vpw vnwc vddc vddc vddpe
+  bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 vpw vnwc vddc vddc vddpe bl[1]_6 nbl[1]_6
+  nbl[0]_6 bl[0]_6 bl[3]_5 vpw vnwc vddc vddc vddpe bl[1]_5 nbl[1]_5 nbl[0]_5
+  bl[0]_5 vpw vnwc vddc vddc vddpe bl[1]_4 nbl[1]_4 nbl[0]_4 bl[0]_4 nbl[2]_3
+  vpw vnwc vddc vddc vddpe bl[1]_3 nbl[1]_3 nbl[0]_3 bl[0]_3 nbl[2]_2 vpw
+  vnwc vddc vddc vddpe bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 vpw vnwc vddc vddc
+  vddpe bl[1]_1 nbl[1]_1 nbl[0]_1 bl[0]_1 vpw vnwc vddc vddc vddpe bl[1]_0
+  nbl[1]_0 nbl[0]_0 bl[0]_0 vnwp_0 vnwc vpw vnwp_1 vpw vddc vddpe bl[1]_31
+  nbl[1]_31 nbl[0]_31 bl[0]_31 vpw vnwc vddc vddc nbl[1]_30 nbl[0]_30
+  bl[0]_30 bl[3]_29 vpw vnwc vddc vddc nbl[1]_29 nbl[0]_29 bl[0]_29 bl[3]_28
+  vpw vnwc vddc vddc nbl[1]_28 nbl[0]_28 bl[0]_28 bl[3]_27 nbl[3]_27 vpw vnwc
+  vddc vddc nbl[1]_27 nbl[0]_27 bl[0]_27 bl[3]_26 nbl[3]_26 vpw vnwc vddc
+  vddc nbl[1]_26 nbl[0]_26 bl[3]_25 bl[2]_25 vpw vddc nbl[0]_25 bl[3]_24
+  nbl[3]_24 vddc bl[3]_23 vddc bl[3]_22 nbl[3]_22 vddc bl[3]_21 nbl[3]_21
+  bl[3]_20 nbl[3]_20 bl[2]_20 bl[3]_19 nbl[3]_19 bl[2]_19 bl[3]_18 nbl[3]_18
+  bl[2]_18 vddc bl[3]_17 nbl[3]_17 vddc bl[3]_16 nbl[3]_16 bl[3]_15 nbl[3]_15
+  bl[3]_14 nbl[3]_14 bl[2]_14 bl[3]_13 nbl[3]_13 bl[2]_13 bl[3]_12 nbl[3]_12
+  nbl[2]_12 bl[2]_12 bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 bl[3]_10 nbl[3]_10
+  bl[3]_9 nbl[3]_9 bl[2]_9 bl[3]_8 nbl[3]_8 bl[2]_8 bl[3]_7 nbl[3]_7 nbl[2]_7
+  bl[2]_7 bl[3]_6 nbl[3]_6 nbl[2]_6 bl[2]_6 nbl[3]_5 nbl[2]_5 bl[2]_5 bl[3]_4
+  nbl[3]_4 nbl[2]_4 bl[2]_4 bl[3]_3 nbl[3]_3 bl[2]_3 bl[3]_2 nbl[3]_2 bl[2]_2
+  bl[3]_1 nbl[3]_1 nbl[2]_1 bl[2]_1 bl[3]_0 nbl[3]_0 nbl[2]_0 bl[2]_0 wl[1]_1
+  wl[0]_1 rf64x128mem_r_test1row
xmem_r_row_10 vpw vnwc bl[3]_31 nbl[3]_31 nbl[2]_31 bl[2]_31 vnwc vddc
+  bl[3]_30 nbl[3]_30 nbl[2]_30 bl[2]_30 vddpe bl[1]_30 nbl[3]_29 nbl[2]_29
+  bl[2]_29 vddpe bl[1]_29 nbl[3]_28 nbl[2]_28 bl[2]_28 vddpe bl[1]_28
+  nbl[2]_27 bl[2]_27 vddpe bl[1]_27 nbl[2]_26 bl[2]_26 vddpe bl[1]_26
+  bl[0]_26 nbl[3]_25 nbl[2]_25 vnwc vddc vddpe bl[1]_25 nbl[1]_25 bl[0]_25
+  nbl[2]_24 bl[2]_24 vssc vpw vnwc vddc vddpe bl[1]_24 nbl[1]_24 nbl[0]_24
+  bl[0]_24 nbl[3]_23 nbl[2]_23 bl[2]_23 vpw vnwc vddc vddpe bl[1]_23
+  nbl[1]_23 nbl[0]_23 bl[0]_23 nbl[2]_22 bl[2]_22 vpw vnwc vddc vddpe
+  bl[1]_22 nbl[1]_22 nbl[0]_22 bl[0]_22 nbl[2]_21 bl[2]_21 vpw vnwc vddc vddc
+  vddpe bl[1]_21 nbl[1]_21 nbl[0]_21 bl[0]_21 nbl[2]_20 vpw vnwc vddc vddc
+  vddpe bl[1]_20 nbl[1]_20 nbl[0]_20 bl[0]_20 nbl[2]_19 vpw vnwc vddc vddc
+  vddpe bl[1]_19 nbl[1]_19 nbl[0]_19 bl[0]_19 nbl[2]_18 vpw vnwc vddc vddpe
+  bl[1]_18 nbl[1]_18 nbl[0]_18 bl[0]_18 nbl[2]_17 bl[2]_17 vpw vnwc vddc
+  vddpe bl[1]_17 nbl[1]_17 nbl[0]_17 bl[0]_17 nbl[2]_16 bl[2]_16 vpw vnwc
+  vddc vddc vddpe bl[1]_16 nbl[1]_16 nbl[0]_16 bl[0]_16 nbl[2]_15 bl[2]_15
+  vpw vnwc vddc vddc vddpe bl[1]_15 nbl[1]_15 nbl[0]_15 bl[0]_15 nbl[2]_14
+  vpw vnwc vddc vddc vddpe bl[1]_14 nbl[1]_14 nbl[0]_14 bl[0]_14 nbl[2]_13
+  vpw vnwc vddc vddc vddpe bl[1]_13 nbl[1]_13 nbl[0]_13 bl[0]_13 vpw vnwc
+  vddc vddc vddpe bl[1]_12 nbl[1]_12 nbl[0]_12 bl[0]_12 vpw vnwc vddc vddc
+  vddpe bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 nbl[2]_10 bl[2]_10 vpw vnwc
+  vddc vddc vddpe bl[1]_10 nbl[1]_10 nbl[0]_10 bl[0]_10 nbl[2]_9 vpw vnwc
+  vddc vddc vddpe bl[1]_9 nbl[1]_9 nbl[0]_9 bl[0]_9 nbl[2]_8 vpw vnwc vddc
+  vddc vddpe bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 vpw vnwc vddc vddc vddpe
+  bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 vpw vnwc vddc vddc vddpe bl[1]_6 nbl[1]_6
+  nbl[0]_6 bl[0]_6 bl[3]_5 vpw vnwc vddc vddc vddpe bl[1]_5 nbl[1]_5 nbl[0]_5
+  bl[0]_5 vpw vnwc vddc vddc vddpe bl[1]_4 nbl[1]_4 nbl[0]_4 bl[0]_4 nbl[2]_3
+  vpw vnwc vddc vddc vddpe bl[1]_3 nbl[1]_3 nbl[0]_3 bl[0]_3 nbl[2]_2 vpw
+  vnwc vddc vddc vddpe bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 vpw vnwc vddc vddc
+  vddpe bl[1]_1 nbl[1]_1 nbl[0]_1 bl[0]_1 vpw vnwc vddc vddc vddpe bl[1]_0
+  nbl[1]_0 nbl[0]_0 bl[0]_0 vnwp_0 vnwc vpw vnwp_1 vpw vddc vddpe bl[1]_31
+  nbl[1]_31 nbl[0]_31 bl[0]_31 vpw vnwc vddc vddc nbl[1]_30 nbl[0]_30
+  bl[0]_30 bl[3]_29 vpw vnwc vddc vddc nbl[1]_29 nbl[0]_29 bl[0]_29 bl[3]_28
+  vpw vnwc vddc vddc nbl[1]_28 nbl[0]_28 bl[0]_28 bl[3]_27 nbl[3]_27 vpw vnwc
+  vddc vddc nbl[1]_27 nbl[0]_27 bl[0]_27 bl[3]_26 nbl[3]_26 vpw vnwc vddc
+  vddc nbl[1]_26 nbl[0]_26 bl[3]_25 bl[2]_25 vpw vddc nbl[0]_25 bl[3]_24
+  nbl[3]_24 vddc bl[3]_23 vddc bl[3]_22 nbl[3]_22 vddc bl[3]_21 nbl[3]_21
+  bl[3]_20 nbl[3]_20 bl[2]_20 bl[3]_19 nbl[3]_19 bl[2]_19 bl[3]_18 nbl[3]_18
+  bl[2]_18 vddc bl[3]_17 nbl[3]_17 vddc bl[3]_16 nbl[3]_16 bl[3]_15 nbl[3]_15
+  bl[3]_14 nbl[3]_14 bl[2]_14 bl[3]_13 nbl[3]_13 bl[2]_13 bl[3]_12 nbl[3]_12
+  nbl[2]_12 bl[2]_12 bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 bl[3]_10 nbl[3]_10
+  bl[3]_9 nbl[3]_9 bl[2]_9 bl[3]_8 nbl[3]_8 bl[2]_8 bl[3]_7 nbl[3]_7 nbl[2]_7
+  bl[2]_7 bl[3]_6 nbl[3]_6 nbl[2]_6 bl[2]_6 nbl[3]_5 nbl[2]_5 bl[2]_5 bl[3]_4
+  nbl[3]_4 nbl[2]_4 bl[2]_4 bl[3]_3 nbl[3]_3 bl[2]_3 bl[3]_2 nbl[3]_2 bl[2]_2
+  bl[3]_1 nbl[3]_1 nbl[2]_1 bl[2]_1 bl[3]_0 nbl[3]_0 nbl[2]_0 bl[2]_0
+  wl[1]_10 wl[0]_10 rf64x128mem_r_test10row
xmem_r_row_11 vpw vnwc bl[3]_31 nbl[3]_31 nbl[2]_31 bl[2]_31 vnwc vddc
+  bl[3]_30 nbl[3]_30 nbl[2]_30 bl[2]_30 vddpe bl[1]_30 nbl[3]_29 nbl[2]_29
+  bl[2]_29 vddpe bl[1]_29 nbl[3]_28 nbl[2]_28 bl[2]_28 vddpe bl[1]_28
+  nbl[2]_27 bl[2]_27 vddpe bl[1]_27 nbl[2]_26 bl[2]_26 vddpe bl[1]_26
+  bl[0]_26 nbl[3]_25 nbl[2]_25 vnwc vddc vddpe bl[1]_25 nbl[1]_25 bl[0]_25
+  nbl[2]_24 bl[2]_24 vssc vpw vnwc vddc vddpe bl[1]_24 nbl[1]_24 nbl[0]_24
+  bl[0]_24 nbl[3]_23 nbl[2]_23 bl[2]_23 vpw vnwc vddc vddpe bl[1]_23
+  nbl[1]_23 nbl[0]_23 bl[0]_23 nbl[2]_22 bl[2]_22 vpw vnwc vddc vddpe
+  bl[1]_22 nbl[1]_22 nbl[0]_22 bl[0]_22 nbl[2]_21 bl[2]_21 vpw vnwc vddc vddc
+  vddpe bl[1]_21 nbl[1]_21 nbl[0]_21 bl[0]_21 nbl[2]_20 vpw vnwc vddc vddc
+  vddpe bl[1]_20 nbl[1]_20 nbl[0]_20 bl[0]_20 nbl[2]_19 vpw vnwc vddc vddc
+  vddpe bl[1]_19 nbl[1]_19 nbl[0]_19 bl[0]_19 nbl[2]_18 vpw vnwc vddc vddpe
+  bl[1]_18 nbl[1]_18 nbl[0]_18 bl[0]_18 nbl[2]_17 bl[2]_17 vpw vnwc vddc
+  vddpe bl[1]_17 nbl[1]_17 nbl[0]_17 bl[0]_17 nbl[2]_16 bl[2]_16 vpw vnwc
+  vddc vddc vddpe bl[1]_16 nbl[1]_16 nbl[0]_16 bl[0]_16 nbl[2]_15 bl[2]_15
+  vpw vnwc vddc vddc vddpe bl[1]_15 nbl[1]_15 nbl[0]_15 bl[0]_15 nbl[2]_14
+  vpw vnwc vddc vddc vddpe bl[1]_14 nbl[1]_14 nbl[0]_14 bl[0]_14 nbl[2]_13
+  vpw vnwc vddc vddc vddpe bl[1]_13 nbl[1]_13 nbl[0]_13 bl[0]_13 vpw vnwc
+  vddc vddc vddpe bl[1]_12 nbl[1]_12 nbl[0]_12 bl[0]_12 vpw vnwc vddc vddc
+  vddpe bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 nbl[2]_10 bl[2]_10 vpw vnwc
+  vddc vddc vddpe bl[1]_10 nbl[1]_10 nbl[0]_10 bl[0]_10 nbl[2]_9 vpw vnwc
+  vddc vddc vddpe bl[1]_9 nbl[1]_9 nbl[0]_9 bl[0]_9 nbl[2]_8 vpw vnwc vddc
+  vddc vddpe bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 vpw vnwc vddc vddc vddpe
+  bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 vpw vnwc vddc vddc vddpe bl[1]_6 nbl[1]_6
+  nbl[0]_6 bl[0]_6 bl[3]_5 vpw vnwc vddc vddc vddpe bl[1]_5 nbl[1]_5 nbl[0]_5
+  bl[0]_5 vpw vnwc vddc vddc vddpe bl[1]_4 nbl[1]_4 nbl[0]_4 bl[0]_4 nbl[2]_3
+  vpw vnwc vddc vddc vddpe bl[1]_3 nbl[1]_3 nbl[0]_3 bl[0]_3 nbl[2]_2 vpw
+  vnwc vddc vddc vddpe bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 vpw vnwc vddc vddc
+  vddpe bl[1]_1 nbl[1]_1 nbl[0]_1 bl[0]_1 vpw vnwc vddc vddc vddpe bl[1]_0
+  nbl[1]_0 nbl[0]_0 bl[0]_0 vnwp_0 vnwc vpw vnwp_1 vpw vddc vddpe bl[1]_31
+  nbl[1]_31 nbl[0]_31 bl[0]_31 vpw vnwc vddc vddc nbl[1]_30 nbl[0]_30
+  bl[0]_30 bl[3]_29 vpw vnwc vddc vddc nbl[1]_29 nbl[0]_29 bl[0]_29 bl[3]_28
+  vpw vnwc vddc vddc nbl[1]_28 nbl[0]_28 bl[0]_28 bl[3]_27 nbl[3]_27 vpw vnwc
+  vddc vddc nbl[1]_27 nbl[0]_27 bl[0]_27 bl[3]_26 nbl[3]_26 vpw vnwc vddc
+  vddc nbl[1]_26 nbl[0]_26 bl[3]_25 bl[2]_25 vpw vddc nbl[0]_25 bl[3]_24
+  nbl[3]_24 vddc bl[3]_23 vddc bl[3]_22 nbl[3]_22 vddc bl[3]_21 nbl[3]_21
+  bl[3]_20 nbl[3]_20 bl[2]_20 bl[3]_19 nbl[3]_19 bl[2]_19 bl[3]_18 nbl[3]_18
+  bl[2]_18 vddc bl[3]_17 nbl[3]_17 vddc bl[3]_16 nbl[3]_16 bl[3]_15 nbl[3]_15
+  bl[3]_14 nbl[3]_14 bl[2]_14 bl[3]_13 nbl[3]_13 bl[2]_13 bl[3]_12 nbl[3]_12
+  nbl[2]_12 bl[2]_12 bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 bl[3]_10 nbl[3]_10
+  bl[3]_9 nbl[3]_9 bl[2]_9 bl[3]_8 nbl[3]_8 bl[2]_8 bl[3]_7 nbl[3]_7 nbl[2]_7
+  bl[2]_7 bl[3]_6 nbl[3]_6 nbl[2]_6 bl[2]_6 nbl[3]_5 nbl[2]_5 bl[2]_5 bl[3]_4
+  nbl[3]_4 nbl[2]_4 bl[2]_4 bl[3]_3 nbl[3]_3 bl[2]_3 bl[3]_2 nbl[3]_2 bl[2]_2
+  bl[3]_1 nbl[3]_1 nbl[2]_1 bl[2]_1 bl[3]_0 nbl[3]_0 nbl[2]_0 bl[2]_0
+  wl[1]_11 wl[0]_11 rf64x128mem_r_test11row
xmem_r_row_12 vpw vnwc bl[3]_31 nbl[3]_31 nbl[2]_31 bl[2]_31 vnwc vddc
+  bl[3]_30 nbl[3]_30 nbl[2]_30 bl[2]_30 vddpe bl[1]_30 nbl[3]_29 nbl[2]_29
+  bl[2]_29 vddpe bl[1]_29 nbl[3]_28 nbl[2]_28 bl[2]_28 vddpe bl[1]_28
+  nbl[2]_27 bl[2]_27 vddpe bl[1]_27 nbl[2]_26 bl[2]_26 vddpe bl[1]_26
+  bl[0]_26 nbl[3]_25 nbl[2]_25 vnwc vddc vddpe bl[1]_25 nbl[1]_25 bl[0]_25
+  nbl[2]_24 bl[2]_24 vssc vpw vnwc vddc vddpe bl[1]_24 nbl[1]_24 nbl[0]_24
+  bl[0]_24 nbl[3]_23 nbl[2]_23 bl[2]_23 vpw vnwc vddc vddpe bl[1]_23
+  nbl[1]_23 nbl[0]_23 bl[0]_23 nbl[2]_22 bl[2]_22 vpw vnwc vddc vddpe
+  bl[1]_22 nbl[1]_22 nbl[0]_22 bl[0]_22 nbl[2]_21 bl[2]_21 vpw vnwc vddc vddc
+  vddpe bl[1]_21 nbl[1]_21 nbl[0]_21 bl[0]_21 nbl[2]_20 vpw vnwc vddc vddc
+  vddpe bl[1]_20 nbl[1]_20 nbl[0]_20 bl[0]_20 nbl[2]_19 vpw vnwc vddc vddc
+  vddpe bl[1]_19 nbl[1]_19 nbl[0]_19 bl[0]_19 nbl[2]_18 vpw vnwc vddc vddpe
+  bl[1]_18 nbl[1]_18 nbl[0]_18 bl[0]_18 nbl[2]_17 bl[2]_17 vpw vnwc vddc
+  vddpe bl[1]_17 nbl[1]_17 nbl[0]_17 bl[0]_17 nbl[2]_16 bl[2]_16 vpw vnwc
+  vddc vddc vddpe bl[1]_16 nbl[1]_16 nbl[0]_16 bl[0]_16 nbl[2]_15 bl[2]_15
+  vpw vnwc vddc vddc vddpe bl[1]_15 nbl[1]_15 nbl[0]_15 bl[0]_15 nbl[2]_14
+  vpw vnwc vddc vddc vddpe bl[1]_14 nbl[1]_14 nbl[0]_14 bl[0]_14 nbl[2]_13
+  vpw vnwc vddc vddc vddpe bl[1]_13 nbl[1]_13 nbl[0]_13 bl[0]_13 vpw vnwc
+  vddc vddc vddpe bl[1]_12 nbl[1]_12 nbl[0]_12 bl[0]_12 vpw vnwc vddc vddc
+  vddpe bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 nbl[2]_10 bl[2]_10 vpw vnwc
+  vddc vddc vddpe bl[1]_10 nbl[1]_10 nbl[0]_10 bl[0]_10 nbl[2]_9 vpw vnwc
+  vddc vddc vddpe bl[1]_9 nbl[1]_9 nbl[0]_9 bl[0]_9 nbl[2]_8 vpw vnwc vddc
+  vddc vddpe bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 vpw vnwc vddc vddc vddpe
+  bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 vpw vnwc vddc vddc vddpe bl[1]_6 nbl[1]_6
+  nbl[0]_6 bl[0]_6 bl[3]_5 vpw vnwc vddc vddc vddpe bl[1]_5 nbl[1]_5 nbl[0]_5
+  bl[0]_5 vpw vnwc vddc vddc vddpe bl[1]_4 nbl[1]_4 nbl[0]_4 bl[0]_4 nbl[2]_3
+  vpw vnwc vddc vddc vddpe bl[1]_3 nbl[1]_3 nbl[0]_3 bl[0]_3 nbl[2]_2 vpw
+  vnwc vddc vddc vddpe bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 vpw vnwc vddc vddc
+  vddpe bl[1]_1 nbl[1]_1 nbl[0]_1 bl[0]_1 vpw vnwc vddc vddc vddpe bl[1]_0
+  nbl[1]_0 nbl[0]_0 bl[0]_0 vnwp_0 vnwc vpw vnwp_1 vpw vddc vddpe bl[1]_31
+  nbl[1]_31 nbl[0]_31 bl[0]_31 vpw vnwc vddc vddc nbl[1]_30 nbl[0]_30
+  bl[0]_30 bl[3]_29 vpw vnwc vddc vddc nbl[1]_29 nbl[0]_29 bl[0]_29 bl[3]_28
+  vpw vnwc vddc vddc nbl[1]_28 nbl[0]_28 bl[0]_28 bl[3]_27 nbl[3]_27 vpw vnwc
+  vddc vddc nbl[1]_27 nbl[0]_27 bl[0]_27 bl[3]_26 nbl[3]_26 vpw vnwc vddc
+  vddc nbl[1]_26 nbl[0]_26 bl[3]_25 bl[2]_25 vpw vddc nbl[0]_25 bl[3]_24
+  nbl[3]_24 vddc bl[3]_23 vddc bl[3]_22 nbl[3]_22 vddc bl[3]_21 nbl[3]_21
+  bl[3]_20 nbl[3]_20 bl[2]_20 bl[3]_19 nbl[3]_19 bl[2]_19 bl[3]_18 nbl[3]_18
+  bl[2]_18 vddc bl[3]_17 nbl[3]_17 vddc bl[3]_16 nbl[3]_16 bl[3]_15 nbl[3]_15
+  bl[3]_14 nbl[3]_14 bl[2]_14 bl[3]_13 nbl[3]_13 bl[2]_13 bl[3]_12 nbl[3]_12
+  nbl[2]_12 bl[2]_12 bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 bl[3]_10 nbl[3]_10
+  bl[3]_9 nbl[3]_9 bl[2]_9 bl[3]_8 nbl[3]_8 bl[2]_8 bl[3]_7 nbl[3]_7 nbl[2]_7
+  bl[2]_7 bl[3]_6 nbl[3]_6 nbl[2]_6 bl[2]_6 nbl[3]_5 nbl[2]_5 bl[2]_5 bl[3]_4
+  nbl[3]_4 nbl[2]_4 bl[2]_4 bl[3]_3 nbl[3]_3 bl[2]_3 bl[3]_2 nbl[3]_2 bl[2]_2
+  bl[3]_1 nbl[3]_1 nbl[2]_1 bl[2]_1 bl[3]_0 nbl[3]_0 nbl[2]_0 bl[2]_0
+  wl[1]_12 wl[0]_12 rf64x128mem_r_test12row
xmem_r_row_13 vpw vnwc bl[3]_31 nbl[3]_31 nbl[2]_31 bl[2]_31 vnwc vddc
+  bl[3]_30 nbl[3]_30 nbl[2]_30 bl[2]_30 vddpe bl[1]_30 nbl[3]_29 nbl[2]_29
+  bl[2]_29 vddpe bl[1]_29 nbl[3]_28 nbl[2]_28 bl[2]_28 vddpe bl[1]_28
+  nbl[2]_27 bl[2]_27 vddpe bl[1]_27 nbl[2]_26 bl[2]_26 vddpe bl[1]_26
+  bl[0]_26 nbl[3]_25 nbl[2]_25 vnwc vddc vddpe bl[1]_25 nbl[1]_25 bl[0]_25
+  nbl[2]_24 bl[2]_24 vssc vpw vnwc vddc vddpe bl[1]_24 nbl[1]_24 nbl[0]_24
+  bl[0]_24 nbl[3]_23 nbl[2]_23 bl[2]_23 vpw vnwc vddc vddpe bl[1]_23
+  nbl[1]_23 nbl[0]_23 bl[0]_23 nbl[2]_22 bl[2]_22 vpw vnwc vddc vddpe
+  bl[1]_22 nbl[1]_22 nbl[0]_22 bl[0]_22 nbl[2]_21 bl[2]_21 vpw vnwc vddc vddc
+  vddpe bl[1]_21 nbl[1]_21 nbl[0]_21 bl[0]_21 nbl[2]_20 vpw vnwc vddc vddc
+  vddpe bl[1]_20 nbl[1]_20 nbl[0]_20 bl[0]_20 nbl[2]_19 vpw vnwc vddc vddc
+  vddpe bl[1]_19 nbl[1]_19 nbl[0]_19 bl[0]_19 nbl[2]_18 vpw vnwc vddc vddpe
+  bl[1]_18 nbl[1]_18 nbl[0]_18 bl[0]_18 nbl[2]_17 bl[2]_17 vpw vnwc vddc
+  vddpe bl[1]_17 nbl[1]_17 nbl[0]_17 bl[0]_17 nbl[2]_16 bl[2]_16 vpw vnwc
+  vddc vddc vddpe bl[1]_16 nbl[1]_16 nbl[0]_16 bl[0]_16 nbl[2]_15 bl[2]_15
+  vpw vnwc vddc vddc vddpe bl[1]_15 nbl[1]_15 nbl[0]_15 bl[0]_15 nbl[2]_14
+  vpw vnwc vddc vddc vddpe bl[1]_14 nbl[1]_14 nbl[0]_14 bl[0]_14 nbl[2]_13
+  vpw vnwc vddc vddc vddpe bl[1]_13 nbl[1]_13 nbl[0]_13 bl[0]_13 vpw vnwc
+  vddc vddc vddpe bl[1]_12 nbl[1]_12 nbl[0]_12 bl[0]_12 vpw vnwc vddc vddc
+  vddpe bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 nbl[2]_10 bl[2]_10 vpw vnwc
+  vddc vddc vddpe bl[1]_10 nbl[1]_10 nbl[0]_10 bl[0]_10 nbl[2]_9 vpw vnwc
+  vddc vddc vddpe bl[1]_9 nbl[1]_9 nbl[0]_9 bl[0]_9 nbl[2]_8 vpw vnwc vddc
+  vddc vddpe bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 vpw vnwc vddc vddc vddpe
+  bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 vpw vnwc vddc vddc vddpe bl[1]_6 nbl[1]_6
+  nbl[0]_6 bl[0]_6 bl[3]_5 vpw vnwc vddc vddc vddpe bl[1]_5 nbl[1]_5 nbl[0]_5
+  bl[0]_5 vpw vnwc vddc vddc vddpe bl[1]_4 nbl[1]_4 nbl[0]_4 bl[0]_4 nbl[2]_3
+  vpw vnwc vddc vddc vddpe bl[1]_3 nbl[1]_3 nbl[0]_3 bl[0]_3 nbl[2]_2 vpw
+  vnwc vddc vddc vddpe bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 vpw vnwc vddc vddc
+  vddpe bl[1]_1 nbl[1]_1 nbl[0]_1 bl[0]_1 vpw vnwc vddc vddc vddpe bl[1]_0
+  nbl[1]_0 nbl[0]_0 bl[0]_0 vnwp_0 vnwc vpw vnwp_1 vpw vddc vddpe bl[1]_31
+  nbl[1]_31 nbl[0]_31 bl[0]_31 vpw vnwc vddc vddc nbl[1]_30 nbl[0]_30
+  bl[0]_30 bl[3]_29 vpw vnwc vddc vddc nbl[1]_29 nbl[0]_29 bl[0]_29 bl[3]_28
+  vpw vnwc vddc vddc nbl[1]_28 nbl[0]_28 bl[0]_28 bl[3]_27 nbl[3]_27 vpw vnwc
+  vddc vddc nbl[1]_27 nbl[0]_27 bl[0]_27 bl[3]_26 nbl[3]_26 vpw vnwc vddc
+  vddc nbl[1]_26 nbl[0]_26 bl[3]_25 bl[2]_25 vpw vddc nbl[0]_25 bl[3]_24
+  nbl[3]_24 vddc bl[3]_23 vddc bl[3]_22 nbl[3]_22 vddc bl[3]_21 nbl[3]_21
+  bl[3]_20 nbl[3]_20 bl[2]_20 bl[3]_19 nbl[3]_19 bl[2]_19 bl[3]_18 nbl[3]_18
+  bl[2]_18 vddc bl[3]_17 nbl[3]_17 vddc bl[3]_16 nbl[3]_16 bl[3]_15 nbl[3]_15
+  bl[3]_14 nbl[3]_14 bl[2]_14 bl[3]_13 nbl[3]_13 bl[2]_13 bl[3]_12 nbl[3]_12
+  nbl[2]_12 bl[2]_12 bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 bl[3]_10 nbl[3]_10
+  bl[3]_9 nbl[3]_9 bl[2]_9 bl[3]_8 nbl[3]_8 bl[2]_8 bl[3]_7 nbl[3]_7 nbl[2]_7
+  bl[2]_7 bl[3]_6 nbl[3]_6 nbl[2]_6 bl[2]_6 nbl[3]_5 nbl[2]_5 bl[2]_5 bl[3]_4
+  nbl[3]_4 nbl[2]_4 bl[2]_4 bl[3]_3 nbl[3]_3 bl[2]_3 bl[3]_2 nbl[3]_2 bl[2]_2
+  bl[3]_1 nbl[3]_1 nbl[2]_1 bl[2]_1 bl[3]_0 nbl[3]_0 nbl[2]_0 bl[2]_0
+  wl[1]_13 wl[0]_13 rf64x128mem_r_test13row
xmem_r_row_14 vpw vnwc bl[3]_31 nbl[3]_31 nbl[2]_31 bl[2]_31 vnwc vddc
+  bl[3]_30 nbl[3]_30 nbl[2]_30 bl[2]_30 vddpe bl[1]_30 nbl[3]_29 nbl[2]_29

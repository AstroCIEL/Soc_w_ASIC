+  bl[2]_29 vddpe bl[1]_29 nbl[3]_28 nbl[2]_28 bl[2]_28 vddpe bl[1]_28
+  nbl[2]_27 bl[2]_27 vddpe bl[1]_27 nbl[2]_26 bl[2]_26 vddpe bl[1]_26
+  bl[0]_26 nbl[3]_25 nbl[2]_25 vnwc vddc vddpe bl[1]_25 nbl[1]_25 bl[0]_25
+  nbl[2]_24 bl[2]_24 vssc vpw vnwc vddc vddpe bl[1]_24 nbl[1]_24 nbl[0]_24
+  bl[0]_24 nbl[3]_23 nbl[2]_23 bl[2]_23 vpw vnwc vddc vddpe bl[1]_23
+  nbl[1]_23 nbl[0]_23 bl[0]_23 nbl[2]_22 bl[2]_22 vpw vnwc vddc vddpe
+  bl[1]_22 nbl[1]_22 nbl[0]_22 bl[0]_22 nbl[2]_21 bl[2]_21 vpw vnwc vddc vddc
+  vddpe bl[1]_21 nbl[1]_21 nbl[0]_21 bl[0]_21 nbl[2]_20 vpw vnwc vddc vddc
+  vddpe bl[1]_20 nbl[1]_20 nbl[0]_20 bl[0]_20 nbl[2]_19 vpw vnwc vddc vddc
+  vddpe bl[1]_19 nbl[1]_19 nbl[0]_19 bl[0]_19 nbl[2]_18 vpw vnwc vddc vddpe
+  bl[1]_18 nbl[1]_18 nbl[0]_18 bl[0]_18 nbl[2]_17 bl[2]_17 vpw vnwc vddc
+  vddpe bl[1]_17 nbl[1]_17 nbl[0]_17 bl[0]_17 nbl[2]_16 bl[2]_16 vpw vnwc
+  vddc vddc vddpe bl[1]_16 nbl[1]_16 nbl[0]_16 bl[0]_16 nbl[2]_15 bl[2]_15
+  vpw vnwc vddc vddc vddpe bl[1]_15 nbl[1]_15 nbl[0]_15 bl[0]_15 nbl[2]_14
+  vpw vnwc vddc vddc vddpe bl[1]_14 nbl[1]_14 nbl[0]_14 bl[0]_14 nbl[2]_13
+  vpw vnwc vddc vddc vddpe bl[1]_13 nbl[1]_13 nbl[0]_13 bl[0]_13 vpw vnwc
+  vddc vddc vddpe bl[1]_12 nbl[1]_12 nbl[0]_12 bl[0]_12 vpw vnwc vddc vddc
+  vddpe bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 nbl[2]_10 bl[2]_10 vpw vnwc
+  vddc vddc vddpe bl[1]_10 nbl[1]_10 nbl[0]_10 bl[0]_10 nbl[2]_9 vpw vnwc
+  vddc vddc vddpe bl[1]_9 nbl[1]_9 nbl[0]_9 bl[0]_9 nbl[2]_8 vpw vnwc vddc
+  vddc vddpe bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 vpw vnwc vddc vddc vddpe
+  bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 vpw vnwc vddc vddc vddpe bl[1]_6 nbl[1]_6
+  nbl[0]_6 bl[0]_6 bl[3]_5 vpw vnwc vddc vddc vddpe bl[1]_5 nbl[1]_5 nbl[0]_5
+  bl[0]_5 vpw vnwc vddc vddc vddpe bl[1]_4 nbl[1]_4 nbl[0]_4 bl[0]_4 nbl[2]_3
+  vpw vnwc vddc vddc vddpe bl[1]_3 nbl[1]_3 nbl[0]_3 bl[0]_3 nbl[2]_2 vpw
+  vnwc vddc vddc vddpe bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 vpw vnwc vddc vddc
+  vddpe bl[1]_1 nbl[1]_1 nbl[0]_1 bl[0]_1 vpw vnwc vddc vddc vddpe bl[1]_0
+  nbl[1]_0 nbl[0]_0 bl[0]_0 vnwp_0 vnwc vpw vnwp_1 vpw vddc vddpe bl[1]_31
+  nbl[1]_31 nbl[0]_31 bl[0]_31 vpw vnwc vddc vddc nbl[1]_30 nbl[0]_30
+  bl[0]_30 bl[3]_29 vpw vnwc vddc vddc nbl[1]_29 nbl[0]_29 bl[0]_29 bl[3]_28
+  vpw vnwc vddc vddc nbl[1]_28 nbl[0]_28 bl[0]_28 bl[3]_27 nbl[3]_27 vpw vnwc
+  vddc vddc nbl[1]_27 nbl[0]_27 bl[0]_27 bl[3]_26 nbl[3]_26 vpw vnwc vddc
+  vddc nbl[1]_26 nbl[0]_26 bl[3]_25 bl[2]_25 vpw vddc nbl[0]_25 bl[3]_24
+  nbl[3]_24 vddc bl[3]_23 vddc bl[3]_22 nbl[3]_22 vddc bl[3]_21 nbl[3]_21
+  bl[3]_20 nbl[3]_20 bl[2]_20 bl[3]_19 nbl[3]_19 bl[2]_19 bl[3]_18 nbl[3]_18
+  bl[2]_18 vddc bl[3]_17 nbl[3]_17 vddc bl[3]_16 nbl[3]_16 bl[3]_15 nbl[3]_15
+  bl[3]_14 nbl[3]_14 bl[2]_14 bl[3]_13 nbl[3]_13 bl[2]_13 bl[3]_12 nbl[3]_12
+  nbl[2]_12 bl[2]_12 bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 bl[3]_10 nbl[3]_10
+  bl[3]_9 nbl[3]_9 bl[2]_9 bl[3]_8 nbl[3]_8 bl[2]_8 bl[3]_7 nbl[3]_7 nbl[2]_7
+  bl[2]_7 bl[3]_6 nbl[3]_6 nbl[2]_6 bl[2]_6 nbl[3]_5 nbl[2]_5 bl[2]_5 bl[3]_4
+  nbl[3]_4 nbl[2]_4 bl[2]_4 bl[3]_3 nbl[3]_3 bl[2]_3 bl[3]_2 nbl[3]_2 bl[2]_2
+  bl[3]_1 nbl[3]_1 nbl[2]_1 bl[2]_1 bl[3]_0 nbl[3]_0 nbl[2]_0 bl[2]_0
+  wl[1]_14 wl[0]_14 rf64x128mem_r_test14row
xmem_r_row_2 vpw vnwc bl[3]_31 nbl[3]_31 nbl[2]_31 bl[2]_31 vnwc vddc bl[3]_30
+  nbl[3]_30 nbl[2]_30 bl[2]_30 vddpe bl[1]_30 nbl[3]_29 nbl[2]_29 bl[2]_29
+  vddpe bl[1]_29 nbl[3]_28 nbl[2]_28 bl[2]_28 vddpe bl[1]_28 nbl[2]_27
+  bl[2]_27 vddpe bl[1]_27 nbl[2]_26 bl[2]_26 vddpe bl[1]_26 bl[0]_26
+  nbl[3]_25 nbl[2]_25 vnwc vddc vddpe bl[1]_25 nbl[1]_25 bl[0]_25 nbl[2]_24
+  bl[2]_24 vssc vpw vnwc vddc vddpe bl[1]_24 nbl[1]_24 nbl[0]_24 bl[0]_24
+  nbl[3]_23 nbl[2]_23 bl[2]_23 vpw vnwc vddc vddpe bl[1]_23 nbl[1]_23
+  nbl[0]_23 bl[0]_23 nbl[2]_22 bl[2]_22 vpw vnwc vddc vddpe bl[1]_22
+  nbl[1]_22 nbl[0]_22 bl[0]_22 nbl[2]_21 bl[2]_21 vpw vnwc vddc vddc vddpe
+  bl[1]_21 nbl[1]_21 nbl[0]_21 bl[0]_21 nbl[2]_20 vpw vnwc vddc vddc vddpe
+  bl[1]_20 nbl[1]_20 nbl[0]_20 bl[0]_20 nbl[2]_19 vpw vnwc vddc vddc vddpe
+  bl[1]_19 nbl[1]_19 nbl[0]_19 bl[0]_19 nbl[2]_18 vpw vnwc vddc vddpe
+  bl[1]_18 nbl[1]_18 nbl[0]_18 bl[0]_18 nbl[2]_17 bl[2]_17 vpw vnwc vddc
+  vddpe bl[1]_17 nbl[1]_17 nbl[0]_17 bl[0]_17 nbl[2]_16 bl[2]_16 vpw vnwc
+  vddc vddc vddpe bl[1]_16 nbl[1]_16 nbl[0]_16 bl[0]_16 nbl[2]_15 bl[2]_15
+  vpw vnwc vddc vddc vddpe bl[1]_15 nbl[1]_15 nbl[0]_15 bl[0]_15 nbl[2]_14
+  vpw vnwc vddc vddc vddpe bl[1]_14 nbl[1]_14 nbl[0]_14 bl[0]_14 nbl[2]_13
+  vpw vnwc vddc vddc vddpe bl[1]_13 nbl[1]_13 nbl[0]_13 bl[0]_13 vpw vnwc
+  vddc vddc vddpe bl[1]_12 nbl[1]_12 nbl[0]_12 bl[0]_12 vpw vnwc vddc vddc
+  vddpe bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 nbl[2]_10 bl[2]_10 vpw vnwc
+  vddc vddc vddpe bl[1]_10 nbl[1]_10 nbl[0]_10 bl[0]_10 nbl[2]_9 vpw vnwc
+  vddc vddc vddpe bl[1]_9 nbl[1]_9 nbl[0]_9 bl[0]_9 nbl[2]_8 vpw vnwc vddc
+  vddc vddpe bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 vpw vnwc vddc vddc vddpe
+  bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 vpw vnwc vddc vddc vddpe bl[1]_6 nbl[1]_6
+  nbl[0]_6 bl[0]_6 bl[3]_5 vpw vnwc vddc vddc vddpe bl[1]_5 nbl[1]_5 nbl[0]_5
+  bl[0]_5 vpw vnwc vddc vddc vddpe bl[1]_4 nbl[1]_4 nbl[0]_4 bl[0]_4 nbl[2]_3
+  vpw vnwc vddc vddc vddpe bl[1]_3 nbl[1]_3 nbl[0]_3 bl[0]_3 nbl[2]_2 vpw
+  vnwc vddc vddc vddpe bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 vpw vnwc vddc vddc
+  vddpe bl[1]_1 nbl[1]_1 nbl[0]_1 bl[0]_1 vpw vnwc vddc vddc vddpe bl[1]_0
+  nbl[1]_0 nbl[0]_0 bl[0]_0 vnwp_0 vnwc vpw vnwp_1 vpw vddc vddpe bl[1]_31
+  nbl[1]_31 nbl[0]_31 bl[0]_31 vpw vnwc vddc vddc nbl[1]_30 nbl[0]_30
+  bl[0]_30 bl[3]_29 vpw vnwc vddc vddc nbl[1]_29 nbl[0]_29 bl[0]_29 bl[3]_28
+  vpw vnwc vddc vddc nbl[1]_28 nbl[0]_28 bl[0]_28 bl[3]_27 nbl[3]_27 vpw vnwc
+  vddc vddc nbl[1]_27 nbl[0]_27 bl[0]_27 bl[3]_26 nbl[3]_26 vpw vnwc vddc
+  vddc nbl[1]_26 nbl[0]_26 bl[3]_25 bl[2]_25 vpw vddc nbl[0]_25 bl[3]_24
+  nbl[3]_24 vddc bl[3]_23 vddc bl[3]_22 nbl[3]_22 vddc bl[3]_21 nbl[3]_21
+  bl[3]_20 nbl[3]_20 bl[2]_20 bl[3]_19 nbl[3]_19 bl[2]_19 bl[3]_18 nbl[3]_18
+  bl[2]_18 vddc bl[3]_17 nbl[3]_17 vddc bl[3]_16 nbl[3]_16 bl[3]_15 nbl[3]_15
+  bl[3]_14 nbl[3]_14 bl[2]_14 bl[3]_13 nbl[3]_13 bl[2]_13 bl[3]_12 nbl[3]_12
+  nbl[2]_12 bl[2]_12 bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 bl[3]_10 nbl[3]_10
+  bl[3]_9 nbl[3]_9 bl[2]_9 bl[3]_8 nbl[3]_8 bl[2]_8 bl[3]_7 nbl[3]_7 nbl[2]_7
+  bl[2]_7 bl[3]_6 nbl[3]_6 nbl[2]_6 bl[2]_6 nbl[3]_5 nbl[2]_5 bl[2]_5 bl[3]_4
+  nbl[3]_4 nbl[2]_4 bl[2]_4 bl[3]_3 nbl[3]_3 bl[2]_3 bl[3]_2 nbl[3]_2 bl[2]_2
+  bl[3]_1 nbl[3]_1 nbl[2]_1 bl[2]_1 bl[3]_0 nbl[3]_0 nbl[2]_0 bl[2]_0 wl[1]_2
+  wl[0]_2 rf64x128mem_r_test2row
xmem_r_row_3 vpw vnwc bl[3]_31 nbl[3]_31 nbl[2]_31 bl[2]_31 vnwc vddc bl[3]_30
+  nbl[3]_30 nbl[2]_30 bl[2]_30 vddpe bl[1]_30 nbl[3]_29 nbl[2]_29 bl[2]_29
+  vddpe bl[1]_29 nbl[3]_28 nbl[2]_28 bl[2]_28 vddpe bl[1]_28 nbl[2]_27
+  bl[2]_27 vddpe bl[1]_27 nbl[2]_26 bl[2]_26 vddpe bl[1]_26 bl[0]_26
+  nbl[3]_25 nbl[2]_25 vnwc vddc vddpe bl[1]_25 nbl[1]_25 bl[0]_25 nbl[2]_24
+  bl[2]_24 vssc vpw vnwc vddc vddpe bl[1]_24 nbl[1]_24 nbl[0]_24 bl[0]_24
+  nbl[3]_23 nbl[2]_23 bl[2]_23 vpw vnwc vddc vddpe bl[1]_23 nbl[1]_23
+  nbl[0]_23 bl[0]_23 nbl[2]_22 bl[2]_22 vpw vnwc vddc vddpe bl[1]_22
+  nbl[1]_22 nbl[0]_22 bl[0]_22 nbl[2]_21 bl[2]_21 vpw vnwc vddc vddc vddpe
+  bl[1]_21 nbl[1]_21 nbl[0]_21 bl[0]_21 nbl[2]_20 vpw vnwc vddc vddc vddpe
+  bl[1]_20 nbl[1]_20 nbl[0]_20 bl[0]_20 nbl[2]_19 vpw vnwc vddc vddc vddpe
+  bl[1]_19 nbl[1]_19 nbl[0]_19 bl[0]_19 nbl[2]_18 vpw vnwc vddc vddpe
+  bl[1]_18 nbl[1]_18 nbl[0]_18 bl[0]_18 nbl[2]_17 bl[2]_17 vpw vnwc vddc
+  vddpe bl[1]_17 nbl[1]_17 nbl[0]_17 bl[0]_17 nbl[2]_16 bl[2]_16 vpw vnwc
+  vddc vddc vddpe bl[1]_16 nbl[1]_16 nbl[0]_16 bl[0]_16 nbl[2]_15 bl[2]_15
+  vpw vnwc vddc vddc vddpe bl[1]_15 nbl[1]_15 nbl[0]_15 bl[0]_15 nbl[2]_14
+  vpw vnwc vddc vddc vddpe bl[1]_14 nbl[1]_14 nbl[0]_14 bl[0]_14 nbl[2]_13
+  vpw vnwc vddc vddc vddpe bl[1]_13 nbl[1]_13 nbl[0]_13 bl[0]_13 vpw vnwc
+  vddc vddc vddpe bl[1]_12 nbl[1]_12 nbl[0]_12 bl[0]_12 vpw vnwc vddc vddc
+  vddpe bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 nbl[2]_10 bl[2]_10 vpw vnwc
+  vddc vddc vddpe bl[1]_10 nbl[1]_10 nbl[0]_10 bl[0]_10 nbl[2]_9 vpw vnwc
+  vddc vddc vddpe bl[1]_9 nbl[1]_9 nbl[0]_9 bl[0]_9 nbl[2]_8 vpw vnwc vddc
+  vddc vddpe bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 vpw vnwc vddc vddc vddpe
+  bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 vpw vnwc vddc vddc vddpe bl[1]_6 nbl[1]_6
+  nbl[0]_6 bl[0]_6 bl[3]_5 vpw vnwc vddc vddc vddpe bl[1]_5 nbl[1]_5 nbl[0]_5
+  bl[0]_5 vpw vnwc vddc vddc vddpe bl[1]_4 nbl[1]_4 nbl[0]_4 bl[0]_4 nbl[2]_3
+  vpw vnwc vddc vddc vddpe bl[1]_3 nbl[1]_3 nbl[0]_3 bl[0]_3 nbl[2]_2 vpw
+  vnwc vddc vddc vddpe bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 vpw vnwc vddc vddc
+  vddpe bl[1]_1 nbl[1]_1 nbl[0]_1 bl[0]_1 vpw vnwc vddc vddc vddpe bl[1]_0
+  nbl[1]_0 nbl[0]_0 bl[0]_0 vnwp_0 vnwc vpw vnwp_1 vpw vddc vddpe bl[1]_31
+  nbl[1]_31 nbl[0]_31 bl[0]_31 vpw vnwc vddc vddc nbl[1]_30 nbl[0]_30
+  bl[0]_30 bl[3]_29 vpw vnwc vddc vddc nbl[1]_29 nbl[0]_29 bl[0]_29 bl[3]_28
+  vpw vnwc vddc vddc nbl[1]_28 nbl[0]_28 bl[0]_28 bl[3]_27 nbl[3]_27 vpw vnwc
+  vddc vddc nbl[1]_27 nbl[0]_27 bl[0]_27 bl[3]_26 nbl[3]_26 vpw vnwc vddc
+  vddc nbl[1]_26 nbl[0]_26 bl[3]_25 bl[2]_25 vpw vddc nbl[0]_25 bl[3]_24
+  nbl[3]_24 vddc bl[3]_23 vddc bl[3]_22 nbl[3]_22 vddc bl[3]_21 nbl[3]_21
+  bl[3]_20 nbl[3]_20 bl[2]_20 bl[3]_19 nbl[3]_19 bl[2]_19 bl[3]_18 nbl[3]_18
+  bl[2]_18 vddc bl[3]_17 nbl[3]_17 vddc bl[3]_16 nbl[3]_16 bl[3]_15 nbl[3]_15
+  bl[3]_14 nbl[3]_14 bl[2]_14 bl[3]_13 nbl[3]_13 bl[2]_13 bl[3]_12 nbl[3]_12
+  nbl[2]_12 bl[2]_12 bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 bl[3]_10 nbl[3]_10
+  bl[3]_9 nbl[3]_9 bl[2]_9 bl[3]_8 nbl[3]_8 bl[2]_8 bl[3]_7 nbl[3]_7 nbl[2]_7
+  bl[2]_7 bl[3]_6 nbl[3]_6 nbl[2]_6 bl[2]_6 nbl[3]_5 nbl[2]_5 bl[2]_5 bl[3]_4
+  nbl[3]_4 nbl[2]_4 bl[2]_4 bl[3]_3 nbl[3]_3 bl[2]_3 bl[3]_2 nbl[3]_2 bl[2]_2
+  bl[3]_1 nbl[3]_1 nbl[2]_1 bl[2]_1 bl[3]_0 nbl[3]_0 nbl[2]_0 bl[2]_0 wl[1]_3
+  wl[0]_3 rf64x128mem_r_test3row
xmem_r_row_4 vpw vnwc bl[3]_31 nbl[3]_31 nbl[2]_31 bl[2]_31 vnwc vddc bl[3]_30
+  nbl[3]_30 nbl[2]_30 bl[2]_30 vddpe bl[1]_30 nbl[3]_29 nbl[2]_29 bl[2]_29
+  vddpe bl[1]_29 nbl[3]_28 nbl[2]_28 bl[2]_28 vddpe bl[1]_28 nbl[2]_27
+  bl[2]_27 vddpe bl[1]_27 nbl[2]_26 bl[2]_26 vddpe bl[1]_26 bl[0]_26
+  nbl[3]_25 nbl[2]_25 vnwc vddc vddpe bl[1]_25 nbl[1]_25 bl[0]_25 nbl[2]_24
+  bl[2]_24 vssc vpw vnwc vddc vddpe bl[1]_24 nbl[1]_24 nbl[0]_24 bl[0]_24
+  nbl[3]_23 nbl[2]_23 bl[2]_23 vpw vnwc vddc vddpe bl[1]_23 nbl[1]_23
+  nbl[0]_23 bl[0]_23 nbl[2]_22 bl[2]_22 vpw vnwc vddc vddpe bl[1]_22
+  nbl[1]_22 nbl[0]_22 bl[0]_22 nbl[2]_21 bl[2]_21 vpw vnwc vddc vddc vddpe
+  bl[1]_21 nbl[1]_21 nbl[0]_21 bl[0]_21 nbl[2]_20 vpw vnwc vddc vddc vddpe
+  bl[1]_20 nbl[1]_20 nbl[0]_20 bl[0]_20 nbl[2]_19 vpw vnwc vddc vddc vddpe
+  bl[1]_19 nbl[1]_19 nbl[0]_19 bl[0]_19 nbl[2]_18 vpw vnwc vddc vddpe
+  bl[1]_18 nbl[1]_18 nbl[0]_18 bl[0]_18 nbl[2]_17 bl[2]_17 vpw vnwc vddc
+  vddpe bl[1]_17 nbl[1]_17 nbl[0]_17 bl[0]_17 nbl[2]_16 bl[2]_16 vpw vnwc
+  vddc vddc vddpe bl[1]_16 nbl[1]_16 nbl[0]_16 bl[0]_16 nbl[2]_15 bl[2]_15
+  vpw vnwc vddc vddc vddpe bl[1]_15 nbl[1]_15 nbl[0]_15 bl[0]_15 nbl[2]_14
+  vpw vnwc vddc vddc vddpe bl[1]_14 nbl[1]_14 nbl[0]_14 bl[0]_14 nbl[2]_13
+  vpw vnwc vddc vddc vddpe bl[1]_13 nbl[1]_13 nbl[0]_13 bl[0]_13 vpw vnwc
+  vddc vddc vddpe bl[1]_12 nbl[1]_12 nbl[0]_12 bl[0]_12 vpw vnwc vddc vddc
+  vddpe bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 nbl[2]_10 bl[2]_10 vpw vnwc
+  vddc vddc vddpe bl[1]_10 nbl[1]_10 nbl[0]_10 bl[0]_10 nbl[2]_9 vpw vnwc
+  vddc vddc vddpe bl[1]_9 nbl[1]_9 nbl[0]_9 bl[0]_9 nbl[2]_8 vpw vnwc vddc
+  vddc vddpe bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 vpw vnwc vddc vddc vddpe
+  bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 vpw vnwc vddc vddc vddpe bl[1]_6 nbl[1]_6
+  nbl[0]_6 bl[0]_6 bl[3]_5 vpw vnwc vddc vddc vddpe bl[1]_5 nbl[1]_5 nbl[0]_5
+  bl[0]_5 vpw vnwc vddc vddc vddpe bl[1]_4 nbl[1]_4 nbl[0]_4 bl[0]_4 nbl[2]_3
+  vpw vnwc vddc vddc vddpe bl[1]_3 nbl[1]_3 nbl[0]_3 bl[0]_3 nbl[2]_2 vpw
+  vnwc vddc vddc vddpe bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 vpw vnwc vddc vddc
+  vddpe bl[1]_1 nbl[1]_1 nbl[0]_1 bl[0]_1 vpw vnwc vddc vddc vddpe bl[1]_0
+  nbl[1]_0 nbl[0]_0 bl[0]_0 vnwp_0 vnwc vpw vnwp_1 vpw vddc vddpe bl[1]_31
+  nbl[1]_31 nbl[0]_31 bl[0]_31 vpw vnwc vddc vddc nbl[1]_30 nbl[0]_30
+  bl[0]_30 bl[3]_29 vpw vnwc vddc vddc nbl[1]_29 nbl[0]_29 bl[0]_29 bl[3]_28
+  vpw vnwc vddc vddc nbl[1]_28 nbl[0]_28 bl[0]_28 bl[3]_27 nbl[3]_27 vpw vnwc
+  vddc vddc nbl[1]_27 nbl[0]_27 bl[0]_27 bl[3]_26 nbl[3]_26 vpw vnwc vddc
+  vddc nbl[1]_26 nbl[0]_26 bl[3]_25 bl[2]_25 vpw vddc nbl[0]_25 bl[3]_24
+  nbl[3]_24 vddc bl[3]_23 vddc bl[3]_22 nbl[3]_22 vddc bl[3]_21 nbl[3]_21
+  bl[3]_20 nbl[3]_20 bl[2]_20 bl[3]_19 nbl[3]_19 bl[2]_19 bl[3]_18 nbl[3]_18
+  bl[2]_18 vddc bl[3]_17 nbl[3]_17 vddc bl[3]_16 nbl[3]_16 bl[3]_15 nbl[3]_15
+  bl[3]_14 nbl[3]_14 bl[2]_14 bl[3]_13 nbl[3]_13 bl[2]_13 bl[3]_12 nbl[3]_12
+  nbl[2]_12 bl[2]_12 bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 bl[3]_10 nbl[3]_10
+  bl[3]_9 nbl[3]_9 bl[2]_9 bl[3]_8 nbl[3]_8 bl[2]_8 bl[3]_7 nbl[3]_7 nbl[2]_7
+  bl[2]_7 bl[3]_6 nbl[3]_6 nbl[2]_6 bl[2]_6 nbl[3]_5 nbl[2]_5 bl[2]_5 bl[3]_4
+  nbl[3]_4 nbl[2]_4 bl[2]_4 bl[3]_3 nbl[3]_3 bl[2]_3 bl[3]_2 nbl[3]_2 bl[2]_2
+  bl[3]_1 nbl[3]_1 nbl[2]_1 bl[2]_1 bl[3]_0 nbl[3]_0 nbl[2]_0 bl[2]_0 wl[1]_4
+  wl[0]_4 rf64x128mem_r_test4row
xmem_r_row_5 vpw vnwc bl[3]_31 nbl[3]_31 nbl[2]_31 bl[2]_31 vnwc vddc bl[3]_30
+  nbl[3]_30 nbl[2]_30 bl[2]_30 vddpe bl[1]_30 nbl[3]_29 nbl[2]_29 bl[2]_29
+  vddpe bl[1]_29 nbl[3]_28 nbl[2]_28 bl[2]_28 vddpe bl[1]_28 nbl[2]_27
+  bl[2]_27 vddpe bl[1]_27 nbl[2]_26 bl[2]_26 vddpe bl[1]_26 bl[0]_26
+  nbl[3]_25 nbl[2]_25 vnwc vddc vddpe bl[1]_25 nbl[1]_25 bl[0]_25 nbl[2]_24
+  bl[2]_24 vssc vpw vnwc vddc vddpe bl[1]_24 nbl[1]_24 nbl[0]_24 bl[0]_24
+  nbl[3]_23 nbl[2]_23 bl[2]_23 vpw vnwc vddc vddpe bl[1]_23 nbl[1]_23
+  nbl[0]_23 bl[0]_23 nbl[2]_22 bl[2]_22 vpw vnwc vddc vddpe bl[1]_22
+  nbl[1]_22 nbl[0]_22 bl[0]_22 nbl[2]_21 bl[2]_21 vpw vnwc vddc vddc vddpe
+  bl[1]_21 nbl[1]_21 nbl[0]_21 bl[0]_21 nbl[2]_20 vpw vnwc vddc vddc vddpe
+  bl[1]_20 nbl[1]_20 nbl[0]_20 bl[0]_20 nbl[2]_19 vpw vnwc vddc vddc vddpe
+  bl[1]_19 nbl[1]_19 nbl[0]_19 bl[0]_19 nbl[2]_18 vpw vnwc vddc vddpe
+  bl[1]_18 nbl[1]_18 nbl[0]_18 bl[0]_18 nbl[2]_17 bl[2]_17 vpw vnwc vddc
+  vddpe bl[1]_17 nbl[1]_17 nbl[0]_17 bl[0]_17 nbl[2]_16 bl[2]_16 vpw vnwc
+  vddc vddc vddpe bl[1]_16 nbl[1]_16 nbl[0]_16 bl[0]_16 nbl[2]_15 bl[2]_15
+  vpw vnwc vddc vddc vddpe bl[1]_15 nbl[1]_15 nbl[0]_15 bl[0]_15 nbl[2]_14
+  vpw vnwc vddc vddc vddpe bl[1]_14 nbl[1]_14 nbl[0]_14 bl[0]_14 nbl[2]_13
+  vpw vnwc vddc vddc vddpe bl[1]_13 nbl[1]_13 nbl[0]_13 bl[0]_13 vpw vnwc
+  vddc vddc vddpe bl[1]_12 nbl[1]_12 nbl[0]_12 bl[0]_12 vpw vnwc vddc vddc
+  vddpe bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 nbl[2]_10 bl[2]_10 vpw vnwc
+  vddc vddc vddpe bl[1]_10 nbl[1]_10 nbl[0]_10 bl[0]_10 nbl[2]_9 vpw vnwc
+  vddc vddc vddpe bl[1]_9 nbl[1]_9 nbl[0]_9 bl[0]_9 nbl[2]_8 vpw vnwc vddc
+  vddc vddpe bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 vpw vnwc vddc vddc vddpe
+  bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 vpw vnwc vddc vddc vddpe bl[1]_6 nbl[1]_6
+  nbl[0]_6 bl[0]_6 bl[3]_5 vpw vnwc vddc vddc vddpe bl[1]_5 nbl[1]_5 nbl[0]_5
+  bl[0]_5 vpw vnwc vddc vddc vddpe bl[1]_4 nbl[1]_4 nbl[0]_4 bl[0]_4 nbl[2]_3
+  vpw vnwc vddc vddc vddpe bl[1]_3 nbl[1]_3 nbl[0]_3 bl[0]_3 nbl[2]_2 vpw
+  vnwc vddc vddc vddpe bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 vpw vnwc vddc vddc
+  vddpe bl[1]_1 nbl[1]_1 nbl[0]_1 bl[0]_1 vpw vnwc vddc vddc vddpe bl[1]_0
+  nbl[1]_0 nbl[0]_0 bl[0]_0 vnwp_0 vnwc vpw vnwp_1 vpw vddc vddpe bl[1]_31
+  nbl[1]_31 nbl[0]_31 bl[0]_31 vpw vnwc vddc vddc nbl[1]_30 nbl[0]_30
+  bl[0]_30 bl[3]_29 vpw vnwc vddc vddc nbl[1]_29 nbl[0]_29 bl[0]_29 bl[3]_28
+  vpw vnwc vddc vddc nbl[1]_28 nbl[0]_28 bl[0]_28 bl[3]_27 nbl[3]_27 vpw vnwc
+  vddc vddc nbl[1]_27 nbl[0]_27 bl[0]_27 bl[3]_26 nbl[3]_26 vpw vnwc vddc
+  vddc nbl[1]_26 nbl[0]_26 bl[3]_25 bl[2]_25 vpw vddc nbl[0]_25 bl[3]_24
+  nbl[3]_24 vddc bl[3]_23 vddc bl[3]_22 nbl[3]_22 vddc bl[3]_21 nbl[3]_21
+  bl[3]_20 nbl[3]_20 bl[2]_20 bl[3]_19 nbl[3]_19 bl[2]_19 bl[3]_18 nbl[3]_18
+  bl[2]_18 vddc bl[3]_17 nbl[3]_17 vddc bl[3]_16 nbl[3]_16 bl[3]_15 nbl[3]_15
+  bl[3]_14 nbl[3]_14 bl[2]_14 bl[3]_13 nbl[3]_13 bl[2]_13 bl[3]_12 nbl[3]_12
+  nbl[2]_12 bl[2]_12 bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 bl[3]_10 nbl[3]_10
+  bl[3]_9 nbl[3]_9 bl[2]_9 bl[3]_8 nbl[3]_8 bl[2]_8 bl[3]_7 nbl[3]_7 nbl[2]_7
+  bl[2]_7 bl[3]_6 nbl[3]_6 nbl[2]_6 bl[2]_6 nbl[3]_5 nbl[2]_5 bl[2]_5 bl[3]_4
+  nbl[3]_4 nbl[2]_4 bl[2]_4 bl[3]_3 nbl[3]_3 bl[2]_3 bl[3]_2 nbl[3]_2 bl[2]_2
+  bl[3]_1 nbl[3]_1 nbl[2]_1 bl[2]_1 bl[3]_0 nbl[3]_0 nbl[2]_0 bl[2]_0 wl[1]_5
+  wl[0]_5 rf64x128mem_r_test5row
xmem_r_row_9 vpw vnwc bl[3]_31 nbl[3]_31 nbl[2]_31 bl[2]_31 vnwc vddc bl[3]_30
+  nbl[3]_30 nbl[2]_30 bl[2]_30 vddpe bl[1]_30 nbl[3]_29 nbl[2]_29 bl[2]_29
+  vddpe bl[1]_29 nbl[3]_28 nbl[2]_28 bl[2]_28 vddpe bl[1]_28 nbl[2]_27
+  bl[2]_27 vddpe bl[1]_27 nbl[2]_26 bl[2]_26 vddpe bl[1]_26 bl[0]_26
+  nbl[3]_25 nbl[2]_25 vnwc vddc vddpe bl[1]_25 nbl[1]_25 bl[0]_25 nbl[2]_24
+  bl[2]_24 vssc vpw vnwc vddc vddpe bl[1]_24 nbl[1]_24 nbl[0]_24 bl[0]_24
+  nbl[3]_23 nbl[2]_23 bl[2]_23 vpw vnwc vddc vddpe bl[1]_23 nbl[1]_23
+  nbl[0]_23 bl[0]_23 nbl[2]_22 bl[2]_22 vpw vnwc vddc vddpe bl[1]_22
+  nbl[1]_22 nbl[0]_22 bl[0]_22 nbl[2]_21 bl[2]_21 vpw vnwc vddc vddc vddpe
+  bl[1]_21 nbl[1]_21 nbl[0]_21 bl[0]_21 nbl[2]_20 vpw vnwc vddc vddc vddpe
+  bl[1]_20 nbl[1]_20 nbl[0]_20 bl[0]_20 nbl[2]_19 vpw vnwc vddc vddc vddpe
+  bl[1]_19 nbl[1]_19 nbl[0]_19 bl[0]_19 nbl[2]_18 vpw vnwc vddc vddpe
+  bl[1]_18 nbl[1]_18 nbl[0]_18 bl[0]_18 nbl[2]_17 bl[2]_17 vpw vnwc vddc
+  vddpe bl[1]_17 nbl[1]_17 nbl[0]_17 bl[0]_17 nbl[2]_16 bl[2]_16 vpw vnwc
+  vddc vddc vddpe bl[1]_16 nbl[1]_16 nbl[0]_16 bl[0]_16 nbl[2]_15 bl[2]_15
+  vpw vnwc vddc vddc vddpe bl[1]_15 nbl[1]_15 nbl[0]_15 bl[0]_15 nbl[2]_14
+  vpw vnwc vddc vddc vddpe bl[1]_14 nbl[1]_14 nbl[0]_14 bl[0]_14 nbl[2]_13
+  vpw vnwc vddc vddc vddpe bl[1]_13 nbl[1]_13 nbl[0]_13 bl[0]_13 vpw vnwc
+  vddc vddc vddpe bl[1]_12 nbl[1]_12 nbl[0]_12 bl[0]_12 vpw vnwc vddc vddc
+  vddpe bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 nbl[2]_10 bl[2]_10 vpw vnwc
+  vddc vddc vddpe bl[1]_10 nbl[1]_10 nbl[0]_10 bl[0]_10 nbl[2]_9 vpw vnwc
+  vddc vddc vddpe bl[1]_9 nbl[1]_9 nbl[0]_9 bl[0]_9 nbl[2]_8 vpw vnwc vddc
+  vddc vddpe bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 vpw vnwc vddc vddc vddpe
+  bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 vpw vnwc vddc vddc vddpe bl[1]_6 nbl[1]_6
+  nbl[0]_6 bl[0]_6 bl[3]_5 vpw vnwc vddc vddc vddpe bl[1]_5 nbl[1]_5 nbl[0]_5
+  bl[0]_5 vpw vnwc vddc vddc vddpe bl[1]_4 nbl[1]_4 nbl[0]_4 bl[0]_4 nbl[2]_3
+  vpw vnwc vddc vddc vddpe bl[1]_3 nbl[1]_3 nbl[0]_3 bl[0]_3 nbl[2]_2 vpw
+  vnwc vddc vddc vddpe bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 vpw vnwc vddc vddc
+  vddpe bl[1]_1 nbl[1]_1 nbl[0]_1 bl[0]_1 vpw vnwc vddc vddc vddpe bl[1]_0
+  nbl[1]_0 nbl[0]_0 bl[0]_0 vnwp_0 vnwc vpw vnwp_1 vpw vddc vddpe bl[1]_31
+  nbl[1]_31 nbl[0]_31 bl[0]_31 vpw vnwc vddc vddc nbl[1]_30 nbl[0]_30
+  bl[0]_30 bl[3]_29 vpw vnwc vddc vddc nbl[1]_29 nbl[0]_29 bl[0]_29 bl[3]_28
+  vpw vnwc vddc vddc nbl[1]_28 nbl[0]_28 bl[0]_28 bl[3]_27 nbl[3]_27 vpw vnwc
+  vddc vddc nbl[1]_27 nbl[0]_27 bl[0]_27 bl[3]_26 nbl[3]_26 vpw vnwc vddc
+  vddc nbl[1]_26 nbl[0]_26 bl[3]_25 bl[2]_25 vpw vddc nbl[0]_25 bl[3]_24
+  nbl[3]_24 vddc bl[3]_23 vddc bl[3]_22 nbl[3]_22 vddc bl[3]_21 nbl[3]_21
+  bl[3]_20 nbl[3]_20 bl[2]_20 bl[3]_19 nbl[3]_19 bl[2]_19 bl[3]_18 nbl[3]_18
+  bl[2]_18 vddc bl[3]_17 nbl[3]_17 vddc bl[3]_16 nbl[3]_16 bl[3]_15 nbl[3]_15
+  bl[3]_14 nbl[3]_14 bl[2]_14 bl[3]_13 nbl[3]_13 bl[2]_13 bl[3]_12 nbl[3]_12
+  nbl[2]_12 bl[2]_12 bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 bl[3]_10 nbl[3]_10
+  bl[3]_9 nbl[3]_9 bl[2]_9 bl[3]_8 nbl[3]_8 bl[2]_8 bl[3]_7 nbl[3]_7 nbl[2]_7
+  bl[2]_7 bl[3]_6 nbl[3]_6 nbl[2]_6 bl[2]_6 nbl[3]_5 nbl[2]_5 bl[2]_5 bl[3]_4
+  nbl[3]_4 nbl[2]_4 bl[2]_4 bl[3]_3 nbl[3]_3 bl[2]_3 bl[3]_2 nbl[3]_2 bl[2]_2
+  bl[3]_1 nbl[3]_1 nbl[2]_1 bl[2]_1 bl[3]_0 nbl[3]_0 nbl[2]_0 bl[2]_0 wl[1]_9
+  wl[0]_9 rf64x128mem_r_test9row
xmem_r_row_bot vpw vnwc bl[3]_31 nbl[3]_31 nbl[2]_31 bl[2]_31 vnwc vddc
+  bl[3]_30 nbl[3]_30 nbl[2]_30 bl[2]_30 vddpe bl[1]_30 nbl[3]_29 nbl[2]_29
+  bl[2]_29 vddpe bl[1]_29 nbl[3]_28 nbl[2]_28 bl[2]_28 vddpe bl[1]_28
+  nbl[2]_27 bl[2]_27 vddpe bl[1]_27 nbl[2]_26 bl[2]_26 vddpe bl[1]_26
+  bl[0]_26 nbl[3]_25 nbl[2]_25 vnwc vddc vddpe bl[1]_25 nbl[1]_25 bl[0]_25
+  nbl[2]_24 bl[2]_24 vssc vpw vnwc vddc vddpe bl[1]_24 nbl[1]_24 nbl[0]_24
+  bl[0]_24 nbl[3]_23 nbl[2]_23 bl[2]_23 vpw vnwc vddc vddpe bl[1]_23
+  nbl[1]_23 nbl[0]_23 bl[0]_23 nbl[2]_22 bl[2]_22 vpw vnwc vddc vddpe
+  bl[1]_22 nbl[1]_22 nbl[0]_22 bl[0]_22 nbl[2]_21 bl[2]_21 vpw vnwc vddc vddc
+  vddpe bl[1]_21 nbl[1]_21 nbl[0]_21 bl[0]_21 nbl[2]_20 vpw vnwc vddc vddc
+  vddpe bl[1]_20 nbl[1]_20 nbl[0]_20 bl[0]_20 nbl[2]_19 vpw vnwc vddc vddc
+  vddpe bl[1]_19 nbl[1]_19 nbl[0]_19 bl[0]_19 nbl[2]_18 vpw vnwc vddc vddpe
+  bl[1]_18 nbl[1]_18 nbl[0]_18 bl[0]_18 nbl[2]_17 bl[2]_17 vpw vnwc vddc
+  vddpe bl[1]_17 nbl[1]_17 nbl[0]_17 bl[0]_17 nbl[2]_16 bl[2]_16 vpw vnwc
+  vddc vddc vddpe bl[1]_16 nbl[1]_16 nbl[0]_16 bl[0]_16 nbl[2]_15 bl[2]_15
+  vpw vnwc vddc vddc vddpe bl[1]_15 nbl[1]_15 nbl[0]_15 bl[0]_15 nbl[2]_14
+  vpw vnwc vddc vddc vddpe bl[1]_14 nbl[1]_14 nbl[0]_14 bl[0]_14 nbl[2]_13
+  vpw vnwc vddc vddc vddpe bl[1]_13 nbl[1]_13 nbl[0]_13 bl[0]_13 vpw vnwc
+  vddc vddc vddpe bl[1]_12 nbl[1]_12 nbl[0]_12 bl[0]_12 vpw vnwc vddc vddc
+  vddpe bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 nbl[2]_10 bl[2]_10 vpw vnwc
+  vddc vddc vddpe bl[1]_10 nbl[1]_10 nbl[0]_10 bl[0]_10 nbl[2]_9 vpw vnwc
+  vddc vddc vddpe bl[1]_9 nbl[1]_9 nbl[0]_9 bl[0]_9 nbl[2]_8 vpw vnwc vddc
+  vddc vddpe bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 vpw vnwc vddc vddc vddpe
+  bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 vpw vnwc vddc vddc vddpe bl[1]_6 nbl[1]_6
+  nbl[0]_6 bl[0]_6 bl[3]_5 vpw vnwc vddc vddc vddpe bl[1]_5 nbl[1]_5 nbl[0]_5
+  bl[0]_5 vpw vnwc vddc vddc vddpe bl[1]_4 nbl[1]_4 nbl[0]_4 bl[0]_4 nbl[2]_3
+  vpw vnwc vddc vddc vddpe bl[1]_3 nbl[1]_3 nbl[0]_3 bl[0]_3 nbl[2]_2 vpw
+  vnwc vddc vddc vddpe bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 vpw vnwc vddc vddc
+  vddpe bl[1]_1 nbl[1]_1 nbl[0]_1 bl[0]_1 vpw vssc vnwc vddc vddc vddpe
+  bl[1]_0 nbl[1]_0 nbl[0]_0 bl[0]_0 vnwp_0 vnwc vpw vnwp_1 vpw vssc vddc
+  vddpe bl[1]_31 nbl[1]_31 nbl[0]_31 bl[0]_31 vpw vnwc vddc vddc nbl[1]_30
+  nbl[0]_30 bl[0]_30 bl[3]_29 vpw vnwc vddc vddc nbl[1]_29 nbl[0]_29 bl[0]_29
+  bl[3]_28 vpw vnwc vddc vddc nbl[1]_28 nbl[0]_28 bl[0]_28 bl[3]_27 nbl[3]_27
+  vpw vnwc vddc vddc nbl[1]_27 nbl[0]_27 bl[0]_27 bl[3]_26 nbl[3]_26 vpw vnwc
+  vddc vddc nbl[1]_26 nbl[0]_26 bl[3]_25 bl[2]_25 vpw vddc nbl[0]_25 bl[3]_24
+  nbl[3]_24 vddc bl[3]_23 vddc bl[3]_22 nbl[3]_22 vddc bl[3]_21 nbl[3]_21
+  bl[3]_20 nbl[3]_20 bl[2]_20 bl[3]_19 nbl[3]_19 bl[2]_19 bl[3]_18 nbl[3]_18
+  bl[2]_18 vddc bl[3]_17 nbl[3]_17 vddc bl[3]_16 nbl[3]_16 bl[3]_15 nbl[3]_15
+  bl[3]_14 nbl[3]_14 bl[2]_14 bl[3]_13 nbl[3]_13 bl[2]_13 bl[3]_12 nbl[3]_12
+  nbl[2]_12 bl[2]_12 bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 bl[3]_10 nbl[3]_10
+  bl[3]_9 nbl[3]_9 bl[2]_9 bl[3]_8 nbl[3]_8 bl[2]_8 bl[3]_7 nbl[3]_7 nbl[2]_7
+  bl[2]_7 bl[3]_6 nbl[3]_6 nbl[2]_6 bl[2]_6 nbl[3]_5 nbl[2]_5 bl[2]_5 bl[3]_4
+  nbl[3]_4 nbl[2]_4 bl[2]_4 bl[3]_3 nbl[3]_3 bl[2]_3 bl[3]_2 nbl[3]_2 bl[2]_2
+  bl[3]_1 nbl[3]_1 nbl[2]_1 bl[2]_1 bl[3]_0 nbl[3]_0 nbl[2]_0 bl[2]_0 wl[1]_0
+  wl[0]_0 rf64x128mem_r_bot_row
xmem_r_row_mid vpw vnwc bl[3]_31 nbl[3]_31 nbl[2]_31 bl[2]_31 vnwc vddc
+  bl[3]_30 nbl[3]_30 nbl[2]_30 bl[2]_30 vddpe bl[1]_30 nbl[3]_29 nbl[2]_29
+  bl[2]_29 vddpe bl[1]_29 nbl[3]_28 nbl[2]_28 bl[2]_28 vddpe bl[1]_28
+  nbl[2]_27 bl[2]_27 vddpe bl[1]_27 nbl[2]_26 bl[2]_26 vddpe bl[1]_26
+  bl[0]_26 nbl[3]_25 nbl[2]_25 vnwc vddc vddpe bl[1]_25 nbl[1]_25 bl[0]_25
+  nbl[2]_24 bl[2]_24 vssc vpw vnwc vddc vddpe bl[1]_24 nbl[1]_24 nbl[0]_24
+  bl[0]_24 nbl[3]_23 nbl[2]_23 bl[2]_23 vpw vnwc vddc vddpe bl[1]_23
+  nbl[1]_23 nbl[0]_23 bl[0]_23 nbl[2]_22 bl[2]_22 vpw vnwc vddc vddpe
+  bl[1]_22 nbl[1]_22 nbl[0]_22 bl[0]_22 nbl[2]_21 bl[2]_21 vpw vnwc vddc vddc
+  vddpe bl[1]_21 nbl[1]_21 nbl[0]_21 bl[0]_21 nbl[2]_20 vpw vnwc vddc vddc
+  vddpe bl[1]_20 nbl[1]_20 nbl[0]_20 bl[0]_20 nbl[2]_19 vpw vnwc vddc vddc
+  vddpe bl[1]_19 nbl[1]_19 nbl[0]_19 bl[0]_19 nbl[2]_18 vpw vnwc vddc vddpe
+  bl[1]_18 nbl[1]_18 nbl[0]_18 bl[0]_18 nbl[2]_17 bl[2]_17 vpw vnwc vddc
+  vddpe bl[1]_17 nbl[1]_17 nbl[0]_17 bl[0]_17 nbl[2]_16 bl[2]_16 vpw vnwc
+  vddc vddc vddpe bl[1]_16 nbl[1]_16 nbl[0]_16 bl[0]_16 nbl[2]_15 bl[2]_15
+  vpw vnwc vddc vddc vddpe bl[1]_15 nbl[1]_15 nbl[0]_15 bl[0]_15 nbl[2]_14
+  vpw vnwc vddc vddc vddpe bl[1]_14 nbl[1]_14 nbl[0]_14 bl[0]_14 nbl[2]_13
+  vpw vnwc vddc vddc vddpe bl[1]_13 nbl[1]_13 nbl[0]_13 bl[0]_13 vpw vnwc
+  vddc vddc vddpe bl[1]_12 nbl[1]_12 nbl[0]_12 bl[0]_12 vpw vnwc vddc vddc
+  vddpe bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 nbl[2]_10 bl[2]_10 vpw vnwc
+  vddc vddc vddpe bl[1]_10 nbl[1]_10 nbl[0]_10 bl[0]_10 nbl[2]_9 vpw vnwc
+  vddc vddc vddpe bl[1]_9 nbl[1]_9 nbl[0]_9 bl[0]_9 nbl[2]_8 vpw vnwc vddc
+  vddc vddpe bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 vpw vnwc vddc vddc vddpe
+  bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 vpw vnwc vddc vddc vddpe bl[1]_6 nbl[1]_6
+  nbl[0]_6 bl[0]_6 bl[3]_5 vpw vnwc vddc vddc vddpe bl[1]_5 nbl[1]_5 nbl[0]_5
+  bl[0]_5 vpw vnwc vddc vddc vddpe bl[1]_4 nbl[1]_4 nbl[0]_4 bl[0]_4 nbl[2]_3
+  vpw vnwc vddc vddc vddpe bl[1]_3 nbl[1]_3 nbl[0]_3 bl[0]_3 nbl[2]_2 vpw
+  vnwc vddc vddc vddpe bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 vpw vnwc vddc vddc
+  vddpe bl[1]_1 nbl[1]_1 nbl[0]_1 bl[0]_1 vpw vnwc vddc vddc vddpe bl[1]_0
+  nbl[1]_0 nbl[0]_0 bl[0]_0 vnwp_0 vnwc vpw vnwp_1 vpw vddc vddpe bl[1]_31
+  nbl[1]_31 nbl[0]_31 bl[0]_31 vpw vnwc vddc vddc nbl[1]_30 nbl[0]_30
+  bl[0]_30 bl[3]_29 vpw vnwc vddc vddc nbl[1]_29 nbl[0]_29 bl[0]_29 bl[3]_28
+  vpw vnwc vddc vddc nbl[1]_28 nbl[0]_28 bl[0]_28 bl[3]_27 nbl[3]_27 vpw vnwc
+  vddc vddc nbl[1]_27 nbl[0]_27 bl[0]_27 bl[3]_26 nbl[3]_26 vpw vnwc vddc
+  vddc nbl[1]_26 nbl[0]_26 bl[3]_25 bl[2]_25 vpw vddc nbl[0]_25 bl[3]_24
+  nbl[3]_24 vddc bl[3]_23 vddc bl[3]_22 nbl[3]_22 vddc bl[3]_21 nbl[3]_21
+  bl[3]_20 nbl[3]_20 bl[2]_20 bl[3]_19 nbl[3]_19 bl[2]_19 bl[3]_18 nbl[3]_18
+  bl[2]_18 vddc bl[3]_17 nbl[3]_17 vddc bl[3]_16 nbl[3]_16 bl[3]_15 nbl[3]_15
+  bl[3]_14 nbl[3]_14 bl[2]_14 bl[3]_13 nbl[3]_13 bl[2]_13 bl[3]_12 nbl[3]_12
+  nbl[2]_12 bl[2]_12 bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 bl[3]_10 nbl[3]_10
+  bl[3]_9 nbl[3]_9 bl[2]_9 bl[3]_8 nbl[3]_8 bl[2]_8 bl[3]_7 nbl[3]_7 nbl[2]_7
+  bl[2]_7 bl[3]_6 nbl[3]_6 nbl[2]_6 bl[2]_6 nbl[3]_5 nbl[2]_5 bl[2]_5 bl[3]_4
+  nbl[3]_4 nbl[2]_4 bl[2]_4 bl[3]_3 nbl[3]_3 bl[2]_3 bl[3]_2 nbl[3]_2 bl[2]_2
+  bl[3]_1 nbl[3]_1 nbl[2]_1 bl[2]_1 bl[3]_0 nbl[3]_0 nbl[2]_0 bl[2]_0 wl[1]_7
+  wl[0]_7 rf64x128mem_r_mid_row
xmem_r_row_midb vpw vnwc bl[3]_31 nbl[3]_31 nbl[2]_31 bl[2]_31 vnwc vddc
+  bl[3]_30 nbl[3]_30 nbl[2]_30 bl[2]_30 vddpe bl[1]_30 nbl[3]_29 nbl[2]_29
+  bl[2]_29 vddpe bl[1]_29 nbl[3]_28 nbl[2]_28 bl[2]_28 vddpe bl[1]_28
+  nbl[2]_27 bl[2]_27 vddpe bl[1]_27 nbl[2]_26 bl[2]_26 vddpe bl[1]_26
+  bl[0]_26 nbl[3]_25 nbl[2]_25 vnwc vddc vddpe bl[1]_25 nbl[1]_25 bl[0]_25
+  nbl[2]_24 bl[2]_24 vssc vpw vnwc vddc vddpe bl[1]_24 nbl[1]_24 nbl[0]_24
+  bl[0]_24 nbl[3]_23 nbl[2]_23 bl[2]_23 vpw vnwc vddc vddpe bl[1]_23
+  nbl[1]_23 nbl[0]_23 bl[0]_23 nbl[2]_22 bl[2]_22 vpw vnwc vddc vddpe
+  bl[1]_22 nbl[1]_22 nbl[0]_22 bl[0]_22 nbl[2]_21 bl[2]_21 vpw vnwc vddc vddc
+  vddpe bl[1]_21 nbl[1]_21 nbl[0]_21 bl[0]_21 nbl[2]_20 vpw vnwc vddc vddc
+  vddpe bl[1]_20 nbl[1]_20 nbl[0]_20 bl[0]_20 nbl[2]_19 vpw vnwc vddc vddc
+  vddpe bl[1]_19 nbl[1]_19 nbl[0]_19 bl[0]_19 nbl[2]_18 vpw vnwc vddc vddpe
+  bl[1]_18 nbl[1]_18 nbl[0]_18 bl[0]_18 nbl[2]_17 bl[2]_17 vpw vnwc vddc
+  vddpe bl[1]_17 nbl[1]_17 nbl[0]_17 bl[0]_17 nbl[2]_16 bl[2]_16 vpw vnwc
+  vddc vddc vddpe bl[1]_16 nbl[1]_16 nbl[0]_16 bl[0]_16 nbl[2]_15 bl[2]_15
+  vpw vnwc vddc vddc vddpe bl[1]_15 nbl[1]_15 nbl[0]_15 bl[0]_15 nbl[2]_14
+  vpw vnwc vddc vddc vddpe bl[1]_14 nbl[1]_14 nbl[0]_14 bl[0]_14 nbl[2]_13
+  vpw vnwc vddc vddc vddpe bl[1]_13 nbl[1]_13 nbl[0]_13 bl[0]_13 vpw vnwc
+  vddc vddc vddpe bl[1]_12 nbl[1]_12 nbl[0]_12 bl[0]_12 vpw vnwc vddc vddc
+  vddpe bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 nbl[2]_10 bl[2]_10 vpw vnwc
+  vddc vddc vddpe bl[1]_10 nbl[1]_10 nbl[0]_10 bl[0]_10 nbl[2]_9 vpw vnwc
+  vddc vddc vddpe bl[1]_9 nbl[1]_9 nbl[0]_9 bl[0]_9 nbl[2]_8 vpw vnwc vddc
+  vddc vddpe bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 vpw vnwc vddc vddc vddpe
+  bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 vpw vnwc vddc vddc vddpe bl[1]_6 nbl[1]_6
+  nbl[0]_6 bl[0]_6 bl[3]_5 vpw vnwc vddc vddc vddpe bl[1]_5 nbl[1]_5 nbl[0]_5
+  bl[0]_5 vpw vnwc vddc vddc vddpe bl[1]_4 nbl[1]_4 nbl[0]_4 bl[0]_4 nbl[2]_3
+  vpw vnwc vddc vddc vddpe bl[1]_3 nbl[1]_3 nbl[0]_3 bl[0]_3 nbl[2]_2 vpw
+  vnwc vddc vddc vddpe bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 vpw vnwc vddc vddc
+  vddpe bl[1]_1 nbl[1]_1 nbl[0]_1 bl[0]_1 vpw vnwc vddc vddc vddpe bl[1]_0
+  nbl[1]_0 nbl[0]_0 bl[0]_0 vnwp_0 vnwc vpw vnwp_1 vpw vddc vddpe bl[1]_31
+  nbl[1]_31 nbl[0]_31 bl[0]_31 vpw vnwc vddc vddc nbl[1]_30 nbl[0]_30
+  bl[0]_30 bl[3]_29 vpw vnwc vddc vddc nbl[1]_29 nbl[0]_29 bl[0]_29 bl[3]_28
+  vpw vnwc vddc vddc nbl[1]_28 nbl[0]_28 bl[0]_28 bl[3]_27 nbl[3]_27 vpw vnwc
+  vddc vddc nbl[1]_27 nbl[0]_27 bl[0]_27 bl[3]_26 nbl[3]_26 vpw vnwc vddc
+  vddc nbl[1]_26 nbl[0]_26 bl[3]_25 bl[2]_25 vpw vddc nbl[0]_25 bl[3]_24
+  nbl[3]_24 vddc bl[3]_23 vddc bl[3]_22 nbl[3]_22 vddc bl[3]_21 nbl[3]_21
+  bl[3]_20 nbl[3]_20 bl[2]_20 bl[3]_19 nbl[3]_19 bl[2]_19 bl[3]_18 nbl[3]_18
+  bl[2]_18 vddc bl[3]_17 nbl[3]_17 vddc bl[3]_16 nbl[3]_16 bl[3]_15 nbl[3]_15
+  bl[3]_14 nbl[3]_14 bl[2]_14 bl[3]_13 nbl[3]_13 bl[2]_13 bl[3]_12 nbl[3]_12
+  nbl[2]_12 bl[2]_12 bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 bl[3]_10 nbl[3]_10
+  bl[3]_9 nbl[3]_9 bl[2]_9 bl[3]_8 nbl[3]_8 bl[2]_8 bl[3]_7 nbl[3]_7 nbl[2]_7
+  bl[2]_7 bl[3]_6 nbl[3]_6 nbl[2]_6 bl[2]_6 nbl[3]_5 nbl[2]_5 bl[2]_5 bl[3]_4
+  nbl[3]_4 nbl[2]_4 bl[2]_4 bl[3]_3 nbl[3]_3 bl[2]_3 bl[3]_2 nbl[3]_2 bl[2]_2
+  bl[3]_1 nbl[3]_1 nbl[2]_1 bl[2]_1 bl[3]_0 nbl[3]_0 nbl[2]_0 bl[2]_0 wl[1]_6
+  wl[0]_6 rf64x128mem_r_midb_row
xmem_r_row_midt vpw vnwc bl[3]_31 nbl[3]_31 nbl[2]_31 bl[2]_31 vnwc vddc
+  bl[3]_30 nbl[3]_30 nbl[2]_30 bl[2]_30 vddpe bl[1]_30 nbl[3]_29 nbl[2]_29
+  bl[2]_29 vddpe bl[1]_29 nbl[3]_28 nbl[2]_28 bl[2]_28 vddpe bl[1]_28
+  nbl[2]_27 bl[2]_27 vddpe bl[1]_27 nbl[2]_26 bl[2]_26 vddpe bl[1]_26
+  bl[0]_26 nbl[3]_25 nbl[2]_25 vnwc vddc vddpe bl[1]_25 nbl[1]_25 bl[0]_25
+  nbl[2]_24 bl[2]_24 vssc vpw vnwc vddc vddpe bl[1]_24 nbl[1]_24 nbl[0]_24
+  bl[0]_24 nbl[3]_23 nbl[2]_23 bl[2]_23 vpw vnwc vddc vddpe bl[1]_23
+  nbl[1]_23 nbl[0]_23 bl[0]_23 nbl[2]_22 bl[2]_22 vpw vnwc vddc vddpe
+  bl[1]_22 nbl[1]_22 nbl[0]_22 bl[0]_22 nbl[2]_21 bl[2]_21 vpw vnwc vddc vddc
+  vddpe bl[1]_21 nbl[1]_21 nbl[0]_21 bl[0]_21 nbl[2]_20 vpw vnwc vddc vddc
+  vddpe bl[1]_20 nbl[1]_20 nbl[0]_20 bl[0]_20 nbl[2]_19 vpw vnwc vddc vddc
+  vddpe bl[1]_19 nbl[1]_19 nbl[0]_19 bl[0]_19 nbl[2]_18 vpw vnwc vddc vddpe
+  bl[1]_18 nbl[1]_18 nbl[0]_18 bl[0]_18 nbl[2]_17 bl[2]_17 vpw vnwc vddc
+  vddpe bl[1]_17 nbl[1]_17 nbl[0]_17 bl[0]_17 nbl[2]_16 bl[2]_16 vpw vnwc
+  vddc vddc vddpe bl[1]_16 nbl[1]_16 nbl[0]_16 bl[0]_16 nbl[2]_15 bl[2]_15
+  vpw vnwc vddc vddc vddpe bl[1]_15 nbl[1]_15 nbl[0]_15 bl[0]_15 nbl[2]_14
+  vpw vnwc vddc vddc vddpe bl[1]_14 nbl[1]_14 nbl[0]_14 bl[0]_14 nbl[2]_13
+  vpw vnwc vddc vddc vddpe bl[1]_13 nbl[1]_13 nbl[0]_13 bl[0]_13 vpw vnwc
+  vddc vddc vddpe bl[1]_12 nbl[1]_12 nbl[0]_12 bl[0]_12 vpw vnwc vddc vddc
+  vddpe bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 nbl[2]_10 bl[2]_10 vpw vnwc
+  vddc vddc vddpe bl[1]_10 nbl[1]_10 nbl[0]_10 bl[0]_10 nbl[2]_9 vpw vnwc
+  vddc vddc vddpe bl[1]_9 nbl[1]_9 nbl[0]_9 bl[0]_9 nbl[2]_8 vpw vnwc vddc
+  vddc vddpe bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 vpw vnwc vddc vddc vddpe
+  bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 vpw vnwc vddc vddc vddpe bl[1]_6 nbl[1]_6
+  nbl[0]_6 bl[0]_6 bl[3]_5 vpw vnwc vddc vddc vddpe bl[1]_5 nbl[1]_5 nbl[0]_5
+  bl[0]_5 vpw vnwc vddc vddc vddpe bl[1]_4 nbl[1]_4 nbl[0]_4 bl[0]_4 nbl[2]_3
+  vpw vnwc vddc vddc vddpe bl[1]_3 nbl[1]_3 nbl[0]_3 bl[0]_3 nbl[2]_2 vpw
+  vnwc vddc vddc vddpe bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 vpw vnwc vddc vddc
+  vddpe bl[1]_1 nbl[1]_1 nbl[0]_1 bl[0]_1 vpw vnwc vddc vddc vddpe bl[1]_0
+  nbl[1]_0 nbl[0]_0 bl[0]_0 vnwp_0 vnwc vpw vnwp_1 vpw vddc vddpe bl[1]_31
+  nbl[1]_31 nbl[0]_31 bl[0]_31 vpw vnwc vddc vddc nbl[1]_30 nbl[0]_30
+  bl[0]_30 bl[3]_29 vpw vnwc vddc vddc nbl[1]_29 nbl[0]_29 bl[0]_29 bl[3]_28
+  vpw vnwc vddc vddc nbl[1]_28 nbl[0]_28 bl[0]_28 bl[3]_27 nbl[3]_27 vpw vnwc
+  vddc vddc nbl[1]_27 nbl[0]_27 bl[0]_27 bl[3]_26 nbl[3]_26 vpw vnwc vddc
+  vddc nbl[1]_26 nbl[0]_26 bl[3]_25 bl[2]_25 vpw vddc nbl[0]_25 bl[3]_24
+  nbl[3]_24 vddc bl[3]_23 vddc bl[3]_22 nbl[3]_22 vddc bl[3]_21 nbl[3]_21
+  bl[3]_20 nbl[3]_20 bl[2]_20 bl[3]_19 nbl[3]_19 bl[2]_19 bl[3]_18 nbl[3]_18
+  bl[2]_18 vddc bl[3]_17 nbl[3]_17 vddc bl[3]_16 nbl[3]_16 bl[3]_15 nbl[3]_15
+  bl[3]_14 nbl[3]_14 bl[2]_14 bl[3]_13 nbl[3]_13 bl[2]_13 bl[3]_12 nbl[3]_12
+  nbl[2]_12 bl[2]_12 bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 bl[3]_10 nbl[3]_10
+  bl[3]_9 nbl[3]_9 bl[2]_9 bl[3]_8 nbl[3]_8 bl[2]_8 bl[3]_7 nbl[3]_7 nbl[2]_7
+  bl[2]_7 bl[3]_6 nbl[3]_6 nbl[2]_6 bl[2]_6 nbl[3]_5 nbl[2]_5 bl[2]_5 bl[3]_4
+  nbl[3]_4 nbl[2]_4 bl[2]_4 bl[3]_3 nbl[3]_3 bl[2]_3 bl[3]_2 nbl[3]_2 bl[2]_2
+  bl[3]_1 nbl[3]_1 nbl[2]_1 bl[2]_1 bl[3]_0 nbl[3]_0 nbl[2]_0 bl[2]_0 wl[1]_8
+  wl[0]_8 rf64x128mem_r_midt_row
xmem_r_row_top vpw vnwc bl[3]_31 nbl[3]_31 nbl[2]_31 bl[2]_31 vnwc vddc
+  bl[3]_30 nbl[3]_30 nbl[2]_30 bl[2]_30 vddpe bl[1]_30 nbl[3]_29 nbl[2]_29
+  bl[2]_29 vddpe bl[1]_29 nbl[3]_28 nbl[2]_28 bl[2]_28 vddpe bl[1]_28
+  nbl[2]_27 bl[2]_27 vddpe bl[1]_27 nbl[2]_26 bl[2]_26 vddpe bl[1]_26
+  bl[0]_26 nbl[3]_25 nbl[2]_25 vnwc vddc vddpe bl[1]_25 nbl[1]_25 bl[0]_25
+  nbl[2]_24 bl[2]_24 vssc vpw vnwc vddc vddpe bl[1]_24 nbl[1]_24 nbl[0]_24
+  bl[0]_24 nbl[3]_23 nbl[2]_23 bl[2]_23 vpw vnwc vddc vddpe bl[1]_23
+  nbl[1]_23 nbl[0]_23 bl[0]_23 nbl[2]_22 bl[2]_22 vpw vnwc vddc vddpe
+  bl[1]_22 nbl[1]_22 nbl[0]_22 bl[0]_22 nbl[2]_21 bl[2]_21 vpw vnwc vddc vddc
+  vddpe bl[1]_21 nbl[1]_21 nbl[0]_21 bl[0]_21 nbl[2]_20 vpw vnwc vddc vddc
+  vddpe bl[1]_20 nbl[1]_20 nbl[0]_20 bl[0]_20 nbl[2]_19 vpw vnwc vddc vddc
+  vddpe bl[1]_19 nbl[1]_19 nbl[0]_19 bl[0]_19 nbl[2]_18 vpw vnwc vddc vddpe
+  bl[1]_18 nbl[1]_18 nbl[0]_18 bl[0]_18 nbl[2]_17 bl[2]_17 vpw vnwc vddc
+  vddpe bl[1]_17 nbl[1]_17 nbl[0]_17 bl[0]_17 nbl[2]_16 bl[2]_16 vpw vnwc
+  vddc vddc vddpe bl[1]_16 nbl[1]_16 nbl[0]_16 bl[0]_16 nbl[2]_15 bl[2]_15
+  vpw vnwc vddc vddc vddpe bl[1]_15 nbl[1]_15 nbl[0]_15 bl[0]_15 nbl[2]_14
+  vpw vnwc vddc vddc vddpe bl[1]_14 nbl[1]_14 nbl[0]_14 bl[0]_14 nbl[2]_13
+  vpw vnwc vddc vddc vddpe bl[1]_13 nbl[1]_13 nbl[0]_13 bl[0]_13 vpw vnwc
+  vddc vddc vddpe bl[1]_12 nbl[1]_12 nbl[0]_12 bl[0]_12 vpw vnwc vddc vddc
+  vddpe bl[1]_11 nbl[1]_11 nbl[0]_11 bl[0]_11 nbl[2]_10 bl[2]_10 vpw vnwc
+  vddc vddc vddpe bl[1]_10 nbl[1]_10 nbl[0]_10 bl[0]_10 nbl[2]_9 vpw vnwc
+  vddc vddc vddpe bl[1]_9 nbl[1]_9 nbl[0]_9 bl[0]_9 nbl[2]_8 vpw vnwc vddc
+  vddc vddpe bl[1]_8 nbl[1]_8 nbl[0]_8 bl[0]_8 vpw vnwc vddc vddc vddpe
+  bl[1]_7 nbl[1]_7 nbl[0]_7 bl[0]_7 vpw vnwc vddc vddc vddpe bl[1]_6 nbl[1]_6
+  nbl[0]_6 bl[0]_6 bl[3]_5 vpw vnwc vddc vddc vddpe bl[1]_5 nbl[1]_5 nbl[0]_5
+  bl[0]_5 vpw vnwc vddc vddc vddpe bl[1]_4 nbl[1]_4 nbl[0]_4 bl[0]_4 nbl[2]_3
+  vpw vnwc vddc vddc vddpe bl[1]_3 nbl[1]_3 nbl[0]_3 bl[0]_3 nbl[2]_2 vpw
+  vnwc vddc vddc vddpe bl[1]_2 nbl[1]_2 nbl[0]_2 bl[0]_2 vpw vnwc vddc vddc
+  vddpe bl[1]_1 nbl[1]_1 nbl[0]_1 bl[0]_1 vpw vssc vnwc vddc vddc vddpe
+  bl[1]_0 nbl[1]_0 nbl[0]_0 bl[0]_0 vnwp_0 vnwc vpw vnwp_1 vpw vssc vddc
+  vddpe bl[1]_31 nbl[1]_31 nbl[0]_31 bl[0]_31 vpw vnwc vddc vddc nbl[1]_30
+  nbl[0]_30 bl[0]_30 bl[3]_29 vpw vnwc vddc vddc nbl[1]_29 nbl[0]_29 bl[0]_29
+  bl[3]_28 vpw vnwc vddc vddc nbl[1]_28 nbl[0]_28 bl[0]_28 bl[3]_27 nbl[3]_27
+  vpw vnwc vddc vddc nbl[1]_27 nbl[0]_27 bl[0]_27 bl[3]_26 nbl[3]_26 vpw vnwc
+  vddc vddc nbl[1]_26 nbl[0]_26 bl[3]_25 bl[2]_25 vpw vddc nbl[0]_25 bl[3]_24
+  nbl[3]_24 vddc bl[3]_23 vddc bl[3]_22 nbl[3]_22 vddc bl[3]_21 nbl[3]_21
+  bl[3]_20 nbl[3]_20 bl[2]_20 bl[3]_19 nbl[3]_19 bl[2]_19 bl[3]_18 nbl[3]_18
+  bl[2]_18 vddc bl[3]_17 nbl[3]_17 vddc bl[3]_16 nbl[3]_16 bl[3]_15 nbl[3]_15
+  bl[3]_14 nbl[3]_14 bl[2]_14 bl[3]_13 nbl[3]_13 bl[2]_13 bl[3]_12 nbl[3]_12
+  nbl[2]_12 bl[2]_12 bl[3]_11 nbl[3]_11 nbl[2]_11 bl[2]_11 bl[3]_10 nbl[3]_10
+  bl[3]_9 nbl[3]_9 bl[2]_9 bl[3]_8 nbl[3]_8 bl[2]_8 bl[3]_7 nbl[3]_7 nbl[2]_7
+  bl[2]_7 bl[3]_6 nbl[3]_6 nbl[2]_6 bl[2]_6 nbl[3]_5 nbl[2]_5 bl[2]_5 bl[3]_4
+  nbl[3]_4 nbl[2]_4 bl[2]_4 bl[3]_3 nbl[3]_3 bl[2]_3 bl[3]_2 nbl[3]_2 bl[2]_2
+  bl[3]_1 nbl[3]_1 nbl[2]_1 bl[2]_1 bl[3]_0 nbl[3]_0 nbl[2]_0 bl[2]_0
+  wl[1]_15 wl[0]_15 rf64x128mem_r_top_row
.ends rf64x128memcore_r
****
.subckt rf64x128wdbot nret ret actp dbl dbl_nbl_wa dbl_nbl_wa_turn dbl_term
+  dwl ema[0] ema[1] ema[2] gtpclk0 gtpclk1 la_p2[0] la_p2[1] log0 log0_sa
+  log1 nact_cc nactc nhdr_wl ni0_term ni1_term nla_p2[0] nla_p2[1] nra_p2[0]
+  nra_p2[1] nra_p2[2] nra_p2[3] nra_p2[4] nra_p2[5] nretnvt ra_en0 ra_en1
+  ra_p2[0] ra_p2[1] ra_p2[2] ra_p2[3] ra_p2[4] ra_p2[5] rawl rawlm0 rawlm1
+  vddc_l vddc_r vddce vddi vddp_nor vddpe vnwc vnwp vpw vss vssc_l vssc_r
+  vsse cen_p2 ret1n
** rf64x128wdbot: 40 flat devices **
mi35.mxna1 nret iret vsse vpw nch_mac W=1.6U L=0.035U NF=2
mi35.mxpa1 nret iret vddce vnwc pch_mac W=2U L=0.035U NF=2
mi40.mxna1 iret ret1n i40.n1 vpw nch_mac W=0.8U L=0.035U NF=1
mi40.mxna2 i40.n1 log1 vsse vpw nch_mac W=0.8U L=0.035U NF=1
mi40.mxpa1 iret ret1n vddce vnwc pch_mac W=0.5U L=0.035U NF=1
mi40.mxpa2 iret log1 vddce vnwc pch_mac W=0.5U L=0.035U NF=1
mi42.i0.mxna1 i42.nra_ast0 rawlm0 i42.i0.n1 vpw nch_mac W=0.31U L=0.035U NF=1
mi42.i0.mxna2 i42.i0.n1 rawl vss vpw nch_mac W=0.31U L=0.035U NF=1
mi42.i0.mxpa1 i42.nra_ast0 rawlm0 vddpe vnwp pch_mac W=0.26U L=0.035U NF=1
mi42.i0.mxpa2 i42.nra_ast0 rawl vddpe vnwp pch_mac W=0.26U L=0.035U NF=1
mi42.i115.mxna1 ra_en0 i42.ra_ast0 vsse vpw nch_mac W=0.4U L=0.035U NF=1
mi42.i115.mxpa1 ra_en0 i42.ra_ast0 vddce vnwc pch_mac W=0.26U L=0.035U NF=1
mi42.i162.mxna1 i42.ra_ast0 i42.nra_ast0 i42.i162.n1 vpw nch_mac W=0.55U
+  L=0.035U NF=1
mi42.i162.mxna2 i42.i162.n1 nret vss vpw nch_mac W=0.55U L=0.035U NF=1
mi42.i162.mxpa1 i42.ra_ast0 i42.nra_ast0 vddce vnwc pch_mac W=0.26U L=0.035U
+  NF=1
mi42.i162.mxpa2 i42.ra_ast0 nret vddce vnwc pch_mac W=0.26U L=0.035U NF=1
mi42.i163.mxna1 i42.nra_ast1 rawlm1 i42.i163.n1 vpw nch_mac W=0.31U L=0.035U
+  NF=1
mi42.i163.mxna2 i42.i163.n1 rawl vss vpw nch_mac W=0.31U L=0.035U NF=1
mi42.i163.mxpa1 i42.nra_ast1 rawlm1 vddpe vnwp pch_mac W=0.26U L=0.035U NF=1
mi42.i163.mxpa2 i42.nra_ast1 rawl vddpe vnwp pch_mac W=0.26U L=0.035U NF=1
mi42.i164.mxna1 i42.ra_ast1 i42.nra_ast1 i42.i164.n1 vpw nch_mac W=0.55U
+  L=0.035U NF=1
mi42.i164.mxna2 i42.i164.n1 nret vss vpw nch_mac W=0.55U L=0.035U NF=1
mi42.i164.mxpa1 i42.ra_ast1 i42.nra_ast1 vddce vnwc pch_mac W=0.26U L=0.035U
+  NF=1
mi42.i164.mxpa2 i42.ra_ast1 nret vddce vnwc pch_mac W=0.26U L=0.035U NF=1
mi42.i165.mxna1 ra_en1 i42.ra_ast1 vsse vpw nch_mac W=0.4U L=0.035U NF=1
mi42.i165.mxpa1 ra_en1 i42.ra_ast1 vddce vnwc pch_mac W=0.26U L=0.035U NF=1
mi50.mxna1 ret nret vsse vpw nch_mac W=4.02U L=0.035U NF=6
mi50.mxpa1 ret nret vddce vnwc pch_mac W=8.01U L=0.035U NF=6
mxp0 vddi nhdr_wl vddce vnwc pch_mac W=16U L=0.035U NF=10
m_hdr_ctl.i63.mxna1 _hdr_ctl.ce_p2 cen_p2 vss vpw nch_mac W=0.2U L=0.03U NF=1
m_hdr_ctl.i63.mxna2 _hdr_ctl.ce_p2 iret vss vpw nch_mac W=0.2U L=0.03U NF=1
m_hdr_ctl.i63.mxpa1 _hdr_ctl.ce_p2 cen_p2 _hdr_ctl.i63.p1 vnwp pch_mac W=1.25U
+  L=0.03U NF=1
m_hdr_ctl.i63.mxpa2 _hdr_ctl.i63.p1 iret vddpe vnwp pch_mac W=1.25U L=0.03U
+  NF=1
m_hdr_ctl.mxn2 _hdr_ctl.net4 cen_p2 vss vpw nch_mac W=1U L=0.03U NF=5
m_hdr_ctl.mxn3 nhdr_wl _hdr_ctl.ce_p2 vss vpw nch_mac W=9U L=0.03U NF=10
m_hdr_ctl.mxp10 nhdr_wl nret vddce vnwc pch_mac W=0.66U L=0.03U NF=1
m_hdr_ctl.mxp6 _hdr_ctl.net4 cen_p2 _hdr_ctl.net8 vnwc pch_mac W=0.33U L=0.03U
+  NF=1
m_hdr_ctl.mxp7 _hdr_ctl.net8 nhdr_wl vddce vnwc pch_mac W=0.33U L=0.03U NF=1
m_hdr_ctl.mxp8 _hdr_ctl.net7 _hdr_ctl.net4 vddce vnwc pch_mac W=0.66U L=0.03U
+  NF=1
m_hdr_ctl.mxp9 nhdr_wl _hdr_ctl.ce_p2 _hdr_ctl.net7 vnwc pch_mac W=0.66U
+  L=0.03U NF=1
.ends rf64x128wdbot
****
.subckt rf64x128wdtop actp dbl_ast log0 nhdr_wl ni1 ni0 niactc niretnvt nxp0_0
+  nxp0_1 nxp0_2 nxp0_3 nxp0_4 nxp0_5 nxp0_6 nxp0_7 nxp1_0 nxp1_1 nxp1_2
+  nxp1_3 nxp1_4 nxp1_5 nxp1_6 nxp1_7 ra_en0_l_term ra_en0_r_term
+  ra_en1_l_term ra_en1_r_term ret rowclk1 rowclk0 rowclk2_term rowclk3_term
+  vddc_l vddc_r vddc_wl vddce vddp_nor vddpe vnwc vnwp vpw vss vssc_l vssc_r
+  vsse
** rf64x128wdtop: 9 flat devices **
mi32_0.mxna1 ni0 rowclk0 vss vpw nch_mac W=2U L=0.03U NF=2
mi32_0.mxpa1 ni0 rowclk0 vddc_wl vnwc pch_mac W=1.48U L=0.03U NF=2
mi32_1.mxna1 ni1 rowclk1 vss vpw nch_mac W=2U L=0.03U NF=2
mi32_1.mxpa1 ni1 rowclk1 vddc_wl vnwc pch_mac W=1.48U L=0.03U NF=2
mi44.mxna1 net61 dbl_ast vss vpw nch_mac W=0.63U L=0.035U NF=2
mi44.mxpa1 net61 dbl_ast vddpe vnwp pch_mac W=0.8U L=0.035U NF=2
mi45.mxna1 net60 net61 vss vpw nch_mac W=1.26U L=0.035U NF=2
mi45.mxpa1 net60 net61 vddpe vnwp pch_mac W=1.6U L=0.035U NF=2
mxp8 vddc_wl nhdr_wl vddce vnwc pch_mac W=21.1U L=0.035U NF=10
.ends rf64x128wdtop
****
.subckt rf64x128wdx32 log0_sa nact_cc actp dbl dbl_nbl_wa dbl_nbl_wa_turn dwl
+  ema2_e log0 log1 nhdr_wl ni0 ni1 niactc niretnvt nxp0_0 nxp0_1 nxp0_2
+  nxp0_3 nxp0_4 nxp0_5 nxp0_6 nxp0_7 nxp1_0 nxp1_1 nxp1_2 nxp1_3 nxp1_4
+  nxp1_5 nxp1_6 nxp1_7 rowclk0 rowclk1 vddce vddi vddp_nor vddpe vnwc vnwp
+  vpw vss vssc_l vssc_r vsse wl0_l wl0_r wl1_l wl1_r wl2_l wl2_r wl3_l wl3_r
+  wl4_l wl4_r wl5_l wl5_r wl6_l wl6_r wl7_l wl7_r wl8_l wl8_r wl9_l wl9_r
+  wl10_l wl10_r wl11_l wl11_r wl12_l wl12_r wl13_l wl13_r wl14_l wl14_r
+  wl15_l wl15_r wl16_l wl16_r wl17_l wl17_r wl18_l wl18_r wl19_l wl19_r
+  wl20_l wl20_r wl21_l wl21_r wl22_l wl22_r wl23_l wl23_r wl24_l wl24_r
+  wl25_l wl25_r wl26_l wl26_r wl27_l wl27_r wl28_l wl28_r wl29_l wl29_r
+  wl30_l wl30_r wl31_l wl31_r ema0 ema1 ema2 gtpclk0 gtpclk1 la_p2[0]
+  la_p2[1] nla_p2[0] nla_p2[1] nra_p2[0] nra_p2[1] nra_p2[2] nra_p2[3]
+  nra_p2[4] nra_p2[5] ra_en0_l ra_en0_r ra_en1_l ra_en1_r ra_p2[0] ra_p2[1]
+  ra_p2[2] ra_p2[3] ra_p2[4] ra_p2[5] ret
** rf64x128wdx32: 636 flat devices **
mi41_0.mxna1 nrowclk[0] gtpclk0 i41_0.n1 vpw nch_mac W=2.8U L=0.03U NF=4
mi41_0.mxna2 i41_0.n1 nla_p2[0] vss vpw nch_mac W=2.8U L=0.03U NF=4
mi41_0.mxpa1 nrowclk[0] gtpclk0 vddpe vnwp pch_mac W=1.2U L=0.03U NF=4
mi41_0.mxpa2 nrowclk[0] nla_p2[0] vddpe vnwp pch_mac W=1.2U L=0.03U NF=4
mi41_1.mxna1 nrowclk[1] gtpclk1 i41_1.n1 vpw nch_mac W=2.8U L=0.03U NF=4
mi41_1.mxna2 i41_1.n1 la_p2[0] vss vpw nch_mac W=2.8U L=0.03U NF=4
mi41_1.mxpa1 nrowclk[1] gtpclk1 vddpe vnwp pch_mac W=1.2U L=0.03U NF=4
mi41_1.mxpa2 nrowclk[1] la_p2[0] vddpe vnwp pch_mac W=1.2U L=0.03U NF=4
mi74.mxna1 act_cc ret vsse vpw nch_mac W=0.3U L=0.03U NF=2
mi74.mxpa1 act_cc ret vddpe vnwp pch_mac W=0.6U L=0.03U NF=2
mi82.mxna1 nact_cc act_cc vss vpw nch_mac W=1U L=0.03U NF=4
mi82.mxpa1 nact_cc act_cc vddpe vnwp pch_mac W=2U L=0.03U NF=4
miv_rdwrclk_0.mxna1 rowclk0 nrowclk[0] vss vpw nch_mac W=3U L=0.03U NF=8
miv_rdwrclk_0.mxpa1 rowclk0 nrowclk[0] vddpe vnwp pch_mac W=6U L=0.03U NF=8
miv_rdwrclk_1.mxna1 rowclk1 nrowclk[1] vss vpw nch_mac W=3U L=0.03U NF=8
miv_rdwrclk_1.mxpa1 rowclk1 nrowclk[1] vddpe vnwp pch_mac W=6U L=0.03U NF=8
m_dummy.i2.mxna1 _dummy.nsel0 ema2 vss vpw nch_mac W=0.1U L=0.03U NF=1
m_dummy.i2.mxna2 _dummy.nsel0 ema0 vss vpw nch_mac W=0.1U L=0.03U NF=1
m_dummy.i2.mxpa1 _dummy.nsel0 ema2 _dummy.i2.p1 vnwp pch_mac W=0.2U L=0.03U
+  NF=1
m_dummy.i2.mxpa2 _dummy.i2.p1 ema0 vddpe vnwp pch_mac W=0.2U L=0.03U NF=1
m_dummy.i77.mxna1 _dummy.nsel1 ema2 vss vpw nch_mac W=0.1U L=0.03U NF=1
m_dummy.i77.mxna2 _dummy.nsel1 ema1 vss vpw nch_mac W=0.1U L=0.03U NF=1
m_dummy.i77.mxpa1 _dummy.nsel1 ema2 _dummy.i77.p1 vnwp pch_mac W=0.2U L=0.03U
+  NF=1
m_dummy.i77.mxpa2 _dummy.i77.p1 ema1 vddpe vnwp pch_mac W=0.2U L=0.03U NF=1
m_dummy.i82.mxna1 _dummy.nema[2] ema2_e vss vpw nch_mac W=0.2U L=0.03U NF=1
m_dummy.i82.mxpa1 _dummy.nema[2] ema2_e vddpe vnwp pch_mac W=0.2U L=0.03U NF=1
m_dummy.mxn22 dbl dwl _dummy.ia[1] vpw nch_mac W=0.375U L=0.04U NF=1
m_dummy.mxn23 _dummy.ia[1] _dummy.nsel0 vss vpw nch_mac W=0.375U L=0.04U NF=1
m_dummy.mxn25 dbl dwl _dummy.ia[2] vpw nch_mac W=0.6U L=0.04U NF=2
m_dummy.mxn26 _dummy.ia[2] _dummy.nsel1 vss vpw nch_mac W=0.6U L=0.04U NF=2
m_dummy.mxn28 dbl dwl _dummy.ia[3] vpw nch_mac W=0.4U L=0.03U NF=1
m_dummy.mxn29 _dummy.ia[3] log0 vss vpw nch_mac W=0.4U L=0.03U NF=1
m_dummy.mxn31 dbl dbl _dummy.ia[4] vpw nch_mac W=0.3U L=0.03U NF=1
m_dummy.mxn32 _dummy.ia[4] dwl _dummy.mid vpw nch_mac W=0.3U L=0.03U NF=1
m_dummy.mxn33 _dummy.mid _dummy.nema[2] vss vpw nch_mac W=0.3U L=0.03U NF=1
m_dummy.mxp12 dbl dwl vddpe vnwp pch_mac W=2U L=0.03U NF=4
m_tiehilo.itiehilo.mxn0 _tiehilo.izero _tiehilo.itiehilo.nodeb vsse vpw
+  nch_mac W=0.36U L=0.03U NF=1
m_tiehilo.itiehilo.mxn1 _tiehilo.itiehilo.nodea _tiehilo.itiehilo.nodea vsse
+  vpw nch_mac W=0.21U L=0.03U NF=1
m_tiehilo.itiehilo.mxn2 _tiehilo.itiehilo.nodea _tiehilo.itiehilo.nodeb vsse
+  vpw nch_mac W=0.21U L=0.03U NF=1
m_tiehilo.itiehilo.mxp1 _tiehilo.itiehilo.nodeb _tiehilo.itiehilo.nodea vddpe
+  vnwp pch_mac W=0.275U L=0.03U NF=1
m_tiehilo.itiehilo.mxp4 _tiehilo.ione _tiehilo.itiehilo.nodea vddpe vnwp
+  pch_mac W=0.73U L=0.03U NF=2
m_tiehilo.mxn5 log0 _tiehilo.ione vsse vpw nch_mac W=2.5U L=0.03U NF=4
m_tiehilo.mxn7 log0_sa _tiehilo.ione vsse vpw nch_mac W=1.875U L=0.03U NF=3
m_tiehilo.mxp4 log1 _tiehilo.izero vddpe vnwp pch_mac W=3.6U L=0.03U NF=6
m_wd0.i69.mxn0 _wd0.rowsel nxp1_0 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd0.i69.mxn15 _wd0.rowsel nxp0_0 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd0.i69.mxp1 _wd0.rowsel nxp0_0 _wd0.i69.p1 vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd0.i69.mxp15 _wd0.i69.p1 nxp1_0 vddp_nor vnwp pch_mac W=1.35U L=0.035U NF=1
m_wd0.i69.mx_npd _wd0.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wd0.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U NF=1
m_wd0.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wd0.mxp12 wl1_r ra_en0_r wl0_r vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd0.mxp13 wl1_r ra_en1_r wl0_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd0.mxp14 wl1_l ra_en1_l wl0_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd0.mxp15 wl1_l ra_en0_l wl0_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd0._rowdrv_0.mxn0 wl0_r _wd0._rowdrv_0.nwl vsse vpw nch_mac W=1.2U L=0.035U
+  NF=2
m_wd0._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd0._rowdrv_0.mxn11 wl0_l _wd0._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd0._rowdrv_0.mxn8 _wd0._rowdrv_0.nwl _wd0.rowsel ni0 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd0._rowdrv_0.mxp0 wl0_r _wd0._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd0._rowdrv_0.mxp12 _wd0._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd0._rowdrv_0.mxp13 _wd0._rowdrv_0.nwl _wd0.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd0._rowdrv_0.mxp7 wl0_l _wd0._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd0._rowdrv_1.mxn0 wl1_r _wd0._rowdrv_1.nwl vsse vpw nch_mac W=1.2U L=0.035U
+  NF=2
m_wd0._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd0._rowdrv_1.mxn11 wl1_l _wd0._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd0._rowdrv_1.mxn8 _wd0._rowdrv_1.nwl _wd0.rowsel ni1 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd0._rowdrv_1.mxp0 wl1_r _wd0._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd0._rowdrv_1.mxp12 _wd0._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd0._rowdrv_1.mxp13 _wd0._rowdrv_1.nwl _wd0.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd0._rowdrv_1.mxp7 wl1_l _wd0._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd1.i69.mxn0 _wd1.rowsel nxp1_0 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd1.i69.mxn15 _wd1.rowsel nxp0_1 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd1.i69.mxp1 _wd1.rowsel nxp0_1 _wd1.i69.p1 vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd1.i69.mxp15 _wd1.i69.p1 nxp1_0 vddp_nor vnwp pch_mac W=1.35U L=0.035U NF=1
m_wd1.i69.mx_npd _wd1.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wd1.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U NF=1
m_wd1.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wd1.mxp12 wl3_r ra_en0_r wl2_r vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd1.mxp13 wl3_r ra_en1_r wl2_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd1.mxp14 wl3_l ra_en1_l wl2_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd1.mxp15 wl3_l ra_en0_l wl2_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd1._rowdrv_0.mxn0 wl2_r _wd1._rowdrv_0.nwl vsse vpw nch_mac W=1.2U L=0.035U
+  NF=2
m_wd1._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd1._rowdrv_0.mxn11 wl2_l _wd1._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd1._rowdrv_0.mxn8 _wd1._rowdrv_0.nwl _wd1.rowsel ni0 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd1._rowdrv_0.mxp0 wl2_r _wd1._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd1._rowdrv_0.mxp12 _wd1._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd1._rowdrv_0.mxp13 _wd1._rowdrv_0.nwl _wd1.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd1._rowdrv_0.mxp7 wl2_l _wd1._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd1._rowdrv_1.mxn0 wl3_r _wd1._rowdrv_1.nwl vsse vpw nch_mac W=1.2U L=0.035U
+  NF=2
m_wd1._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd1._rowdrv_1.mxn11 wl3_l _wd1._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd1._rowdrv_1.mxn8 _wd1._rowdrv_1.nwl _wd1.rowsel ni1 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd1._rowdrv_1.mxp0 wl3_r _wd1._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd1._rowdrv_1.mxp12 _wd1._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd1._rowdrv_1.mxp13 _wd1._rowdrv_1.nwl _wd1.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd1._rowdrv_1.mxp7 wl3_l _wd1._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd10.i69.mxn0 _wd10.rowsel nxp1_1 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd10.i69.mxn15 _wd10.rowsel nxp0_2 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd10.i69.mxp1 _wd10.rowsel nxp0_2 _wd10.i69.p1 vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd10.i69.mxp15 _wd10.i69.p1 nxp1_1 vddp_nor vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd10.i69.mx_npd _wd10.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wd10.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U NF=1
m_wd10.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wd10.mxp12 wl21_r ra_en0_r wl20_r vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd10.mxp13 wl21_r ra_en1_r wl20_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd10.mxp14 wl21_l ra_en1_l wl20_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd10.mxp15 wl21_l ra_en0_l wl20_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd10._rowdrv_0.mxn0 wl20_r _wd10._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd10._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd10._rowdrv_0.mxn11 wl20_l _wd10._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd10._rowdrv_0.mxn8 _wd10._rowdrv_0.nwl _wd10.rowsel ni0 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd10._rowdrv_0.mxp0 wl20_r _wd10._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd10._rowdrv_0.mxp12 _wd10._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd10._rowdrv_0.mxp13 _wd10._rowdrv_0.nwl _wd10.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd10._rowdrv_0.mxp7 wl20_l _wd10._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd10._rowdrv_1.mxn0 wl21_r _wd10._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd10._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd10._rowdrv_1.mxn11 wl21_l _wd10._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd10._rowdrv_1.mxn8 _wd10._rowdrv_1.nwl _wd10.rowsel ni1 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd10._rowdrv_1.mxp0 wl21_r _wd10._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd10._rowdrv_1.mxp12 _wd10._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd10._rowdrv_1.mxp13 _wd10._rowdrv_1.nwl _wd10.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd10._rowdrv_1.mxp7 wl21_l _wd10._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd11.i69.mxn0 _wd11.rowsel nxp1_1 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd11.i69.mxn15 _wd11.rowsel nxp0_3 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd11.i69.mxp1 _wd11.rowsel nxp0_3 _wd11.i69.p1 vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd11.i69.mxp15 _wd11.i69.p1 nxp1_1 vddp_nor vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd11.i69.mx_npd _wd11.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wd11.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U NF=1
m_wd11.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wd11.mxp12 wl23_r ra_en0_r wl22_r vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd11.mxp13 wl23_r ra_en1_r wl22_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd11.mxp14 wl23_l ra_en1_l wl22_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd11.mxp15 wl23_l ra_en0_l wl22_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd11._rowdrv_0.mxn0 wl22_r _wd11._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd11._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd11._rowdrv_0.mxn11 wl22_l _wd11._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd11._rowdrv_0.mxn8 _wd11._rowdrv_0.nwl _wd11.rowsel ni0 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd11._rowdrv_0.mxp0 wl22_r _wd11._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd11._rowdrv_0.mxp12 _wd11._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd11._rowdrv_0.mxp13 _wd11._rowdrv_0.nwl _wd11.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd11._rowdrv_0.mxp7 wl22_l _wd11._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd11._rowdrv_1.mxn0 wl23_r _wd11._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd11._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd11._rowdrv_1.mxn11 wl23_l _wd11._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd11._rowdrv_1.mxn8 _wd11._rowdrv_1.nwl _wd11.rowsel ni1 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd11._rowdrv_1.mxp0 wl23_r _wd11._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd11._rowdrv_1.mxp12 _wd11._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd11._rowdrv_1.mxp13 _wd11._rowdrv_1.nwl _wd11.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd11._rowdrv_1.mxp7 wl23_l _wd11._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd12.i69.mxn0 _wd12.rowsel nxp1_1 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd12.i69.mxn15 _wd12.rowsel nxp0_4 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd12.i69.mxp1 _wd12.rowsel nxp0_4 _wd12.i69.p1 vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd12.i69.mxp15 _wd12.i69.p1 nxp1_1 vddp_nor vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd12.i69.mx_npd _wd12.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wd12.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U NF=1
m_wd12.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wd12.mxp12 wl25_r ra_en0_r wl24_r vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd12.mxp13 wl25_r ra_en1_r wl24_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd12.mxp14 wl25_l ra_en1_l wl24_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd12.mxp15 wl25_l ra_en0_l wl24_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd12._rowdrv_0.mxn0 wl24_r _wd12._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd12._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd12._rowdrv_0.mxn11 wl24_l _wd12._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd12._rowdrv_0.mxn8 _wd12._rowdrv_0.nwl _wd12.rowsel ni0 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd12._rowdrv_0.mxp0 wl24_r _wd12._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd12._rowdrv_0.mxp12 _wd12._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd12._rowdrv_0.mxp13 _wd12._rowdrv_0.nwl _wd12.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd12._rowdrv_0.mxp7 wl24_l _wd12._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd12._rowdrv_1.mxn0 wl25_r _wd12._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd12._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd12._rowdrv_1.mxn11 wl25_l _wd12._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd12._rowdrv_1.mxn8 _wd12._rowdrv_1.nwl _wd12.rowsel ni1 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd12._rowdrv_1.mxp0 wl25_r _wd12._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd12._rowdrv_1.mxp12 _wd12._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd12._rowdrv_1.mxp13 _wd12._rowdrv_1.nwl _wd12.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd12._rowdrv_1.mxp7 wl25_l _wd12._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd13.i69.mxn0 _wd13.rowsel nxp1_1 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd13.i69.mxn15 _wd13.rowsel nxp0_5 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd13.i69.mxp1 _wd13.rowsel nxp0_5 _wd13.i69.p1 vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd13.i69.mxp15 _wd13.i69.p1 nxp1_1 vddp_nor vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd13.i69.mx_npd _wd13.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wd13.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U NF=1
m_wd13.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wd13.mxp12 wl27_r ra_en0_r wl26_r vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd13.mxp13 wl27_r ra_en1_r wl26_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd13.mxp14 wl27_l ra_en1_l wl26_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd13.mxp15 wl27_l ra_en0_l wl26_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd13._rowdrv_0.mxn0 wl26_r _wd13._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd13._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd13._rowdrv_0.mxn11 wl26_l _wd13._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd13._rowdrv_0.mxn8 _wd13._rowdrv_0.nwl _wd13.rowsel ni0 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd13._rowdrv_0.mxp0 wl26_r _wd13._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd13._rowdrv_0.mxp12 _wd13._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd13._rowdrv_0.mxp13 _wd13._rowdrv_0.nwl _wd13.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd13._rowdrv_0.mxp7 wl26_l _wd13._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd13._rowdrv_1.mxn0 wl27_r _wd13._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd13._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd13._rowdrv_1.mxn11 wl27_l _wd13._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd13._rowdrv_1.mxn8 _wd13._rowdrv_1.nwl _wd13.rowsel ni1 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd13._rowdrv_1.mxp0 wl27_r _wd13._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd13._rowdrv_1.mxp12 _wd13._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd13._rowdrv_1.mxp13 _wd13._rowdrv_1.nwl _wd13.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd13._rowdrv_1.mxp7 wl27_l _wd13._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd14.i69.mxn0 _wd14.rowsel nxp1_1 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd14.i69.mxn15 _wd14.rowsel nxp0_6 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd14.i69.mxp1 _wd14.rowsel nxp0_6 _wd14.i69.p1 vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd14.i69.mxp15 _wd14.i69.p1 nxp1_1 vddp_nor vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd14.i69.mx_npd _wd14.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wd14.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U NF=1
m_wd14.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wd14.mxp12 wl29_r ra_en0_r wl28_r vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd14.mxp13 wl29_r ra_en1_r wl28_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd14.mxp14 wl29_l ra_en1_l wl28_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd14.mxp15 wl29_l ra_en0_l wl28_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd14._rowdrv_0.mxn0 wl28_r _wd14._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd14._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd14._rowdrv_0.mxn11 wl28_l _wd14._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd14._rowdrv_0.mxn8 _wd14._rowdrv_0.nwl _wd14.rowsel ni0 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd14._rowdrv_0.mxp0 wl28_r _wd14._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd14._rowdrv_0.mxp12 _wd14._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd14._rowdrv_0.mxp13 _wd14._rowdrv_0.nwl _wd14.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd14._rowdrv_0.mxp7 wl28_l _wd14._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd14._rowdrv_1.mxn0 wl29_r _wd14._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd14._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd14._rowdrv_1.mxn11 wl29_l _wd14._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd14._rowdrv_1.mxn8 _wd14._rowdrv_1.nwl _wd14.rowsel ni1 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd14._rowdrv_1.mxp0 wl29_r _wd14._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd14._rowdrv_1.mxp12 _wd14._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd14._rowdrv_1.mxp13 _wd14._rowdrv_1.nwl _wd14.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd14._rowdrv_1.mxp7 wl29_l _wd14._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd2.i69.mxn0 _wd2.rowsel nxp1_0 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd2.i69.mxn15 _wd2.rowsel nxp0_2 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd2.i69.mxp1 _wd2.rowsel nxp0_2 _wd2.i69.p1 vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd2.i69.mxp15 _wd2.i69.p1 nxp1_0 vddp_nor vnwp pch_mac W=1.35U L=0.035U NF=1
m_wd2.i69.mx_npd _wd2.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wd2.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U NF=1
m_wd2.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wd2.mxp12 wl5_r ra_en0_r wl4_r vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd2.mxp13 wl5_r ra_en1_r wl4_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd2.mxp14 wl5_l ra_en1_l wl4_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd2.mxp15 wl5_l ra_en0_l wl4_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd2._rowdrv_0.mxn0 wl4_r _wd2._rowdrv_0.nwl vsse vpw nch_mac W=1.2U L=0.035U
+  NF=2
m_wd2._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd2._rowdrv_0.mxn11 wl4_l _wd2._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd2._rowdrv_0.mxn8 _wd2._rowdrv_0.nwl _wd2.rowsel ni0 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd2._rowdrv_0.mxp0 wl4_r _wd2._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd2._rowdrv_0.mxp12 _wd2._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd2._rowdrv_0.mxp13 _wd2._rowdrv_0.nwl _wd2.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd2._rowdrv_0.mxp7 wl4_l _wd2._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd2._rowdrv_1.mxn0 wl5_r _wd2._rowdrv_1.nwl vsse vpw nch_mac W=1.2U L=0.035U
+  NF=2
m_wd2._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd2._rowdrv_1.mxn11 wl5_l _wd2._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd2._rowdrv_1.mxn8 _wd2._rowdrv_1.nwl _wd2.rowsel ni1 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd2._rowdrv_1.mxp0 wl5_r _wd2._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd2._rowdrv_1.mxp12 _wd2._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd2._rowdrv_1.mxp13 _wd2._rowdrv_1.nwl _wd2.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd2._rowdrv_1.mxp7 wl5_l _wd2._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd3.i69.mxn0 _wd3.rowsel nxp1_0 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd3.i69.mxn15 _wd3.rowsel nxp0_3 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd3.i69.mxp1 _wd3.rowsel nxp0_3 _wd3.i69.p1 vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd3.i69.mxp15 _wd3.i69.p1 nxp1_0 vddp_nor vnwp pch_mac W=1.35U L=0.035U NF=1
m_wd3.i69.mx_npd _wd3.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wd3.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U NF=1
m_wd3.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wd3.mxp12 wl7_r ra_en0_r wl6_r vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd3.mxp13 wl7_r ra_en1_r wl6_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd3.mxp14 wl7_l ra_en1_l wl6_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd3.mxp15 wl7_l ra_en0_l wl6_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd3._rowdrv_0.mxn0 wl6_r _wd3._rowdrv_0.nwl vsse vpw nch_mac W=1.2U L=0.035U
+  NF=2
m_wd3._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd3._rowdrv_0.mxn11 wl6_l _wd3._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd3._rowdrv_0.mxn8 _wd3._rowdrv_0.nwl _wd3.rowsel ni0 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd3._rowdrv_0.mxp0 wl6_r _wd3._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd3._rowdrv_0.mxp12 _wd3._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd3._rowdrv_0.mxp13 _wd3._rowdrv_0.nwl _wd3.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd3._rowdrv_0.mxp7 wl6_l _wd3._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd3._rowdrv_1.mxn0 wl7_r _wd3._rowdrv_1.nwl vsse vpw nch_mac W=1.2U L=0.035U
+  NF=2
m_wd3._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd3._rowdrv_1.mxn11 wl7_l _wd3._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd3._rowdrv_1.mxn8 _wd3._rowdrv_1.nwl _wd3.rowsel ni1 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd3._rowdrv_1.mxp0 wl7_r _wd3._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd3._rowdrv_1.mxp12 _wd3._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd3._rowdrv_1.mxp13 _wd3._rowdrv_1.nwl _wd3.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd3._rowdrv_1.mxp7 wl7_l _wd3._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd4.i69.mxn0 _wd4.rowsel nxp1_0 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd4.i69.mxn15 _wd4.rowsel nxp0_4 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd4.i69.mxp1 _wd4.rowsel nxp0_4 _wd4.i69.p1 vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd4.i69.mxp15 _wd4.i69.p1 nxp1_0 vddp_nor vnwp pch_mac W=1.35U L=0.035U NF=1
m_wd4.i69.mx_npd _wd4.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wd4.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U NF=1
m_wd4.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wd4.mxp12 wl9_r ra_en0_r wl8_r vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd4.mxp13 wl9_r ra_en1_r wl8_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd4.mxp14 wl9_l ra_en1_l wl8_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd4.mxp15 wl9_l ra_en0_l wl8_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd4._rowdrv_0.mxn0 wl8_r _wd4._rowdrv_0.nwl vsse vpw nch_mac W=1.2U L=0.035U
+  NF=2
m_wd4._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd4._rowdrv_0.mxn11 wl8_l _wd4._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd4._rowdrv_0.mxn8 _wd4._rowdrv_0.nwl _wd4.rowsel ni0 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd4._rowdrv_0.mxp0 wl8_r _wd4._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd4._rowdrv_0.mxp12 _wd4._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd4._rowdrv_0.mxp13 _wd4._rowdrv_0.nwl _wd4.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd4._rowdrv_0.mxp7 wl8_l _wd4._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd4._rowdrv_1.mxn0 wl9_r _wd4._rowdrv_1.nwl vsse vpw nch_mac W=1.2U L=0.035U
+  NF=2
m_wd4._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd4._rowdrv_1.mxn11 wl9_l _wd4._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd4._rowdrv_1.mxn8 _wd4._rowdrv_1.nwl _wd4.rowsel ni1 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd4._rowdrv_1.mxp0 wl9_r _wd4._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd4._rowdrv_1.mxp12 _wd4._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd4._rowdrv_1.mxp13 _wd4._rowdrv_1.nwl _wd4.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd4._rowdrv_1.mxp7 wl9_l _wd4._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd5.i69.mxn0 _wd5.rowsel nxp1_0 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd5.i69.mxn15 _wd5.rowsel nxp0_5 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd5.i69.mxp1 _wd5.rowsel nxp0_5 _wd5.i69.p1 vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd5.i69.mxp15 _wd5.i69.p1 nxp1_0 vddp_nor vnwp pch_mac W=1.35U L=0.035U NF=1
m_wd5.i69.mx_npd _wd5.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wd5.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U NF=1
m_wd5.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wd5.mxp12 wl11_r ra_en0_r wl10_r vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd5.mxp13 wl11_r ra_en1_r wl10_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd5.mxp14 wl11_l ra_en1_l wl10_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd5.mxp15 wl11_l ra_en0_l wl10_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd5._rowdrv_0.mxn0 wl10_r _wd5._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd5._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd5._rowdrv_0.mxn11 wl10_l _wd5._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd5._rowdrv_0.mxn8 _wd5._rowdrv_0.nwl _wd5.rowsel ni0 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd5._rowdrv_0.mxp0 wl10_r _wd5._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd5._rowdrv_0.mxp12 _wd5._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd5._rowdrv_0.mxp13 _wd5._rowdrv_0.nwl _wd5.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd5._rowdrv_0.mxp7 wl10_l _wd5._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd5._rowdrv_1.mxn0 wl11_r _wd5._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd5._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd5._rowdrv_1.mxn11 wl11_l _wd5._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd5._rowdrv_1.mxn8 _wd5._rowdrv_1.nwl _wd5.rowsel ni1 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd5._rowdrv_1.mxp0 wl11_r _wd5._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd5._rowdrv_1.mxp12 _wd5._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd5._rowdrv_1.mxp13 _wd5._rowdrv_1.nwl _wd5.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd5._rowdrv_1.mxp7 wl11_l _wd5._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd6.i69.mxn0 _wd6.rowsel nxp1_0 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd6.i69.mxn15 _wd6.rowsel nxp0_6 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd6.i69.mxp1 _wd6.rowsel nxp0_6 _wd6.i69.p1 vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd6.i69.mxp15 _wd6.i69.p1 nxp1_0 vddp_nor vnwp pch_mac W=1.35U L=0.035U NF=1
m_wd6.i69.mx_npd _wd6.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wd6.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U NF=1
m_wd6.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wd6.mxp12 wl13_r ra_en0_r wl12_r vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd6.mxp13 wl13_r ra_en1_r wl12_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd6.mxp14 wl13_l ra_en1_l wl12_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd6.mxp15 wl13_l ra_en0_l wl12_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd6._rowdrv_0.mxn0 wl12_r _wd6._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd6._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd6._rowdrv_0.mxn11 wl12_l _wd6._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd6._rowdrv_0.mxn8 _wd6._rowdrv_0.nwl _wd6.rowsel ni0 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd6._rowdrv_0.mxp0 wl12_r _wd6._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd6._rowdrv_0.mxp12 _wd6._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd6._rowdrv_0.mxp13 _wd6._rowdrv_0.nwl _wd6.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd6._rowdrv_0.mxp7 wl12_l _wd6._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd6._rowdrv_1.mxn0 wl13_r _wd6._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd6._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd6._rowdrv_1.mxn11 wl13_l _wd6._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd6._rowdrv_1.mxn8 _wd6._rowdrv_1.nwl _wd6.rowsel ni1 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd6._rowdrv_1.mxp0 wl13_r _wd6._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd6._rowdrv_1.mxp12 _wd6._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd6._rowdrv_1.mxp13 _wd6._rowdrv_1.nwl _wd6.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd6._rowdrv_1.mxp7 wl13_l _wd6._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd7.i69.mxn0 _wd7.rowsel nxp1_0 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd7.i69.mxn15 _wd7.rowsel nxp0_7 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd7.i69.mxp1 _wd7.rowsel nxp0_7 _wd7.i69.p1 vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd7.i69.mxp15 _wd7.i69.p1 nxp1_0 vddp_nor vnwp pch_mac W=1.35U L=0.035U NF=1
m_wd7.i69.mx_npd _wd7.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wd7.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U NF=1
m_wd7.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wd7.mxp12 wl15_r ra_en0_r wl14_r vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd7.mxp13 wl15_r ra_en1_r wl14_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd7.mxp14 wl15_l ra_en1_l wl14_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd7.mxp15 wl15_l ra_en0_l wl14_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd7._rowdrv_0.mxn0 wl14_r _wd7._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd7._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd7._rowdrv_0.mxn11 wl14_l _wd7._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd7._rowdrv_0.mxn8 _wd7._rowdrv_0.nwl _wd7.rowsel ni0 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd7._rowdrv_0.mxp0 wl14_r _wd7._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd7._rowdrv_0.mxp12 _wd7._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd7._rowdrv_0.mxp13 _wd7._rowdrv_0.nwl _wd7.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd7._rowdrv_0.mxp7 wl14_l _wd7._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd7._rowdrv_1.mxn0 wl15_r _wd7._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd7._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd7._rowdrv_1.mxn11 wl15_l _wd7._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd7._rowdrv_1.mxn8 _wd7._rowdrv_1.nwl _wd7.rowsel ni1 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd7._rowdrv_1.mxp0 wl15_r _wd7._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd7._rowdrv_1.mxp12 _wd7._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd7._rowdrv_1.mxp13 _wd7._rowdrv_1.nwl _wd7.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd7._rowdrv_1.mxp7 wl15_l _wd7._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd8.i69.mxn0 _wd8.rowsel nxp1_1 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd8.i69.mxn15 _wd8.rowsel nxp0_0 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd8.i69.mxp1 _wd8.rowsel nxp0_0 _wd8.i69.p1 vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd8.i69.mxp15 _wd8.i69.p1 nxp1_1 vddp_nor vnwp pch_mac W=1.35U L=0.035U NF=1
m_wd8.i69.mx_npd _wd8.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wd8.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U NF=1
m_wd8.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wd8.mxp12 wl17_r ra_en0_r wl16_r vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd8.mxp13 wl17_r ra_en1_r wl16_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd8.mxp14 wl17_l ra_en1_l wl16_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd8.mxp15 wl17_l ra_en0_l wl16_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd8._rowdrv_0.mxn0 wl16_r _wd8._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd8._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd8._rowdrv_0.mxn11 wl16_l _wd8._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd8._rowdrv_0.mxn8 _wd8._rowdrv_0.nwl _wd8.rowsel ni0 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd8._rowdrv_0.mxp0 wl16_r _wd8._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd8._rowdrv_0.mxp12 _wd8._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd8._rowdrv_0.mxp13 _wd8._rowdrv_0.nwl _wd8.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd8._rowdrv_0.mxp7 wl16_l _wd8._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd8._rowdrv_1.mxn0 wl17_r _wd8._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd8._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd8._rowdrv_1.mxn11 wl17_l _wd8._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd8._rowdrv_1.mxn8 _wd8._rowdrv_1.nwl _wd8.rowsel ni1 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd8._rowdrv_1.mxp0 wl17_r _wd8._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd8._rowdrv_1.mxp12 _wd8._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd8._rowdrv_1.mxp13 _wd8._rowdrv_1.nwl _wd8.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd8._rowdrv_1.mxp7 wl17_l _wd8._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd9.i69.mxn0 _wd9.rowsel nxp1_1 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd9.i69.mxn15 _wd9.rowsel nxp0_1 vsse vpw nch_mac W=0.515U L=0.035U NF=1
m_wd9.i69.mxp1 _wd9.rowsel nxp0_1 _wd9.i69.p1 vnwp pch_mac W=1.35U L=0.035U
+  NF=1
m_wd9.i69.mxp15 _wd9.i69.p1 nxp1_1 vddp_nor vnwp pch_mac W=1.35U L=0.035U NF=1
m_wd9.i69.mx_npd _wd9.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wd9.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U NF=1
m_wd9.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wd9.mxp12 wl19_r ra_en0_r wl18_r vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd9.mxp13 wl19_r ra_en1_r wl18_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd9.mxp14 wl19_l ra_en1_l wl18_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wd9.mxp15 wl19_l ra_en0_l wl18_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wd9._rowdrv_0.mxn0 wl18_r _wd9._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd9._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd9._rowdrv_0.mxn11 wl18_l _wd9._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd9._rowdrv_0.mxn8 _wd9._rowdrv_0.nwl _wd9.rowsel ni0 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd9._rowdrv_0.mxp0 wl18_r _wd9._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd9._rowdrv_0.mxp12 _wd9._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd9._rowdrv_0.mxp13 _wd9._rowdrv_0.nwl _wd9.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd9._rowdrv_0.mxp7 wl18_l _wd9._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd9._rowdrv_1.mxn0 wl19_r _wd9._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd9._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wd9._rowdrv_1.mxn11 wl19_l _wd9._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd9._rowdrv_1.mxn8 _wd9._rowdrv_1.nwl _wd9.rowsel ni1 vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wd9._rowdrv_1.mxp0 wl19_r _wd9._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wd9._rowdrv_1.mxp12 _wd9._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac W=0.2U
+  L=0.035U NF=1
m_wd9._rowdrv_1.mxp13 _wd9._rowdrv_1.nwl _wd9.rowsel vddce vnwc pch_mac
+  W=0.16U L=0.035U NF=1
m_wd9._rowdrv_1.mxp7 wl19_l _wd9._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wdxtop.i69.mxn0 _wdxtop.rowsel nxp1_1 vsse vpw nch_mac W=0.515U L=0.035U
+  NF=1
m_wdxtop.i69.mxn15 _wdxtop.rowsel nxp0_7 vsse vpw nch_mac W=0.515U L=0.035U
+  NF=1
m_wdxtop.i69.mxp1 _wdxtop.rowsel nxp0_7 _wdxtop.i69.p1 vnwp pch_mac W=1.35U
+  L=0.035U NF=1
m_wdxtop.i69.mxp15 _wdxtop.i69.p1 nxp1_1 vddp_nor vnwp pch_mac W=1.35U
+  L=0.035U NF=1
m_wdxtop.i69.mx_npd _wdxtop.rowsel ret vsse vpw nch_mac W=0.22U L=0.035U NF=1
m_wdxtop.i69.mx_nr_header vddp_nor ret vddpe vnwp pch_mac W=1.25U L=0.035U
+  NF=1
m_wdxtop.mxn0 dbl_nbl_wa log0 vss vpw nch_mac W=0.21U L=0.035U NF=1
m_wdxtop.mxp12 wl31_r ra_en0_r wl30_r vnwc pch_mac W=0.15U L=0.035U NF=1
m_wdxtop.mxp13 wl31_r ra_en1_r wl30_r vnwc pch_mac W=0.5U L=0.035U NF=1
m_wdxtop.mxp14 wl31_l ra_en1_l wl30_l vnwc pch_mac W=0.5U L=0.035U NF=1
m_wdxtop.mxp15 wl31_l ra_en0_l wl30_l vnwc pch_mac W=0.15U L=0.035U NF=1
m_wdxtop._rowdrv_0.mxn0 wl30_r _wdxtop._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wdxtop._rowdrv_0.mxn10 ni0 rowclk0 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wdxtop._rowdrv_0.mxn11 wl30_l _wdxtop._rowdrv_0.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wdxtop._rowdrv_0.mxn8 _wdxtop._rowdrv_0.nwl _wdxtop.rowsel ni0 vpw nch_mac
+  W=1.2U L=0.035U NF=2
m_wdxtop._rowdrv_0.mxp0 wl30_r _wdxtop._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wdxtop._rowdrv_0.mxp12 _wdxtop._rowdrv_0.nwl rowclk0 vddce vnwc pch_mac
+  W=0.2U L=0.035U NF=1
m_wdxtop._rowdrv_0.mxp13 _wdxtop._rowdrv_0.nwl _wdxtop.rowsel vddce vnwc
+  pch_mac W=0.16U L=0.035U NF=1
m_wdxtop._rowdrv_0.mxp7 wl30_l _wdxtop._rowdrv_0.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wdxtop._rowdrv_1.mxn0 wl31_r _wdxtop._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wdxtop._rowdrv_1.mxn10 ni1 rowclk1 vss vpw nch_mac W=0.24U L=0.035U NF=1
m_wdxtop._rowdrv_1.mxn11 wl31_l _wdxtop._rowdrv_1.nwl vsse vpw nch_mac W=1.2U
+  L=0.035U NF=2
m_wdxtop._rowdrv_1.mxn8 _wdxtop._rowdrv_1.nwl _wdxtop.rowsel ni1 vpw nch_mac
+  W=1.2U L=0.035U NF=2
m_wdxtop._rowdrv_1.mxp0 wl31_r _wdxtop._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_wdxtop._rowdrv_1.mxp12 _wdxtop._rowdrv_1.nwl rowclk1 vddce vnwc pch_mac
+  W=0.2U L=0.035U NF=1
m_wdxtop._rowdrv_1.mxp13 _wdxtop._rowdrv_1.nwl _wdxtop.rowsel vddce vnwc
+  pch_mac W=0.16U L=0.035U NF=1
m_wdxtop._rowdrv_1.mxp7 wl31_l _wdxtop._rowdrv_1.nwl vddi vnwc pch_mac W=3.4U
+  L=0.035U NF=2
m_xdec0._dec.i1_0.mxna1 _xdec0._dec.ndec[0] nra_p2[0] _xdec0._dec.i1_0.n2 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec0._dec.i1_0.mxna2 _xdec0._dec.i1_0.n2 nra_p2[1] _xdec0._dec.i1_0.n1 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec0._dec.i1_0.mxna3 _xdec0._dec.i1_0.n1 nra_p2[2] vss vpw nch_mac W=0.48U
+  L=0.035U NF=1
m_xdec0._dec.i1_0.mxpa1 _xdec0._dec.ndec[0] nra_p2[0] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i1_0.mxpa2 _xdec0._dec.ndec[0] nra_p2[1] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i1_0.mxpa3 _xdec0._dec.ndec[0] nra_p2[2] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i1_1.mxna1 _xdec0._dec.ndec[1] ra_p2[0] _xdec0._dec.i1_1.n2 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec0._dec.i1_1.mxna2 _xdec0._dec.i1_1.n2 nra_p2[1] _xdec0._dec.i1_1.n1 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec0._dec.i1_1.mxna3 _xdec0._dec.i1_1.n1 nra_p2[2] vss vpw nch_mac W=0.48U
+  L=0.035U NF=1
m_xdec0._dec.i1_1.mxpa1 _xdec0._dec.ndec[1] ra_p2[0] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i1_1.mxpa2 _xdec0._dec.ndec[1] nra_p2[1] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i1_1.mxpa3 _xdec0._dec.ndec[1] nra_p2[2] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i1_2.mxna1 _xdec0._dec.ndec[2] nra_p2[0] _xdec0._dec.i1_2.n2 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec0._dec.i1_2.mxna2 _xdec0._dec.i1_2.n2 ra_p2[1] _xdec0._dec.i1_2.n1 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec0._dec.i1_2.mxna3 _xdec0._dec.i1_2.n1 nra_p2[2] vss vpw nch_mac W=0.48U
+  L=0.035U NF=1
m_xdec0._dec.i1_2.mxpa1 _xdec0._dec.ndec[2] nra_p2[0] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i1_2.mxpa2 _xdec0._dec.ndec[2] ra_p2[1] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i1_2.mxpa3 _xdec0._dec.ndec[2] nra_p2[2] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i1_3.mxna1 _xdec0._dec.ndec[3] ra_p2[0] _xdec0._dec.i1_3.n2 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec0._dec.i1_3.mxna2 _xdec0._dec.i1_3.n2 ra_p2[1] _xdec0._dec.i1_3.n1 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec0._dec.i1_3.mxna3 _xdec0._dec.i1_3.n1 nra_p2[2] vss vpw nch_mac W=0.48U
+  L=0.035U NF=1
m_xdec0._dec.i1_3.mxpa1 _xdec0._dec.ndec[3] ra_p2[0] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i1_3.mxpa2 _xdec0._dec.ndec[3] ra_p2[1] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i1_3.mxpa3 _xdec0._dec.ndec[3] nra_p2[2] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i1_4.mxna1 _xdec0._dec.ndec[4] nra_p2[0] _xdec0._dec.i1_4.n2 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec0._dec.i1_4.mxna2 _xdec0._dec.i1_4.n2 nra_p2[1] _xdec0._dec.i1_4.n1 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec0._dec.i1_4.mxna3 _xdec0._dec.i1_4.n1 ra_p2[2] vss vpw nch_mac W=0.48U
+  L=0.035U NF=1
m_xdec0._dec.i1_4.mxpa1 _xdec0._dec.ndec[4] nra_p2[0] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i1_4.mxpa2 _xdec0._dec.ndec[4] nra_p2[1] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i1_4.mxpa3 _xdec0._dec.ndec[4] ra_p2[2] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i1_5.mxna1 _xdec0._dec.ndec[5] ra_p2[0] _xdec0._dec.i1_5.n2 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec0._dec.i1_5.mxna2 _xdec0._dec.i1_5.n2 nra_p2[1] _xdec0._dec.i1_5.n1 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec0._dec.i1_5.mxna3 _xdec0._dec.i1_5.n1 ra_p2[2] vss vpw nch_mac W=0.48U
+  L=0.035U NF=1
m_xdec0._dec.i1_5.mxpa1 _xdec0._dec.ndec[5] ra_p2[0] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i1_5.mxpa2 _xdec0._dec.ndec[5] nra_p2[1] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i1_5.mxpa3 _xdec0._dec.ndec[5] ra_p2[2] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i1_6.mxna1 _xdec0._dec.ndec[6] nra_p2[0] _xdec0._dec.i1_6.n2 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec0._dec.i1_6.mxna2 _xdec0._dec.i1_6.n2 ra_p2[1] _xdec0._dec.i1_6.n1 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec0._dec.i1_6.mxna3 _xdec0._dec.i1_6.n1 ra_p2[2] vss vpw nch_mac W=0.48U
+  L=0.035U NF=1
m_xdec0._dec.i1_6.mxpa1 _xdec0._dec.ndec[6] nra_p2[0] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i1_6.mxpa2 _xdec0._dec.ndec[6] ra_p2[1] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i1_6.mxpa3 _xdec0._dec.ndec[6] ra_p2[2] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i1_7.mxna1 _xdec0._dec.ndec[7] ra_p2[0] _xdec0._dec.i1_7.n2 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec0._dec.i1_7.mxna2 _xdec0._dec.i1_7.n2 ra_p2[1] _xdec0._dec.i1_7.n1 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec0._dec.i1_7.mxna3 _xdec0._dec.i1_7.n1 ra_p2[2] vss vpw nch_mac W=0.48U
+  L=0.035U NF=1
m_xdec0._dec.i1_7.mxpa1 _xdec0._dec.ndec[7] ra_p2[0] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i1_7.mxpa2 _xdec0._dec.ndec[7] ra_p2[1] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i1_7.mxpa3 _xdec0._dec.ndec[7] ra_p2[2] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec0._dec.i3_0.mxna1 _xdec0.xp[0] _xdec0._dec.ndec[0] vss vpw nch_mac
+  W=0.39U L=0.035U NF=3
m_xdec0._dec.i3_0.mxpa1 _xdec0.xp[0] _xdec0._dec.ndec[0] vddpe vnwp pch_mac
+  W=0.6U L=0.035U NF=2
m_xdec0._dec.i3_1.mxna1 _xdec0.xp[1] _xdec0._dec.ndec[1] vss vpw nch_mac
+  W=0.39U L=0.035U NF=3
m_xdec0._dec.i3_1.mxpa1 _xdec0.xp[1] _xdec0._dec.ndec[1] vddpe vnwp pch_mac
+  W=0.6U L=0.035U NF=2
m_xdec0._dec.i3_2.mxna1 _xdec0.xp[2] _xdec0._dec.ndec[2] vss vpw nch_mac
+  W=0.39U L=0.035U NF=3
m_xdec0._dec.i3_2.mxpa1 _xdec0.xp[2] _xdec0._dec.ndec[2] vddpe vnwp pch_mac
+  W=0.6U L=0.035U NF=2
m_xdec0._dec.i3_3.mxna1 _xdec0.xp[3] _xdec0._dec.ndec[3] vss vpw nch_mac
+  W=0.39U L=0.035U NF=3
m_xdec0._dec.i3_3.mxpa1 _xdec0.xp[3] _xdec0._dec.ndec[3] vddpe vnwp pch_mac
+  W=0.6U L=0.035U NF=2
m_xdec0._dec.i3_4.mxna1 _xdec0.xp[4] _xdec0._dec.ndec[4] vss vpw nch_mac
+  W=0.39U L=0.035U NF=3
m_xdec0._dec.i3_4.mxpa1 _xdec0.xp[4] _xdec0._dec.ndec[4] vddpe vnwp pch_mac
+  W=0.6U L=0.035U NF=2
m_xdec0._dec.i3_5.mxna1 _xdec0.xp[5] _xdec0._dec.ndec[5] vss vpw nch_mac
+  W=0.39U L=0.035U NF=3
m_xdec0._dec.i3_5.mxpa1 _xdec0.xp[5] _xdec0._dec.ndec[5] vddpe vnwp pch_mac
+  W=0.6U L=0.035U NF=2
m_xdec0._dec.i3_6.mxna1 _xdec0.xp[6] _xdec0._dec.ndec[6] vss vpw nch_mac
+  W=0.39U L=0.035U NF=3
m_xdec0._dec.i3_6.mxpa1 _xdec0.xp[6] _xdec0._dec.ndec[6] vddpe vnwp pch_mac
+  W=0.6U L=0.035U NF=2
m_xdec0._dec.i3_7.mxna1 _xdec0.xp[7] _xdec0._dec.ndec[7] vss vpw nch_mac
+  W=0.39U L=0.035U NF=3
m_xdec0._dec.i3_7.mxpa1 _xdec0.xp[7] _xdec0._dec.ndec[7] vddpe vnwp pch_mac
+  W=0.6U L=0.035U NF=2
m_xdec0._iv_nxp_0.mxna1 nxp0_0 _xdec0.xp[0] vss vpw nch_mac W=1.68U L=0.035U
+  NF=4
m_xdec0._iv_nxp_0.mxpa1 nxp0_0 _xdec0.xp[0] vddpe vnwp pch_mac W=2.24U
+  L=0.035U NF=4
m_xdec0._iv_nxp_1.mxna1 nxp0_1 _xdec0.xp[1] vss vpw nch_mac W=1.68U L=0.035U
+  NF=4
m_xdec0._iv_nxp_1.mxpa1 nxp0_1 _xdec0.xp[1] vddpe vnwp pch_mac W=2.24U
+  L=0.035U NF=4
m_xdec0._iv_nxp_2.mxna1 nxp0_2 _xdec0.xp[2] vss vpw nch_mac W=1.68U L=0.035U
+  NF=4
m_xdec0._iv_nxp_2.mxpa1 nxp0_2 _xdec0.xp[2] vddpe vnwp pch_mac W=2.24U
+  L=0.035U NF=4
m_xdec0._iv_nxp_3.mxna1 nxp0_3 _xdec0.xp[3] vss vpw nch_mac W=1.68U L=0.035U
+  NF=4
m_xdec0._iv_nxp_3.mxpa1 nxp0_3 _xdec0.xp[3] vddpe vnwp pch_mac W=2.24U
+  L=0.035U NF=4
m_xdec0._iv_nxp_4.mxna1 nxp0_4 _xdec0.xp[4] vss vpw nch_mac W=1.68U L=0.035U
+  NF=4
m_xdec0._iv_nxp_4.mxpa1 nxp0_4 _xdec0.xp[4] vddpe vnwp pch_mac W=2.24U
+  L=0.035U NF=4
m_xdec0._iv_nxp_5.mxna1 nxp0_5 _xdec0.xp[5] vss vpw nch_mac W=1.68U L=0.035U
+  NF=4
m_xdec0._iv_nxp_5.mxpa1 nxp0_5 _xdec0.xp[5] vddpe vnwp pch_mac W=2.24U
+  L=0.035U NF=4
m_xdec0._iv_nxp_6.mxna1 nxp0_6 _xdec0.xp[6] vss vpw nch_mac W=1.68U L=0.035U
+  NF=4
m_xdec0._iv_nxp_6.mxpa1 nxp0_6 _xdec0.xp[6] vddpe vnwp pch_mac W=2.24U
+  L=0.035U NF=4
m_xdec0._iv_nxp_7.mxna1 nxp0_7 _xdec0.xp[7] vss vpw nch_mac W=1.68U L=0.035U
+  NF=4
m_xdec0._iv_nxp_7.mxpa1 nxp0_7 _xdec0.xp[7] vddpe vnwp pch_mac W=2.24U
+  L=0.035U NF=4
m_xdec1._dec.i1_0.mxna1 _xdec1._dec.ndec[0] nra_p2[3] _xdec1._dec.i1_0.n2 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec1._dec.i1_0.mxna2 _xdec1._dec.i1_0.n2 nra_p2[4] _xdec1._dec.i1_0.n1 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec1._dec.i1_0.mxna3 _xdec1._dec.i1_0.n1 nra_p2[5] vss vpw nch_mac W=0.48U
+  L=0.035U NF=1
m_xdec1._dec.i1_0.mxpa1 _xdec1._dec.ndec[0] nra_p2[3] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i1_0.mxpa2 _xdec1._dec.ndec[0] nra_p2[4] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i1_0.mxpa3 _xdec1._dec.ndec[0] nra_p2[5] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i1_1.mxna1 _xdec1._dec.ndec[1] ra_p2[3] _xdec1._dec.i1_1.n2 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec1._dec.i1_1.mxna2 _xdec1._dec.i1_1.n2 nra_p2[4] _xdec1._dec.i1_1.n1 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec1._dec.i1_1.mxna3 _xdec1._dec.i1_1.n1 nra_p2[5] vss vpw nch_mac W=0.48U
+  L=0.035U NF=1
m_xdec1._dec.i1_1.mxpa1 _xdec1._dec.ndec[1] ra_p2[3] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i1_1.mxpa2 _xdec1._dec.ndec[1] nra_p2[4] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i1_1.mxpa3 _xdec1._dec.ndec[1] nra_p2[5] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i1_2.mxna1 _xdec1._dec.ndec[2] nra_p2[3] _xdec1._dec.i1_2.n2 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec1._dec.i1_2.mxna2 _xdec1._dec.i1_2.n2 ra_p2[4] _xdec1._dec.i1_2.n1 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec1._dec.i1_2.mxna3 _xdec1._dec.i1_2.n1 nra_p2[5] vss vpw nch_mac W=0.48U
+  L=0.035U NF=1
m_xdec1._dec.i1_2.mxpa1 _xdec1._dec.ndec[2] nra_p2[3] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i1_2.mxpa2 _xdec1._dec.ndec[2] ra_p2[4] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i1_2.mxpa3 _xdec1._dec.ndec[2] nra_p2[5] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i1_3.mxna1 _xdec1._dec.ndec[3] ra_p2[3] _xdec1._dec.i1_3.n2 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec1._dec.i1_3.mxna2 _xdec1._dec.i1_3.n2 ra_p2[4] _xdec1._dec.i1_3.n1 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec1._dec.i1_3.mxna3 _xdec1._dec.i1_3.n1 nra_p2[5] vss vpw nch_mac W=0.48U
+  L=0.035U NF=1
m_xdec1._dec.i1_3.mxpa1 _xdec1._dec.ndec[3] ra_p2[3] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i1_3.mxpa2 _xdec1._dec.ndec[3] ra_p2[4] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i1_3.mxpa3 _xdec1._dec.ndec[3] nra_p2[5] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i1_4.mxna1 _xdec1._dec.ndec[4] nra_p2[3] _xdec1._dec.i1_4.n2 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec1._dec.i1_4.mxna2 _xdec1._dec.i1_4.n2 nra_p2[4] _xdec1._dec.i1_4.n1 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec1._dec.i1_4.mxna3 _xdec1._dec.i1_4.n1 ra_p2[5] vss vpw nch_mac W=0.48U
+  L=0.035U NF=1
m_xdec1._dec.i1_4.mxpa1 _xdec1._dec.ndec[4] nra_p2[3] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i1_4.mxpa2 _xdec1._dec.ndec[4] nra_p2[4] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i1_4.mxpa3 _xdec1._dec.ndec[4] ra_p2[5] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i1_5.mxna1 _xdec1._dec.ndec[5] ra_p2[3] _xdec1._dec.i1_5.n2 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec1._dec.i1_5.mxna2 _xdec1._dec.i1_5.n2 nra_p2[4] _xdec1._dec.i1_5.n1 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec1._dec.i1_5.mxna3 _xdec1._dec.i1_5.n1 ra_p2[5] vss vpw nch_mac W=0.48U
+  L=0.035U NF=1
m_xdec1._dec.i1_5.mxpa1 _xdec1._dec.ndec[5] ra_p2[3] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i1_5.mxpa2 _xdec1._dec.ndec[5] nra_p2[4] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i1_5.mxpa3 _xdec1._dec.ndec[5] ra_p2[5] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i1_6.mxna1 _xdec1._dec.ndec[6] nra_p2[3] _xdec1._dec.i1_6.n2 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec1._dec.i1_6.mxna2 _xdec1._dec.i1_6.n2 ra_p2[4] _xdec1._dec.i1_6.n1 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec1._dec.i1_6.mxna3 _xdec1._dec.i1_6.n1 ra_p2[5] vss vpw nch_mac W=0.48U
+  L=0.035U NF=1
m_xdec1._dec.i1_6.mxpa1 _xdec1._dec.ndec[6] nra_p2[3] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i1_6.mxpa2 _xdec1._dec.ndec[6] ra_p2[4] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i1_6.mxpa3 _xdec1._dec.ndec[6] ra_p2[5] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i1_7.mxna1 _xdec1._dec.ndec[7] ra_p2[3] _xdec1._dec.i1_7.n2 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec1._dec.i1_7.mxna2 _xdec1._dec.i1_7.n2 ra_p2[4] _xdec1._dec.i1_7.n1 vpw
+  nch_mac W=0.48U L=0.035U NF=1
m_xdec1._dec.i1_7.mxna3 _xdec1._dec.i1_7.n1 ra_p2[5] vss vpw nch_mac W=0.48U
+  L=0.035U NF=1
m_xdec1._dec.i1_7.mxpa1 _xdec1._dec.ndec[7] ra_p2[3] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i1_7.mxpa2 _xdec1._dec.ndec[7] ra_p2[4] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i1_7.mxpa3 _xdec1._dec.ndec[7] ra_p2[5] vddpe vnwp pch_mac
+  W=0.36U L=0.035U NF=1
m_xdec1._dec.i3_0.mxna1 _xdec1.xp[0] _xdec1._dec.ndec[0] vss vpw nch_mac
+  W=0.39U L=0.035U NF=3
m_xdec1._dec.i3_0.mxpa1 _xdec1.xp[0] _xdec1._dec.ndec[0] vddpe vnwp pch_mac
+  W=0.6U L=0.035U NF=2
m_xdec1._dec.i3_1.mxna1 _xdec1.xp[1] _xdec1._dec.ndec[1] vss vpw nch_mac
+  W=0.39U L=0.035U NF=3
m_xdec1._dec.i3_1.mxpa1 _xdec1.xp[1] _xdec1._dec.ndec[1] vddpe vnwp pch_mac
+  W=0.6U L=0.035U NF=2
m_xdec1._dec.i3_2.mxna1 _xdec1.xp[2] _xdec1._dec.ndec[2] vss vpw nch_mac
+  W=0.39U L=0.035U NF=3
m_xdec1._dec.i3_2.mxpa1 _xdec1.xp[2] _xdec1._dec.ndec[2] vddpe vnwp pch_mac
+  W=0.6U L=0.035U NF=2
m_xdec1._dec.i3_3.mxna1 _xdec1.xp[3] _xdec1._dec.ndec[3] vss vpw nch_mac
+  W=0.39U L=0.035U NF=3
m_xdec1._dec.i3_3.mxpa1 _xdec1.xp[3] _xdec1._dec.ndec[3] vddpe vnwp pch_mac
+  W=0.6U L=0.035U NF=2
m_xdec1._dec.i3_4.mxna1 _xdec1.xp[4] _xdec1._dec.ndec[4] vss vpw nch_mac
+  W=0.39U L=0.035U NF=3
m_xdec1._dec.i3_4.mxpa1 _xdec1.xp[4] _xdec1._dec.ndec[4] vddpe vnwp pch_mac
+  W=0.6U L=0.035U NF=2
m_xdec1._dec.i3_5.mxna1 _xdec1.xp[5] _xdec1._dec.ndec[5] vss vpw nch_mac
+  W=0.39U L=0.035U NF=3
m_xdec1._dec.i3_5.mxpa1 _xdec1.xp[5] _xdec1._dec.ndec[5] vddpe vnwp pch_mac
+  W=0.6U L=0.035U NF=2
m_xdec1._dec.i3_6.mxna1 _xdec1.xp[6] _xdec1._dec.ndec[6] vss vpw nch_mac
+  W=0.39U L=0.035U NF=3
m_xdec1._dec.i3_6.mxpa1 _xdec1.xp[6] _xdec1._dec.ndec[6] vddpe vnwp pch_mac
+  W=0.6U L=0.035U NF=2
m_xdec1._dec.i3_7.mxna1 _xdec1.xp[7] _xdec1._dec.ndec[7] vss vpw nch_mac
+  W=0.39U L=0.035U NF=3
m_xdec1._dec.i3_7.mxpa1 _xdec1.xp[7] _xdec1._dec.ndec[7] vddpe vnwp pch_mac
+  W=0.6U L=0.035U NF=2
m_xdec1._iv_nxp_0.mxna1 nxp1_0 _xdec1.xp[0] vss vpw nch_mac W=1.68U L=0.035U
+  NF=4
m_xdec1._iv_nxp_0.mxpa1 nxp1_0 _xdec1.xp[0] vddpe vnwp pch_mac W=2.24U
+  L=0.035U NF=4
m_xdec1._iv_nxp_1.mxna1 nxp1_1 _xdec1.xp[1] vss vpw nch_mac W=1.68U L=0.035U
+  NF=4
m_xdec1._iv_nxp_1.mxpa1 nxp1_1 _xdec1.xp[1] vddpe vnwp pch_mac W=2.24U
+  L=0.035U NF=4
m_xdec1._iv_nxp_2.mxna1 nxp1_2 _xdec1.xp[2] vss vpw nch_mac W=1.68U L=0.035U
+  NF=4
m_xdec1._iv_nxp_2.mxpa1 nxp1_2 _xdec1.xp[2] vddpe vnwp pch_mac W=2.24U
+  L=0.035U NF=4
m_xdec1._iv_nxp_3.mxna1 nxp1_3 _xdec1.xp[3] vss vpw nch_mac W=1.68U L=0.035U
+  NF=4
m_xdec1._iv_nxp_3.mxpa1 nxp1_3 _xdec1.xp[3] vddpe vnwp pch_mac W=2.24U
+  L=0.035U NF=4
m_xdec1._iv_nxp_4.mxna1 nxp1_4 _xdec1.xp[4] vss vpw nch_mac W=1.68U L=0.035U
+  NF=4
m_xdec1._iv_nxp_4.mxpa1 nxp1_4 _xdec1.xp[4] vddpe vnwp pch_mac W=2.24U
+  L=0.035U NF=4
m_xdec1._iv_nxp_5.mxna1 nxp1_5 _xdec1.xp[5] vss vpw nch_mac W=1.68U L=0.035U
+  NF=4
m_xdec1._iv_nxp_5.mxpa1 nxp1_5 _xdec1.xp[5] vddpe vnwp pch_mac W=2.24U
+  L=0.035U NF=4
m_xdec1._iv_nxp_6.mxna1 nxp1_6 _xdec1.xp[6] vss vpw nch_mac W=1.68U L=0.035U
+  NF=4
m_xdec1._iv_nxp_6.mxpa1 nxp1_6 _xdec1.xp[6] vddpe vnwp pch_mac W=2.24U
+  L=0.035U NF=4
m_xdec1._iv_nxp_7.mxna1 nxp1_7 _xdec1.xp[7] vss vpw nch_mac W=1.68U L=0.035U
+  NF=4
m_xdec1._iv_nxp_7.mxpa1 nxp1_7 _xdec1.xp[7] vddpe vnwp pch_mac W=2.24U
+  L=0.035U NF=4
.ends rf64x128wdx32
****
.subckt rf64x128wddrvcol ret niactc vpw vddc_wl dbl_nbl_wa nact_cc niretnvt
+  actp vddce vddp_nor vddpe log1 log0 log0_sa dbl dwl gtpclk1 gtpclk0
+  nla_p2[1] nla_p2[0] la_p2[1] la_p2[0] nra_p2[5] nra_p2[4] nra_p2[3]
+  nra_p2[2] nra_p2[1] nra_p2[0] ra_p2[5] ra_p2[4] ra_p2[3] ra_p2[2] ra_p2[1]
+  ra_p2[0] rawlm1 rawlm0 rawl cen_p2 nret ret1n ema[0] ema[1] ema[2] vddc_r_1
+  vssc_r_2 wl31_r wl30_r wl29_r wl28_r wl27_r wl26_r wl25_r wl24_r wl23_r
+  vssc_r_1 wl22_r wl21_r wl20_r wl19_r wl18_r wl17_r wl16_r wl15_r wl14_r
+  wl13_r wl12_r wl11_r wl10_r wl9_r wl8_r wl7_r wl6_r wl5_r wl4_r wl3_r wl2_r
+  wl1_r wl0_r vssc_r_0 vddc_r_0 vddc_l_1 vssc_l_2 wl31_l wl30_l wl29_l wl28_l
+  wl27_l wl26_l wl25_l wl24_l wl23_l wl22_l wl21_l wl20_l wl19_l wl18_l
+  wl17_l wl16_l wl15_l wl14_l wl13_l wl12_l wl11_l wl10_l wl9_l wl8_l wl7_l
+  wl6_l wl5_l wl4_l wl3_l wl2_l wl1_l vssc_l_1 wl0_l vssc_l_0 vddc_l_0
** rf64x128wddrvcol: 685 flat devices **
xwd_bot log0_sa nact_cc actp dbl dbl_nbl_wa dbl_nbl_wa dwl log1 log0 log1
+  nhdr_wl ni0_term ni1_term niactc niretnvt nxp0_0 nxp0_1 nxp0_2 nxp0_3
+  nxp0_4 nxp0_5 nxp0_6 nxp0_7 nxp1_0 nxp1_1 nxp1_2 nxp1_3 nxp1_4 nxp1_5
+  nxp1_6 nxp1_7 rowclk0 rowclk1 vddce vddc_wl vddp_nor vddpe vddce vddpe vpw
+  vpw vssc_l_1 vssc_r_1 vpw wl0_l wl0_r wl1_l wl1_r wl2_l wl2_r wl3_l wl3_r
+  wl4_l wl4_r wl5_l wl5_r wl6_l wl6_r wl7_l wl7_r wl8_l wl8_r wl9_l wl9_r
+  wl10_l wl10_r wl11_l wl11_r wl12_l wl12_r wl13_l wl13_r wl14_l wl14_r
+  wl15_l wl15_r wl16_l wl16_r wl17_l wl17_r wl18_l wl18_r wl19_l wl19_r
+  wl20_l wl20_r wl21_l wl21_r wl22_l wl22_r wl23_l wl23_r wl24_l wl24_r
+  wl25_l wl25_r wl26_l wl26_r wl27_l wl27_r wl28_l wl28_r wl29_l wl29_r
+  wl30_l wl30_r wl31_l wl31_r ema[0] ema[1] ema[2] gtpclk0 gtpclk1 la_p2[0]
+  la_p2[1] nla_p2[0] nla_p2[1] nra_p2[0] nra_p2[1] nra_p2[2] nra_p2[3]
+  nra_p2[4] nra_p2[5] ra_en0 ra_en0 ra_en1 ra_en1 ra_p2[0] ra_p2[1] ra_p2[2]
+  ra_p2[3] ra_p2[4] ra_p2[5] ret rf64x128wdx32
xwd_cap actp dbl_nbl_wa log0 nhdr_wl ni1_term ni0_term niactc niretnvt nxp0_0
+  nxp0_1 nxp0_2 nxp0_3 nxp0_4 nxp0_5 nxp0_6 nxp0_7 nxp1_0 nxp1_1 nxp1_2
+  nxp1_3 nxp1_4 nxp1_5 nxp1_6 nxp1_7 ra_en0 ra_en0 ra_en1 ra_en1 ret rowclk1
+  rowclk0 vpw vpw vddc_l_1 vddc_r_1 vddc_wl vddce vddp_nor vddpe vddce vddpe
+  vpw vpw vssc_l_2 vssc_r_2 vpw rf64x128wdtop
xwdbot nret ret actp dbl dbl_nbl_wa dbl_nbl_wa dbl dwl ema[0] ema[1] ema[2]
+  gtpclk0 gtpclk1 la_p2[0] la_p2[1] log0 log0_sa log1 nact_cc niactc nhdr_wl
+  ni0_term ni1_term nla_p2[0] nla_p2[1] nra_p2[0] nra_p2[1] nra_p2[2]
+  nra_p2[3] nra_p2[4] nra_p2[5] niretnvt ra_en0 ra_en1 ra_p2[0] ra_p2[1]
+  ra_p2[2] ra_p2[3] ra_p2[4] ra_p2[5] rawl rawlm0 rawlm1 vddc_l_0 vddc_r_0
+  vddce vddc_wl vddp_nor vddpe vddce vddpe vpw vpw vssc_l_0 vssc_r_0 vpw
+  cen_p2 ret1n rf64x128wdbot
.ends rf64x128wddrvcol
****
.subckt rf64x128mem_slice nbl[2]_63 bl[1]_63 bl[0]_63 bl[3]_62 nbl[3]_62
+  nbl[2]_62 bl[2]_62 bl[1]_62 nbl[0]_62 bl[3]_61 nbl[2]_61 bl[2]_61 nbl[0]_61
+  bl[3]_60 nbl[2]_60 bl[2]_60 nbl[0]_60 bl[0]_60 bl[3]_59 nbl[2]_59 bl[2]_59
+  nbl[0]_59 bl[0]_59 bl[3]_58 nbl[2]_58 bl[2]_58 nbl[0]_58 bl[0]_58 bl[3]_57
+  nbl[2]_57 bl[2]_57 nbl[0]_57 bl[2]_56 nbl[0]_56 bl[2]_55 nbl[0]_55 bl[2]_54
+  nbl[0]_54 bl[2]_53 nbl[0]_53 bl[2]_52 nbl[0]_52 nbl[1]_51 nbl[0]_51
+  bl[3]_50 nbl[3]_50 bl[1]_50 nbl[1]_50 nbl[0]_50 nbl[3]_49 bl[1]_49
+  nbl[1]_49 nbl[0]_49 bl[3]_48 nbl[3]_48 bl[1]_48 nbl[1]_48 nbl[0]_48
+  nbl[3]_47 bl[1]_47 nbl[1]_47 nbl[0]_47 bl[3]_46 nbl[3]_46 bl[1]_46
+  nbl[1]_46 nbl[0]_46 bl[3]_45 nbl[3]_45 bl[1]_45 nbl[1]_45 bl[3]_44
+  nbl[3]_44 bl[1]_44 bl[0]_44 bl[3]_43 nbl[3]_43 nbl[2]_43 bl[2]_43 bl[1]_43
+  nbl[0]_43 bl[0]_43 bl[3]_42 nbl[3]_42 nbl[2]_42 bl[2]_42 bl[1]_42 nbl[0]_42
+  bl[0]_42 bl[3]_41 nbl[3]_41 nbl[2]_41 bl[2]_41 bl[1]_41 nbl[0]_41 bl[0]_41
+  bl[3]_40 nbl[3]_40 nbl[2]_40 bl[2]_40 bl[1]_40 nbl[1]_40 nbl[0]_40 bl[0]_40
+  bl[3]_39 nbl[2]_39 bl[2]_39 nbl[1]_39 nbl[0]_39 bl[0]_39 bl[3]_38 nbl[2]_38
+  bl[2]_38 nbl[1]_38 nbl[0]_38 bl[3]_37 bl[2]_37 vddc nbl[0]_37 bl[3]_36
+  bl[2]_36 nbl[0]_36 bl[3]_35 bl[2]_35 nbl[0]_35 bl[3]_34 bl[2]_34 nbl[1]_34
+  nbl[0]_34 bl[3]_33 bl[2]_33 nbl[1]_33 nbl[0]_33 bl[3]_32 bl[2]_32 nbl[1]_32
+  nbl[0]_32 ret niactc actp vddc_wl vnwp_1 nbl[0]_31 bl[3]_31 nbl[0]_30
+  nbl[1]_30 bl[3]_30 nbl[0]_29 nbl[1]_29 nbl[3]_29 bl[3]_29 nbl[0]_28
+  nbl[1]_28 nbl[3]_28 bl[3]_28 nbl[0]_27 nbl[1]_27 nbl[3]_27 bl[3]_27
+  nbl[0]_26 nbl[1]_26 nbl[3]_26 bl[3]_26 nbl[0]_25 bl[1]_25 nbl[3]_25
+  bl[3]_25 nbl[1]_24 bl[1]_24 nbl[3]_24 bl[3]_24 nbl[1]_23 bl[1]_23 nbl[3]_23
+  bl[3]_23 nbl[1]_22 bl[1]_22 nbl[3]_22 bl[3]_22 nbl[1]_21 bl[1]_21 bl[2]_21
+  nbl[3]_21 bl[3]_21 nbl[1]_20 bl[1]_20 bl[2]_20 nbl[3]_20 bl[3]_20 nbl[1]_19
+  bl[2]_19 nbl[2]_19 bl[3]_19 nbl[0]_18 nbl[1]_18 bl[2]_18 bl[3]_18 nbl[0]_17
+  nbl[1]_17 bl[2]_17 bl[3]_17 nbl[0]_16 nbl[1]_16 bl[2]_16 bl[3]_16 nbl[0]_15
+  nbl[1]_15 bl[2]_15 bl[3]_15 nbl[0]_14 nbl[1]_14 bl[2]_14 bl[0]_13 nbl[0]_13
+  nbl[1]_13 bl[2]_13 nbl[2]_13 bl[0]_12 nbl[0]_12 nbl[1]_12 bl[2]_12
+  nbl[0]_11 nbl[1]_11 nbl[0]_10 nbl[1]_10 nbl[0]_9 nbl[1]_9 nbl[0]_8 nbl[1]_8
+  nbl[2]_8 bl[0]_7 bl[1]_7 nbl[2]_7 bl[0]_6 bl[1]_6 nbl[2]_6 bl[0]_5 nbl[2]_5
+  nbl[3]_5 bl[3]_5 bl[0]_4 nbl[3]_4 bl[3]_4 bl[0]_3 nbl[2]_3 nbl[3]_3 bl[3]_3
+  bl[0]_2 nbl[2]_2 bl[3]_2 bl[0]_1 nbl[2]_1 bl[3]_1 bl[0]_0 nbl[2]_0 bl[3]_0
+  vnwp_0 vnwp_3 bl[3]_63 nbl[3]_63 bl[2]_63 nbl[1]_63 nbl[0]_63 nbl[1]_62
+  bl[0]_62 nbl[3]_61 bl[1]_61 nbl[1]_61 bl[0]_61 nbl[3]_60 bl[1]_60 nbl[1]_60
+  nbl[3]_59 bl[1]_59 nbl[1]_59 nbl[3]_58 bl[1]_58 nbl[1]_58 nbl[3]_57
+  bl[1]_57 nbl[1]_57 bl[0]_57 bl[3]_56 nbl[3]_56 nbl[2]_56 bl[1]_56 nbl[1]_56
+  bl[0]_56 bl[3]_55 nbl[3]_55 nbl[2]_55 bl[1]_55 nbl[1]_55 bl[0]_55 bl[3]_54
+  nbl[3]_54 nbl[2]_54 bl[1]_54 nbl[1]_54 bl[0]_54 bl[3]_53 nbl[3]_53
+  nbl[2]_53 bl[1]_53 nbl[1]_53 bl[0]_53 bl[3]_52 nbl[3]_52 nbl[2]_52 bl[1]_52
+  nbl[1]_52 bl[0]_52 bl[3]_51 nbl[3]_51 nbl[2]_51 bl[2]_51 bl[1]_51 bl[0]_51
+  nbl[2]_50 bl[2]_50 bl[0]_50 bl[3]_49 nbl[2]_49 bl[2]_49 bl[0]_49 nbl[2]_48
+  bl[2]_48 bl[0]_48 bl[3]_47 nbl[2]_47 bl[2]_47 bl[0]_47 nbl[2]_46 bl[2]_46
+  bl[0]_46 nbl[2]_45 bl[2]_45 nbl[0]_45 bl[0]_45 nbl[2]_44 bl[2]_44 nbl[1]_44
+  nbl[0]_44 nbl[1]_43 nbl[1]_42 nbl[1]_41 nbl[3]_39 bl[1]_39 nbl[3]_38
+  bl[1]_38 bl[0]_38 nbl[3]_37 nbl[2]_37 bl[1]_37 nbl[1]_37 bl[0]_37 nbl[3]_36
+  nbl[2]_36 bl[1]_36 nbl[1]_36 bl[0]_36 nbl[3]_35 nbl[2]_35 bl[1]_35
+  nbl[1]_35 bl[0]_35 nbl[3]_34 nbl[2]_34 bl[1]_34 bl[0]_34 nbl[3]_33
+  nbl[2]_33 bl[1]_33 bl[0]_33 nbl[3]_32 nbl[2]_32 bl[1]_32 bl[0]_32 vnwp_2
+  dbl_nbl_wa nact_cc niretnvt vddp_nor vddpe log1 log0 log0_sa dbl_1 dwl_1
+  gtpclk1 gtpclk0 nla_p2[1] nla_p2[0] la_p2[1] la_p2[0] nra_p2[5] nra_p2[4]
+  nra_p2[3] nra_p2[2] nra_p2[1] nra_p2[0] ra_p2[5] ra_p2[4] ra_p2[3] ra_p2[2]
+  ra_p2[1] ra_p2[0] rawlm1 rawlm0 rawl cen_p2 nret ret1n ema[0] ema[1] ema[2]
+  dbl_0 dwl_0 bl[0]_31 nbl[1]_31 bl[1]_31 bl[2]_31 nbl[2]_31 nbl[3]_31
+  bl[0]_30 bl[1]_30 bl[2]_30 nbl[2]_30 nbl[3]_30 bl[0]_29 bl[1]_29 bl[2]_29
+  nbl[2]_29 bl[0]_28 bl[1]_28 bl[2]_28 nbl[2]_28 bl[0]_27 bl[1]_27 bl[2]_27
+  nbl[2]_27 bl[0]_26 bl[1]_26 bl[2]_26 nbl[2]_26 bl[0]_25 nbl[1]_25 bl[2]_25
+  nbl[2]_25 bl[0]_24 nbl[0]_24 vpw bl[2]_24 nbl[2]_24 bl[0]_23 nbl[0]_23
+  bl[2]_23 nbl[2]_23 bl[0]_22 nbl[0]_22 bl[2]_22 nbl[2]_22 bl[0]_21 nbl[0]_21
+  nbl[2]_21 bl[0]_20 nbl[0]_20 nbl[2]_20 bl[0]_19 nbl[0]_19 bl[1]_19
+  nbl[3]_19 bl[0]_18 bl[1]_18 nbl[2]_18 nbl[3]_18 bl[0]_17 bl[1]_17 nbl[2]_17
+  nbl[3]_17 bl[0]_16 bl[1]_16 nbl[2]_16 nbl[3]_16 bl[0]_15 bl[1]_15 nbl[2]_15
+  nbl[3]_15 bl[0]_14 bl[1]_14 nbl[2]_14 nbl[3]_14 bl[3]_14 bl[1]_13 nbl[3]_13
+  bl[3]_13 bl[1]_12 nbl[2]_12 nbl[3]_12 bl[3]_12 bl[0]_11 bl[1]_11 bl[2]_11
+  nbl[2]_11 nbl[3]_11 bl[3]_11 bl[0]_10 bl[1]_10 bl[2]_10 nbl[2]_10 nbl[3]_10
+  bl[3]_10 bl[0]_9 bl[1]_9 bl[2]_9 nbl[2]_9 nbl[3]_9 bl[3]_9 bl[0]_8 bl[1]_8
+  bl[2]_8 nbl[3]_8 bl[3]_8 nbl[0]_7 nbl[1]_7 bl[2]_7 nbl[3]_7 bl[3]_7
+  nbl[0]_6 nbl[1]_6 bl[2]_6 nbl[3]_6 bl[3]_6 nbl[0]_5 nbl[1]_5 bl[1]_5
+  bl[2]_5 nbl[0]_4 nbl[1]_4 bl[1]_4 bl[2]_4 nbl[2]_4 nbl[0]_3 nbl[1]_3
+  bl[1]_3 bl[2]_3 nbl[0]_2 nbl[1]_2 bl[1]_2 bl[2]_2 nbl[3]_2 nbl[0]_1
+  nbl[1]_1 bl[1]_1 bl[2]_1 nbl[3]_1 nbl[0]_0 nbl[1]_0 bl[1]_0 bl[2]_0
+  nbl[3]_0
** rf64x128mem_slice: 50029 flat devices **
xmemcore_l vddc bl[2]_31 bl[2]_30 nbl[2]_30 nbl[3]_30 bl[2]_29 nbl[2]_29
+  bl[1]_28 bl[2]_28 nbl[2]_28 nbl[3]_28 bl[1]_27 bl[2]_27 nbl[2]_27 nbl[3]_27
+  bl[1]_26 nbl[2]_26 nbl[3]_26 bl[1]_25 bl[2]_25 nbl[2]_25 nbl[3]_25
+  nbl[1]_24 bl[1]_24 bl[2]_24 nbl[2]_24 nbl[1]_23 bl[1]_23 vpw bl[2]_23
+  nbl[2]_23 bl[0]_22 nbl[1]_22 bl[1]_22 nbl[2]_22 bl[0]_21 nbl[0]_21
+  nbl[1]_21 bl[1]_21 nbl[2]_21 bl[0]_20 nbl[0]_20 nbl[1]_20 bl[1]_20 bl[0]_19
+  nbl[0]_19 nbl[1]_19 bl[1]_19 bl[2]_19 nbl[2]_19 nbl[1]_18 bl[1]_18 bl[2]_18
+  nbl[2]_18 bl[0]_17 nbl[1]_17 bl[1]_17 nbl[2]_17 bl[0]_16 nbl[0]_16
+  nbl[1]_16 bl[1]_16 nbl[2]_16 bl[0]_15 nbl[0]_15 nbl[1]_15 bl[1]_15 bl[0]_14
+  nbl[0]_14 nbl[1]_14 bl[1]_14 nbl[2]_14 bl[3]_14 bl[0]_13 nbl[0]_13
+  nbl[1]_13 bl[1]_13 bl[2]_13 nbl[2]_13 bl[3]_13 bl[0]_12 nbl[0]_12 nbl[1]_12
+  bl[1]_12 nbl[2]_12 bl[0]_11 nbl[1]_11 bl[1]_11 vddc bl[0]_10 nbl[0]_10
+  nbl[1]_10 bl[1]_10 bl[0]_9 nbl[0]_9 nbl[1]_9 bl[1]_9 bl[3]_9 bl[0]_8
+  nbl[0]_8 nbl[1]_8 bl[1]_8 nbl[2]_8 bl[3]_8 bl[0]_7 nbl[0]_7 nbl[1]_7
+  bl[1]_7 nbl[2]_7 bl[3]_7 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 nbl[3]_6 bl[3]_6
+  bl[0]_5 nbl[0]_5 nbl[1]_5 bl[1]_5 bl[0]_4 nbl[0]_4 nbl[1]_4 bl[1]_4 bl[0]_3
+  nbl[0]_3 nbl[1]_3 bl[1]_3 bl[3]_3 bl[0]_2 nbl[0]_2 nbl[1]_2 bl[1]_2 bl[3]_2
+  bl[0]_1 bl[1]_1 nbl[3]_1 bl[3]_1 bl[0]_0 bl[1]_0 bl[3]_0 vnwp_0 vnwp_1
+  dbl_0 dwl_0 bl[0]_31 nbl[0]_31 nbl[1]_31 bl[1]_31 nbl[2]_31 nbl[3]_31
+  bl[3]_31 bl[0]_30 nbl[0]_30 nbl[1]_30 bl[1]_30 bl[3]_30 bl[0]_29 nbl[0]_29
+  nbl[1]_29 bl[1]_29 nbl[3]_29 bl[3]_29 bl[0]_28 nbl[0]_28 nbl[1]_28 bl[3]_28
+  bl[0]_27 nbl[0]_27 nbl[1]_27 bl[3]_27 bl[0]_26 nbl[0]_26 nbl[1]_26 bl[2]_26
+  bl[3]_26 bl[0]_25 nbl[0]_25 nbl[1]_25 bl[3]_25 bl[0]_24 nbl[0]_24 nbl[3]_24
+  bl[3]_24 bl[0]_23 nbl[0]_23 nbl[3]_23 bl[3]_23 nbl[0]_22 bl[2]_22 nbl[3]_22
+  bl[3]_22 bl[2]_21 nbl[3]_21 bl[3]_21 bl[2]_20 nbl[2]_20 nbl[3]_20 bl[3]_20
+  nbl[3]_19 bl[3]_19 bl[0]_18 nbl[0]_18 nbl[3]_18 bl[3]_18 nbl[0]_17 bl[2]_17
+  nbl[3]_17 bl[3]_17 bl[2]_16 nbl[3]_16 bl[3]_16 bl[2]_15 nbl[2]_15 nbl[3]_15
+  bl[3]_15 vpw bl[2]_14 nbl[3]_14 nbl[3]_13 bl[2]_12 nbl[3]_12 bl[3]_12
+  nbl[0]_11 bl[2]_11 nbl[2]_11 nbl[3]_11 bl[3]_11 bl[2]_10 nbl[2]_10
+  nbl[3]_10 bl[3]_10 bl[2]_9 nbl[2]_9 nbl[3]_9 vddpe bl[2]_8 nbl[3]_8 bl[2]_7
+  nbl[3]_7 bl[2]_6 nbl[2]_6 bl[2]_5 nbl[2]_5 nbl[3]_5 bl[3]_5 bl[2]_4
+  nbl[2]_4 nbl[3]_4 bl[3]_4 bl[2]_3 nbl[2]_3 nbl[3]_3 bl[2]_2 nbl[2]_2
+  nbl[3]_2 nbl[0]_1 nbl[1]_1 bl[2]_1 nbl[2]_1 nbl[0]_0 nbl[1]_0 bl[2]_0
+  nbl[2]_0 nbl[3]_0 wl[1]_15 wl[0]_15 wl[0]_14 wl[1]_14 wl[1]_13 wl[0]_13
+  wl[0]_12 wl[1]_12 wl[1]_11 wl[0]_11 wl[1]_10 wl[0]_10 wl[0]_9 wl[1]_9
+  wl[1]_8 wl[0]_8 wl[0]_7 wl[1]_7 wl[1]_6 wl[0]_6 wl[0]_5 wl[1]_5 wl[1]_4
+  wl[0]_4 wl[0]_3 wl[1]_3 wl[1]_2 wl[0]_2 wl[0]_1 wl[1]_1 wl[1]_0 wl[0]_0
+  actp vpw rf64x128memcore_l
xmemcore_r vddc nbl[2]_63 bl[2]_63 bl[3]_62 nbl[3]_62 nbl[2]_62 bl[2]_62
+  nbl[3]_61 nbl[2]_61 bl[2]_61 nbl[2]_60 bl[2]_60 bl[1]_60 nbl[3]_59
+  nbl[2]_59 bl[2]_59 bl[1]_59 nbl[3]_58 nbl[2]_58 bl[1]_58 nbl[3]_57
+  nbl[2]_57 bl[1]_57 nbl[1]_57 nbl[3]_56 nbl[2]_56 bl[2]_56 vpw bl[1]_56
+  nbl[1]_56 nbl[2]_55 bl[2]_55 vpw bl[1]_55 nbl[1]_55 bl[0]_55 nbl[2]_54
+  bl[2]_54 bl[1]_54 nbl[1]_54 nbl[0]_54 bl[0]_54 nbl[2]_53 bl[1]_53 nbl[1]_53
+  nbl[0]_53 bl[0]_53 nbl[2]_52 bl[1]_52 nbl[1]_52 nbl[0]_52 bl[0]_52 bl[1]_51
+  nbl[1]_51 nbl[0]_51 bl[0]_51 bl[3]_50 nbl[2]_50 bl[2]_50 bl[1]_50 nbl[1]_50
+  bl[0]_50 nbl[2]_49 bl[2]_49 bl[1]_49 nbl[1]_49 bl[0]_49 nbl[2]_48 bl[1]_48
+  nbl[1]_48 nbl[0]_48 bl[0]_48 nbl[2]_47 bl[1]_47 nbl[1]_47 nbl[0]_47
+  bl[0]_47 bl[1]_46 nbl[1]_46 nbl[0]_46 bl[0]_46 bl[3]_45 nbl[2]_45 bl[2]_45
+  bl[1]_45 nbl[1]_45 nbl[0]_45 bl[0]_45 bl[3]_44 nbl[2]_44 bl[2]_44 bl[1]_44
+  nbl[1]_44 bl[0]_44 nbl[2]_43 vddc bl[1]_43 nbl[1]_43 nbl[0]_43 bl[0]_43
+  bl[1]_42 nbl[1]_42 nbl[0]_42 bl[0]_42 bl[1]_41 nbl[1]_41 nbl[0]_41 bl[0]_41
+  bl[1]_40 nbl[1]_40 nbl[0]_40 bl[0]_40 bl[3]_39 nbl[2]_39 bl[1]_39 nbl[1]_39
+  nbl[0]_39 bl[0]_39 bl[3]_38 nbl[3]_38 nbl[2]_38 bl[1]_38 nbl[1]_38
+  nbl[0]_38 bl[0]_38 bl[3]_37 nbl[3]_37 bl[1]_37 nbl[1]_37 nbl[0]_37 bl[0]_37
+  bl[1]_36 nbl[1]_36 nbl[0]_36 bl[0]_36 bl[1]_35 nbl[1]_35 nbl[0]_35 bl[0]_35
+  bl[3]_34 bl[1]_34 nbl[1]_34 bl[0]_34 bl[3]_33 bl[1]_33 bl[0]_33 bl[3]_32
+  nbl[3]_32 bl[0]_32 vnwp_2 vnwp_3 bl[3]_63 nbl[3]_63 bl[1]_63 nbl[1]_63
+  nbl[0]_63 bl[0]_63 bl[1]_62 nbl[1]_62 nbl[0]_62 bl[0]_62 bl[3]_61 bl[1]_61
+  nbl[1]_61 nbl[0]_61 bl[0]_61 bl[3]_60 nbl[3]_60 nbl[1]_60 nbl[0]_60
+  bl[0]_60 bl[3]_59 nbl[1]_59 nbl[0]_59 bl[0]_59 bl[3]_58 bl[2]_58 nbl[1]_58
+  nbl[0]_58 bl[0]_58 bl[3]_57 bl[2]_57 nbl[0]_57 bl[0]_57 bl[3]_56 nbl[0]_56
+  bl[0]_56 bl[3]_55 nbl[3]_55 nbl[0]_55 bl[3]_54 nbl[3]_54 bl[3]_53 nbl[3]_53
+  bl[2]_53 bl[3]_52 nbl[3]_52 bl[2]_52 bl[3]_51 nbl[3]_51 nbl[2]_51 bl[2]_51
+  nbl[3]_50 nbl[0]_50 bl[3]_49 nbl[3]_49 nbl[0]_49 bl[3]_48 nbl[3]_48
+  bl[2]_48 bl[3]_47 nbl[3]_47 bl[2]_47 bl[3]_46 nbl[3]_46 nbl[2]_46 bl[2]_46
+  nbl[3]_45 nbl[3]_44 nbl[0]_44 bl[3]_43 nbl[3]_43 bl[2]_43 bl[3]_42
+  nbl[3]_42 nbl[2]_42 bl[2]_42 bl[3]_41 nbl[3]_41 nbl[2]_41 bl[2]_41 bl[3]_40
+  nbl[3]_40 nbl[2]_40 bl[2]_40 vddpe nbl[3]_39 bl[2]_39 bl[2]_38 nbl[2]_37
+  bl[2]_37 bl[3]_36 nbl[3]_36 nbl[2]_36 bl[2]_36 bl[3]_35 nbl[3]_35 nbl[2]_35
+  bl[2]_35 nbl[3]_34 nbl[2]_34 bl[2]_34 nbl[0]_34 nbl[3]_33 nbl[2]_33
+  bl[2]_33 nbl[1]_33 nbl[0]_33 nbl[2]_32 bl[2]_32 bl[1]_32 nbl[1]_32
+  nbl[0]_32 wl[1]_15_32 wl[0]_15_34 wl[1]_14_36 wl[0]_14_38 wl[1]_13_40
+  wl[0]_13_42 wl[1]_12_44 wl[0]_12_46 wl[1]_11_48 wl[0]_11_50 wl[1]_10_52
+  wl[0]_10_54 wl[1]_9_56 wl[0]_9_58 wl[1]_8_60 wl[0]_8_62 wl[1]_7_64
+  wl[0]_7_66 wl[1]_6_68 wl[0]_6_70 wl[1]_5_72 wl[0]_5_74 wl[1]_4_76
+  wl[0]_4_78 wl[1]_3_80 wl[0]_3_82 wl[1]_2_84 wl[0]_2_86 wl[1]_1_88
+  wl[0]_1_90 wl[1]_0_92 wl[0]_0_94 actp vpw rf64x128memcore_r
xwddrvcol ret niactc vpw vddc_wl dbl_nbl_wa nact_cc niretnvt actp vddc
+  vddp_nor vddpe log1 log0 log0_sa dbl_1 dwl_1 gtpclk1 gtpclk0 nla_p2[1]
+  nla_p2[0] la_p2[1] la_p2[0] nra_p2[5] nra_p2[4] nra_p2[3] nra_p2[2]
+  nra_p2[1] nra_p2[0] ra_p2[5] ra_p2[4] ra_p2[3] ra_p2[2] ra_p2[1] ra_p2[0]
+  rawlm1 rawlm0 rawl cen_p2 nret ret1n ema[0] ema[1] ema[2] vddc vpw
+  wl[1]_15_32 wl[0]_15_34 wl[1]_14_36 wl[0]_14_38 wl[1]_13_40 wl[0]_13_42
+  wl[1]_12_44 wl[0]_12_46 wl[1]_11_48 vpw wl[0]_11_50 wl[1]_10_52 wl[0]_10_54
+  wl[1]_9_56 wl[0]_9_58 wl[1]_8_60 wl[0]_8_62 wl[1]_7_64 wl[0]_7_66
+  wl[1]_6_68 wl[0]_6_70 wl[1]_5_72 wl[0]_5_74 wl[1]_4_76 wl[0]_4_78
+  wl[1]_3_80 wl[0]_3_82 wl[1]_2_84 wl[0]_2_86 wl[1]_1_88 wl[0]_1_90
+  wl[1]_0_92 wl[0]_0_94 vpw vddc vddc vpw wl[1]_15 wl[0]_15 wl[0]_14 wl[1]_14
+  wl[1]_13 wl[0]_13 wl[0]_12 wl[1]_12 wl[1]_11 wl[0]_11 wl[1]_10 wl[0]_10
+  wl[0]_9 wl[1]_9 wl[1]_8 wl[0]_8 wl[0]_7 wl[1]_7 wl[1]_6 wl[0]_6 wl[0]_5
+  wl[1]_5 wl[1]_4 wl[0]_4 wl[0]_3 wl[1]_3 wl[1]_2 wl[0]_2 wl[0]_1 wl[1]_1
+  wl[1]_0 vpw wl[0]_0 vpw vddc rf64x128wddrvcol
.ends rf64x128mem_slice
****
.subckt rf64x128TILE_TOP vddpe q1_63 d1_63 wen1_63 weny1_63 weny0_63 wen0_63
+  d0_63 q0_63 q1_62 d1_62 wen1_62 weny1_62 weny0_62 wen0_62 d0_62 q0_62 q1_61
+  d1_61 wen1_61 weny1_61 weny0_61 wen0_61 d0_61 q0_61 q1_60 d1_60 wen1_60
+  weny1_60 weny0_60 wen0_60 d0_60 q0_60 q1_59 d1_59 wen1_59 weny1_59 weny0_59
+  wen0_59 d0_59 q0_59 q1_58 d1_58 wen1_58 weny1_58 weny0_58 wen0_58 d0_58
+  q0_58 q1_57 d1_57 wen1_57 weny1_57 weny0_57 wen0_57 d0_57 q0_57 q1_56 d1_56
+  wen1_56 weny1_56 weny0_56 wen0_56 d0_56 q0_56 q1_55 d1_55 wen1_55 weny1_55
+  weny0_55 wen0_55 d0_55 q0_55 q1_54 d1_54 wen1_54 weny1_54 weny0_54 wen0_54
+  d0_54 q0_54 q1_53 d1_53 wen1_53 weny1_53 weny0_53 wen0_53 d0_53 q0_53 q1_52
+  d1_52 wen1_52 weny1_52 weny0_52 wen0_52 d0_52 q0_52 q1_51 d1_51 wen1_51
+  weny1_51 weny0_51 wen0_51 d0_51 q0_51 q1_50 d1_50 wen1_50 weny1_50 weny0_50
+  wen0_50 d0_50 q0_50 q1_49 d1_49 wen1_49 weny1_49 weny0_49 wen0_49 d0_49
+  q0_49 q1_48 d1_48 wen1_48 weny1_48 weny0_48 wen0_48 d0_48 q0_48 q1_47 d1_47
+  wen1_47 weny1_47 weny0_47 wen0_47 d0_47 q0_47 q1_46 d1_46 wen1_46 weny1_46
+  weny0_46 wen0_46 d0_46 q0_46 q1_45 d1_45 wen1_45 weny1_45 weny0_45 wen0_45
+  d0_45 q0_45 q1_44 d1_44 wen1_44 weny1_44 weny0_44 wen0_44 d0_44 q0_44 q1_43
+  d1_43 wen1_43 weny1_43 weny0_43 wen0_43 d0_43 q0_43 q1_42 d1_42 wen1_42
+  weny1_42 weny0_42 wen0_42 d0_42 q0_42 q1_41 d1_41 wen1_41 weny1_41 weny0_41
+  wen0_41 d0_41 q0_41 q1_40 d1_40 wen1_40 weny1_40 weny0_40 wen0_40 d0_40
+  q0_40 q1_39 d1_39 wen1_39 weny1_39 weny0_39 wen0_39 d0_39 q0_39 q1_38 d1_38
+  wen1_38 weny1_38 weny0_38 wen0_38 d0_38 q0_38 q1_37 d1_37 wen1_37 weny1_37
+  weny0_37 wen0_37 d0_37 q0_37 q1_36 d1_36 wen1_36 weny1_36 weny0_36 wen0_36
+  d0_36 q0_36 q1_35 d1_35 wen1_35 weny1_35 weny0_35 wen0_35 d0_35 q0_35 q1_34
+  d1_34 wen1_34 weny1_34 weny0_34 wen0_34 d0_34 q0_34 q1_33 d1_33 wen1_33
+  weny1_33 weny0_33 wen0_33 d0_33 q0_33 q1_32 d1_32 wen1_32 weny1_32 weny0_32
+  wen0_32 d0_32 q0_32 penso pso1 pso0 wablm1 wablm0 wabl rawlm1 rawlm0 rawl
+  emas ema0 ema1 ema2 emaw0 emaw1 ret1n gwen cen clk a0 a3 a4 a5 a6 a7 a1
+  q0_31 d0_31 wen0_31 weny0_31 weny1_31 wen1_31 d1_31 q1_31 q0_30 d0_30
+  wen0_30 weny0_30 weny1_30 wen1_30 d1_30 q1_30 q0_29 d0_29 wen0_29 weny0_29
+  weny1_29 wen1_29 d1_29 q1_29 q0_28 d0_28 wen0_28 weny0_28 weny1_28 wen1_28
+  d1_28 q1_28 q0_27 d0_27 wen0_27 weny0_27 weny1_27 wen1_27 d1_27 q1_27 q0_26
+  d0_26 wen0_26 weny0_26 weny1_26 wen1_26 d1_26 q1_26 q0_25 d0_25 wen0_25
+  weny0_25 weny1_25 wen1_25 d1_25 q1_25 q0_24 d0_24 wen0_24 weny0_24 weny1_24
+  wen1_24 d1_24 q1_24 q0_23 d0_23 wen0_23 weny0_23 weny1_23 wen1_23 d1_23
+  q1_23 q0_22 d0_22 wen0_22 weny0_22 weny1_22 wen1_22 d1_22 q1_22 q0_21 d0_21
+  wen0_21 weny0_21 weny1_21 wen1_21 d1_21 q1_21 q0_20 d0_20 wen0_20 weny0_20
+  weny1_20 wen1_20 d1_20 q1_20 q0_19 d0_19 wen0_19 weny0_19 weny1_19 wen1_19
+  d1_19 q1_19 q0_18 d0_18 wen0_18 weny0_18 weny1_18 wen1_18 d1_18 q1_18 q0_17
+  d0_17 wen0_17 weny0_17 weny1_17 wen1_17 d1_17 q1_17 q0_16 d0_16 wen0_16
+  weny0_16 weny1_16 wen1_16 d1_16 q1_16 q0_15 d0_15 wen0_15 weny0_15 weny1_15
+  wen1_15 d1_15 q1_15 q0_14 d0_14 wen0_14 weny0_14 weny1_14 wen1_14 d1_14
+  q1_14 q0_13 d0_13 wen0_13 weny0_13 weny1_13 wen1_13 d1_13 q1_13 q0_12 d0_12
+  wen0_12 weny0_12 weny1_12 wen1_12 d1_12 q1_12 q0_11 d0_11 wen0_11 weny0_11
+  weny1_11 wen1_11 d1_11 q1_11 q0_10 d0_10 wen0_10 weny0_10 weny1_10 wen1_10
+  d1_10 q1_10 q0_9 d0_9 wen0_9 weny0_9 weny1_9 wen1_9 d1_9 q1_9 q0_8 d0_8
+  wen0_8 weny0_8 weny1_8 wen1_8 d1_8 q1_8 q0_7 d0_7 wen0_7 weny0_7 weny1_7
+  wen1_7 d1_7 q1_7 q0_6 d0_6 wen0_6 weny0_6 weny1_6 wen1_6 d1_6 vpw q1_6 q0_5
+  d0_5 wen0_5 weny0_5 weny1_5 wen1_5 d1_5 q1_5 q0_4 d0_4 wen0_4 weny0_4
+  weny1_4 wen1_4 d1_4 q1_4 q0_3 d0_3 wen0_3 weny0_3 weny1_3 wen1_3 d1_3 q1_3
+  q0_2 d0_2 wen0_2 weny0_2 weny1_2 wen1_2 d1_2 q1_2 q0_1 d0_1 wen0_1 weny0_1
+  weny1_1 wen1_1 d1_1 q1_1 q0_0 vddce d0_0 wen0_0 weny0_0 weny1_0 wen1_0 d1_0
+  q1_0
** rf64x128TILE_TOP: 69681 flat devices **
xbotcap vpw vpw vpw q1_63 vddce vddpe weny1_63 wen1_62 vpw d0_62 vddce vddpe
+  d1_61 wen1_61 vpw d0_61 vddce vddpe d1_60 wen1_60 vpw d0_60 vddce vddpe
+  d1_59 wen1_59 vpw weny0_59 vpw wen0_59 d0_59 vddpe vddpe q0_59 vddce
+  wen1_58 vpw weny1_58 weny0_58 vpw wen0_58 vpw d0_58 vddpe q0_58 vddce
+  wen1_57 vpw weny1_57 weny0_57 vpw wen0_57 vpw d0_57 vddpe q0_57 vddce vddpe
+  wen1_56 vpw weny1_56 weny0_56 vpw wen0_56 vpw d0_56 vddpe wen1_55 vpw
+  weny0_55 wen0_55 vpw d0_55 q1_54 vddpe wen1_54 vpw weny0_54 wen0_54 d0_54
+  q1_53 weny1_53 weny0_53 vpw wen0_53 vpw q0_53 q1_52 weny1_52 weny0_52 vpw
+  wen0_52 vpw q1_51 vpw weny0_51 wen0_51 d0_51 q0_51 q1_50 vpw weny0_50
+  wen0_50 d0_50 q0_50 q1_49 vpw weny0_49 wen0_49 q0_49 q1_48 vpw weny0_48
+  wen0_48 d1_47 vpw vpw wen0_47 vpw d0_47 d1_46 vpw vpw wen0_46 vpw d0_46
+  d1_45 vpw vpw vpw wen0_45 vpw d0_45 d1_44 vpw vpw vpw wen0_44 d0_44 vddpe
+  vddce vddpe d1_43 vpw wen1_43 vpw weny0_43 vddce vddpe d1_42 vpw wen1_42
+  vpw weny0_42 vpw wen0_42 d0_42 vddce vddpe d1_41 wen1_41 vpw weny0_41 vpw
+  wen0_41 d0_41 vddce vddpe d1_40 wen1_40 vpw weny0_40 vpw wen0_40 d0_40
+  q1_39 vddce vddpe wen1_39 vpw weny0_39 vpw q1_38 vddpe wen1_38 vpw weny0_38
+  vpw q1_37 vddpe wen1_37 vpw weny0_37 vpw vpw q1_36 weny0_36 vpw wen0_36
+  d0_36 q0_36 q1_35 vpw weny0_35 d0_35 q0_35 q1_34 vpw weny0_34 d0_34 q0_34
+  q1_33 vpw weny0_33 vpw d0_33 q0_33 q1_32 vpw weny0_32 vpw d0_32 q0_32 vpw
+  vpw vpw vpw vpw vpw vpw vpw vpw vddce vddce vddpe vpw pso1 pso0 vpw vpw
+  log1 a1 ret1n gwen clk a6 a7 vpw vpw vpw vpw vpw vpw vpw vpw vpw vpw vpw
+  vpw vpw vpw vpw vpw weny1_31 vpw wen1_31 vpw d1_31 vddpe vddce q1_31
+  weny0_30 vpw wen1_30 vpw d1_30 vddpe vddce weny0_29 vpw wen1_29 vpw d1_29
+  vddpe vddce weny0_28 vpw wen1_28 vpw d1_28 vddpe vddce d0_27 vpw wen0_27
+  vpw vpw wen1_27 d1_27 vddpe vddce d0_26 vpw wen0_26 vpw vpw wen1_26 d1_26
+  vddpe vddce q0_25 d0_25 vpw wen0_25 vpw vpw wen1_25 vddpe vddce q0_24 d0_24
+  vpw wen0_24 vpw vpw wen1_24 vddpe q1_24 q0_23 d0_23 vpw wen0_23 vpw
+  weny0_23 vpw wen1_23 vddpe q1_23 q0_22 d0_22 vpw wen0_22 vpw weny0_22 vpw
+  wen1_22 vddpe q1_22 q0_21 d0_21 vpw wen0_21 vpw weny0_21 vpw wen1_21 vddpe
+  q1_21 q0_20 d0_20 vpw wen0_20 vpw weny0_20 weny1_20 vpw wen1_20 vddpe q1_20
+  q0_19 d0_19 wen0_19 vpw weny0_19 weny1_19 vpw d1_19 q1_19 q0_18 wen0_18 vpw
+  weny0_18 weny1_18 vpw d1_18 q1_18 q0_17 wen0_17 vpw weny0_17 weny1_17 vpw
+  d1_17 q1_17 q0_16 wen0_16 vpw weny0_16 weny1_16 vpw d1_16 q1_16 q0_15 vddpe
+  vpw wen0_15 vpw weny0_15 weny1_15 vpw wen1_15 vpw d1_15 vddce q1_15 q0_14
+  vddpe vpw wen0_14 vpw weny0_14 weny1_14 vpw wen1_14 vpw d1_14 vddce q1_14
+  vddpe d0_13 vpw weny1_13 vpw wen1_13 vpw d1_13 vddce q1_13 vddpe d0_12 vpw
+  weny1_12 vpw wen1_12 vpw d1_12 vddce q1_12 q0_11 d0_11 vpw wen0_11 vpw
+  weny1_11 vpw wen1_11 vpw d1_11 vddpe vddce q1_11 q0_10 d0_10 vpw wen0_10
+  vpw weny0_10 weny1_10 vpw wen1_10 vpw d1_10 vddpe vddce q1_10 q0_9 d0_9 vpw
+  wen0_9 vpw weny0_9 weny1_9 vpw wen1_9 vpw d1_9 vddpe vddce q1_9 q0_8 d0_8
+  vpw wen0_8 vpw weny0_8 vpw wen1_8 d1_8 vddpe vddce q1_8 q0_7 d0_7 vpw
+  wen0_7 vpw weny0_7 weny1_7 vpw wen1_7 d1_7 vddpe vddce q1_7 q0_6 d0_6 vpw
+  wen0_6 vpw weny0_6 weny1_6 vpw wen1_6 vpw d1_6 vddpe vddce q1_6 q0_5 d0_5
+  vpw wen0_5 vpw weny0_5 weny1_5 vpw wen1_5 vpw d1_5 vddpe vddce q1_5 q0_4
+  d0_4 vpw wen0_4 vpw weny0_4 weny1_4 vpw wen1_4 vpw d1_4 vddpe vddce d1_3
+  q1_3 q0_2 d0_2 vpw wen0_2 vpw weny0_2 weny1_2 vpw wen1_2 vpw d1_2 vddpe
+  q1_2 q0_1 vddce d0_1 vpw wen0_1 vpw weny0_1 weny1_1 vpw wen1_1 vpw d1_1
+  vddpe q1_1 q0_0 vddce weny1_0 vddpe vddce d1_63 vpw wen1_63 vpw weny0_63
+  vpw wen0_63 vpw d0_63 q0_63 q1_62 d1_62 vpw weny1_62 weny0_62 vpw wen0_62
+  vpw q0_62 q1_61 vpw weny1_61 weny0_61 vpw wen0_61 vpw q0_61 q1_60 vpw
+  weny1_60 weny0_60 vpw wen0_60 vpw q0_60 q1_59 vpw weny1_59 vpw vddce q1_58
+  d1_58 vpw q1_57 d1_57 vpw q1_56 d1_56 vpw q0_56 q1_55 vddce d1_55 vpw
+  weny1_55 vpw q0_55 vddce d1_54 vpw weny1_54 vpw vpw q0_54 vddce d1_53 vpw
+  wen1_53 vpw d0_53 vddpe vddce vddpe d1_52 vpw wen1_52 vpw d0_52 q0_52 vddce
+  vddpe d1_51 wen1_51 vpw weny1_51 vpw vpw vddce vddpe d1_50 wen1_50 vpw
+  weny1_50 vpw vpw vddce vddpe d1_49 wen1_49 vpw weny1_49 vpw vpw d0_49 vddce
+  vddpe d1_48 wen1_48 vpw weny1_48 vpw vpw d0_48 q0_48 q1_47 vddce vddpe
+  wen1_47 vpw weny1_47 weny0_47 q0_47 q1_46 vddce vddpe wen1_46 vpw weny1_46
+  weny0_46 q0_46 q1_45 vddce vddpe wen1_45 weny1_45 weny0_45 q0_45 q1_44
+  vddce wen1_44 weny1_44 weny0_44 vpw q0_44 q1_43 weny1_43 vpw wen0_43 vpw
+  d0_43 q0_43 q1_42 weny1_42 vpw q0_42 q1_41 vpw weny1_41 vpw q0_41 q1_40 vpw
+  weny1_40 vpw q0_40 d1_39 vpw weny1_39 vpw wen0_39 d0_39 q0_39 d1_38 vpw
+  weny1_38 vpw wen0_38 d0_38 vddce q0_38 d1_37 vpw weny1_37 vpw wen0_37 d0_37
+  vddce q0_37 vddce d1_36 vpw wen1_36 vpw weny1_36 vpw vddpe vddce d1_35
+  wen1_35 vpw weny1_35 vpw wen0_35 vpw vddpe vpw vddce d1_34 wen1_34 vpw
+  weny1_34 vpw wen0_34 vpw vddpe vddce d1_33 wen1_33 vpw weny1_33 wen0_33 vpw
+  vddpe vddce vddpe d1_32 wen1_32 vpw weny1_32 wen0_32 vpw vpw vpw vpw vpw
+  vpw vpw vpw vpw vpw penso vpw vpw vpw wablm1 wablm0 wabl rawlm1 rawlm0 rawl
+  vpw emas ema0 ema1 ema2 emaw0 emaw1 vpw vpw cen a0 a3 a4 a5 a1 vpw vpw vpw
+  vpw vpw vpw vpw vpw vpw vpw q0_31 d0_31 vpw wen0_31 vpw weny0_31 q0_30
+  d0_30 vpw wen0_30 vpw weny1_30 q1_30 q0_29 d0_29 vpw wen0_29 vpw weny1_29
+  q1_29 q0_28 d0_28 vpw wen0_28 vpw weny1_28 q1_28 q0_27 weny0_27 weny1_27
+  vpw q1_27 q0_26 weny0_26 weny1_26 vpw q1_26 weny0_25 weny1_25 vpw d1_25
+  q1_25 vddce weny0_24 weny1_24 vpw d1_24 vddce weny1_23 vpw d1_23 vddce
+  weny1_22 vpw d1_22 vddce weny1_21 vpw d1_21 vpw d1_20 vddce vddce vpw vpw
+  wen1_19 vddpe d0_18 vpw vpw wen1_18 vddpe vddce d0_17 vpw vpw wen1_17 vddpe
+  vddce d0_16 vpw vpw wen1_16 vddpe vddce d0_15 d0_14 q0_13 wen0_13 vpw
+  weny0_13 q0_12 wen0_12 vpw weny0_12 weny0_11 weny1_8 vpw vpw q1_4 q0_3
+  vddce d0_3 vpw wen0_3 vpw weny0_3 weny1_3 vpw wen1_3 vpw vddpe vddce d0_0
+  vpw wen0_0 vpw weny0_0 vpw wen1_0 vpw d1_0 q1_0 vpw vpw vddce vpw
+  rf64x128botcaprow
xio_slice bl_term[3]_63 nbl_term[3]_63 nbl_term[2]_63 bl_term[2]_63 vddce
+  bl_term[1]_63 nbl_term[1]_63 nbl_term[0]_63 bl_term[0]_63 bl_term[3]_62
+  nbl_term[3]_62 nbl_term[2]_62 bl_term[2]_62 vddce bl_term[1]_62
+  nbl_term[1]_62 nbl_term[0]_62 bl_term[0]_62 bl_term[3]_61 nbl_term[3]_61
+  nbl_term[2]_61 bl_term[2]_61 vddce bl_term[1]_61 nbl_term[1]_61
+  nbl_term[0]_61 bl_term[0]_61 bl_term[3]_60 nbl_term[3]_60 nbl_term[2]_60
+  bl_term[2]_60 vddce bl_term[1]_60 nbl_term[1]_60 nbl_term[0]_60
+  bl_term[0]_60 bl_term[3]_59 nbl_term[3]_59 nbl_term[2]_59 bl_term[2]_59
+  vddce bl_term[1]_59 nbl_term[1]_59 nbl_term[0]_59 bl_term[0]_59
+  bl_term[3]_58 nbl_term[3]_58 nbl_term[2]_58 bl_term[2]_58 vddce
+  bl_term[1]_58 nbl_term[1]_58 nbl_term[0]_58 bl_term[0]_58 bl_term[3]_57
+  nbl_term[3]_57 nbl_term[2]_57 bl_term[2]_57 vddce bl_term[1]_57
+  nbl_term[1]_57 nbl_term[0]_57 bl_term[0]_57 bl_term[3]_56 nbl_term[3]_56
+  nbl_term[2]_56 bl_term[2]_56 vddce bl_term[1]_56 nbl_term[1]_56
+  nbl_term[0]_56 bl_term[0]_56 bl_term[3]_55 nbl_term[3]_55 nbl_term[2]_55
+  bl_term[2]_55 vddce bl_term[1]_55 nbl_term[1]_55 nbl_term[0]_55
+  bl_term[0]_55 bl_term[3]_54 nbl_term[3]_54 nbl_term[2]_54 bl_term[2]_54
+  vddce bl_term[1]_54 nbl_term[1]_54 nbl_term[0]_54 bl_term[0]_54
+  bl_term[3]_53 nbl_term[3]_53 nbl_term[2]_53 bl_term[2]_53 vddce
+  bl_term[1]_53 nbl_term[1]_53 nbl_term[0]_53 bl_term[0]_53 bl_term[3]_52
+  nbl_term[3]_52 nbl_term[2]_52 bl_term[2]_52 vddce bl_term[1]_52
+  nbl_term[1]_52 nbl_term[0]_52 bl_term[0]_52 bl_term[3]_51 nbl_term[3]_51
+  nbl_term[2]_51 bl_term[2]_51 vddce bl_term[1]_51 nbl_term[1]_51
+  nbl_term[0]_51 bl_term[0]_51 bl_term[3]_50 nbl_term[3]_50 nbl_term[2]_50
+  bl_term[2]_50 vddce bl_term[1]_50 nbl_term[1]_50 nbl_term[0]_50
+  bl_term[0]_50 bl_term[3]_49 nbl_term[3]_49 nbl_term[2]_49 bl_term[2]_49
+  vddce bl_term[1]_49 nbl_term[1]_49 nbl_term[0]_49 bl_term[0]_49
+  bl_term[3]_48 nbl_term[3]_48 nbl_term[2]_48 bl_term[2]_48 vddce
+  bl_term[1]_48 nbl_term[1]_48 nbl_term[0]_48 bl_term[0]_48 bl_term[3]_47
+  nbl_term[3]_47 nbl_term[2]_47 bl_term[2]_47 vddce bl_term[1]_47
+  nbl_term[1]_47 nbl_term[0]_47 bl_term[0]_47 bl_term[3]_46 nbl_term[3]_46
+  nbl_term[2]_46 bl_term[2]_46 vddce bl_term[1]_46 nbl_term[1]_46
+  nbl_term[0]_46 bl_term[0]_46 bl_term[3]_45 nbl_term[3]_45 nbl_term[2]_45
+  bl_term[2]_45 vddce bl_term[1]_45 nbl_term[1]_45 nbl_term[0]_45
+  bl_term[0]_45 bl_term[3]_44 nbl_term[3]_44 nbl_term[2]_44 bl_term[2]_44
+  vddce bl_term[1]_44 nbl_term[1]_44 nbl_term[0]_44 bl_term[0]_44
+  bl_term[3]_43 nbl_term[3]_43 nbl_term[2]_43 bl_term[2]_43 vddce
+  bl_term[1]_43 nbl_term[1]_43 nbl_term[0]_43 bl_term[0]_43 bl_term[3]_42
+  nbl_term[3]_42 nbl_term[2]_42 bl_term[2]_42 vddce bl_term[1]_42
+  nbl_term[1]_42 nbl_term[0]_42 bl_term[0]_42 bl_term[3]_41 nbl_term[3]_41
+  nbl_term[2]_41 bl_term[2]_41 vddce bl_term[1]_41 nbl_term[1]_41
+  nbl_term[0]_41 bl_term[0]_41 bl_term[3]_40 nbl_term[3]_40 nbl_term[2]_40
+  bl_term[2]_40 vddce bl_term[1]_40 nbl_term[1]_40 nbl_term[0]_40
+  bl_term[0]_40 bl_term[3]_39 nbl_term[3]_39 nbl_term[2]_39 bl_term[2]_39
+  vddce bl_term[1]_39 nbl_term[1]_39 nbl_term[0]_39 bl_term[0]_39
+  bl_term[3]_38 nbl_term[3]_38 nbl_term[2]_38 bl_term[2]_38 vddce
+  bl_term[1]_38 nbl_term[1]_38 nbl_term[0]_38 bl_term[0]_38 bl_term[3]_37
+  nbl_term[3]_37 nbl_term[2]_37 bl_term[2]_37 vddce vddce bl_term[1]_37
+  nbl_term[1]_37 nbl_term[0]_37 bl_term[0]_37 bl_term[3]_36 nbl_term[3]_36
+  nbl_term[2]_36 bl_term[2]_36 vddce bl_term[1]_36 nbl_term[1]_36
+  nbl_term[0]_36 bl_term[0]_36 bl_term[3]_35 nbl_term[3]_35 nbl_term[2]_35
+  bl_term[2]_35 vddce bl_term[1]_35 nbl_term[1]_35 nbl_term[0]_35
+  bl_term[0]_35 bl_term[3]_34 nbl_term[3]_34 nbl_term[2]_34 bl_term[2]_34
+  vddce bl_term[1]_34 nbl_term[1]_34 nbl_term[0]_34 bl_term[0]_34
+  bl_term[3]_33 nbl_term[3]_33 nbl_term[2]_33 bl_term[2]_33 vddce
+  bl_term[1]_33 nbl_term[1]_33 nbl_term[0]_33 bl_term[0]_33 bl_term[3]_32
+  nbl_term[3]_32 nbl_term[2]_32 bl_term[2]_32 vpw vddce bl_term[1]_32
+  nbl_term[1]_32 nbl_term[0]_32 bl_term[0]_32 dbl_nbl_wa_turn dbl_nbl_wa_turn
+  nact_cc a1 a1 a1 vddp_nor log0_sa dwl gtp nla_p2[1] nla_p2[0] la_p2[1]
+  la_p2[0] nra_p2[5] nra_p2[4] nra_p2[3] nra_p2[2] nra_p2[1] nra_p2[0]
+  ra_p2[5] ra_p2[4] ra_p2[3] ra_p2[2] ra_p2[1] ra_p2[0] cen_p2 nret ret1n
+  ema0 ema1 ema2 vddce dbl bl_term[0]_31 nbl_term[0]_31 nbl_term[1]_31
+  bl_term[1]_31 vddce bl_term[2]_31 nbl_term[2]_31 nbl_term[3]_31
+  bl_term[3]_31 bl_term[0]_30 nbl_term[0]_30 nbl_term[1]_30 bl_term[1]_30
+  vddce bl_term[2]_30 nbl_term[2]_30 nbl_term[3]_30 bl_term[3]_30
+  bl_term[0]_29 nbl_term[0]_29 nbl_term[1]_29 bl_term[1]_29 vddce
+  bl_term[2]_29 nbl_term[2]_29 nbl_term[3]_29 bl_term[3]_29 bl_term[0]_28
+  nbl_term[0]_28 nbl_term[1]_28 bl_term[1]_28 vddce bl_term[2]_28
+  nbl_term[2]_28 nbl_term[3]_28 bl_term[3]_28 bl_term[0]_27 nbl_term[0]_27
+  nbl_term[1]_27 bl_term[1]_27 vddce bl_term[2]_27 nbl_term[2]_27
+  nbl_term[3]_27 bl_term[3]_27 bl_term[0]_26 nbl_term[0]_26 nbl_term[1]_26
+  bl_term[1]_26 vddce bl_term[2]_26 nbl_term[2]_26 nbl_term[3]_26
+  bl_term[3]_26 bl_term[0]_25 nbl_term[0]_25 nbl_term[1]_25 bl_term[1]_25
+  vddce bl_term[2]_25 nbl_term[2]_25 nbl_term[3]_25 bl_term[3]_25
+  bl_term[0]_24 nbl_term[0]_24 nbl_term[1]_24 bl_term[1]_24 vddce
+  bl_term[2]_24 nbl_term[2]_24 nbl_term[3]_24 bl_term[3]_24 bl_term[0]_23
+  nbl_term[0]_23 nbl_term[1]_23 bl_term[1]_23 vddce bl_term[2]_23
+  nbl_term[2]_23 nbl_term[3]_23 bl_term[3]_23 bl_term[0]_22 nbl_term[0]_22
+  nbl_term[1]_22 bl_term[1]_22 vddce bl_term[2]_22 nbl_term[2]_22
+  nbl_term[3]_22 bl_term[3]_22 bl_term[0]_21 nbl_term[0]_21 nbl_term[1]_21
+  bl_term[1]_21 vddce bl_term[2]_21 nbl_term[2]_21 nbl_term[3]_21
+  bl_term[3]_21 bl_term[0]_20 nbl_term[0]_20 nbl_term[1]_20 bl_term[1]_20
+  vddce bl_term[2]_20 nbl_term[2]_20 nbl_term[3]_20 bl_term[3]_20
+  bl_term[0]_19 nbl_term[0]_19 nbl_term[1]_19 bl_term[1]_19 vddce
+  bl_term[2]_19 nbl_term[2]_19 nbl_term[3]_19 bl_term[3]_19 bl_term[0]_18
+  nbl_term[0]_18 nbl_term[1]_18 bl_term[1]_18 vddce bl_term[2]_18
+  nbl_term[2]_18 nbl_term[3]_18 bl_term[3]_18 bl_term[0]_17 nbl_term[0]_17
+  nbl_term[1]_17 bl_term[1]_17 vddce bl_term[2]_17 nbl_term[2]_17
+  nbl_term[3]_17 bl_term[3]_17 bl_term[0]_16 nbl_term[0]_16 nbl_term[1]_16
+  bl_term[1]_16 vddce bl_term[2]_16 nbl_term[2]_16 nbl_term[3]_16
+  bl_term[3]_16 bl_term[0]_15 nbl_term[0]_15 nbl_term[1]_15 bl_term[1]_15
+  vddce bl_term[2]_15 nbl_term[2]_15 nbl_term[3]_15 bl_term[3]_15
+  bl_term[0]_14 nbl_term[0]_14 nbl_term[1]_14 bl_term[1]_14 vddce
+  bl_term[2]_14 nbl_term[2]_14 nbl_term[3]_14 bl_term[3]_14 bl_term[0]_13
+  nbl_term[0]_13 nbl_term[1]_13 bl_term[1]_13 vddce bl_term[2]_13
+  nbl_term[2]_13 nbl_term[3]_13 bl_term[3]_13 bl_term[0]_12 nbl_term[0]_12
+  nbl_term[1]_12 bl_term[1]_12 vddce bl_term[2]_12 nbl_term[2]_12
+  nbl_term[3]_12 bl_term[3]_12 bl_term[0]_11 nbl_term[0]_11 nbl_term[1]_11
+  bl_term[1]_11 vddce bl_term[2]_11 nbl_term[2]_11 nbl_term[3]_11
+  bl_term[3]_11 bl_term[0]_10 nbl_term[0]_10 nbl_term[1]_10 bl_term[1]_10
+  vddce bl_term[2]_10 nbl_term[2]_10 nbl_term[3]_10 bl_term[3]_10
+  bl_term[0]_9 nbl_term[0]_9 nbl_term[1]_9 bl_term[1]_9 vddce bl_term[2]_9
+  nbl_term[2]_9 nbl_term[3]_9 bl_term[3]_9 bl_term[0]_8 nbl_term[0]_8
+  nbl_term[1]_8 bl_term[1]_8 vddce bl_term[2]_8 nbl_term[2]_8 nbl_term[3]_8
+  bl_term[3]_8 bl_term[0]_7 nbl_term[0]_7 nbl_term[1]_7 bl_term[1]_7 vddce
+  bl_term[2]_7 nbl_term[2]_7 nbl_term[3]_7 bl_term[3]_7 bl_term[0]_6
+  nbl_term[0]_6 nbl_term[1]_6 bl_term[1]_6 vddce bl_term[2]_6 nbl_term[2]_6
+  nbl_term[3]_6 bl_term[3]_6 bl_term[0]_5 nbl_term[0]_5 nbl_term[1]_5
+  bl_term[1]_5 vddce bl_term[2]_5 nbl_term[2]_5 nbl_term[3]_5 bl_term[3]_5
+  bl_term[0]_4 nbl_term[0]_4 nbl_term[1]_4 bl_term[1]_4 vddce bl_term[2]_4
+  nbl_term[2]_4 nbl_term[3]_4 bl_term[3]_4 bl_term[0]_3 nbl_term[0]_3
+  nbl_term[1]_3 bl_term[1]_3 vddce bl_term[2]_3 nbl_term[2]_3 nbl_term[3]_3
+  bl_term[3]_3 bl_term[0]_2 nbl_term[0]_2 nbl_term[1]_2 bl_term[1]_2 vddce
+  bl_term[2]_2 nbl_term[2]_2 nbl_term[3]_2 bl_term[3]_2 bl_term[0]_1
+  nbl_term[0]_1 nbl_term[1]_1 bl_term[1]_1 vddce bl_term[2]_1 nbl_term[2]_1
+  nbl_term[3]_1 bl_term[3]_1 bl_term[0]_0 nbl_term[0]_0 nbl_term[1]_0
+  bl_term[1]_0 vddce bl_term[2]_0 nbl_term[2]_0 nbl_term[3]_0 bl_term[3]_0
+  q1_63 d1_63 wen1_63 weny1_63 weny0_63 wen0_63 d0_63 q0_63 q1_62 d1_62
+  wen1_62 weny1_62 weny0_62 wen0_62 d0_62 q0_62 q1_61 d1_61 wen1_61 weny1_61
+  weny0_61 wen0_61 d0_61 q0_61 q1_60 d1_60 wen1_60 weny1_60 weny0_60 wen0_60
+  d0_60 q0_60 q1_59 d1_59 wen1_59 weny1_59 weny0_59 wen0_59 d0_59 q0_59 q1_58
+  d1_58 wen1_58 weny1_58 weny0_58 wen0_58 d0_58 q0_58 q1_57 d1_57 wen1_57
+  weny1_57 weny0_57 wen0_57 d0_57 q0_57 q1_56 d1_56 wen1_56 weny1_56 weny0_56
+  wen0_56 d0_56 q0_56 q1_55 d1_55 wen1_55 weny1_55 weny0_55 wen0_55 d0_55
+  q0_55 q1_54 d1_54 wen1_54 weny1_54 weny0_54 wen0_54 d0_54 q0_54 q1_53 d1_53
+  wen1_53 weny1_53 weny0_53 wen0_53 d0_53 q0_53 q1_52 d1_52 wen1_52 weny1_52
+  weny0_52 wen0_52 d0_52 q0_52 q1_51 d1_51 wen1_51 weny1_51 weny0_51 wen0_51
+  d0_51 q0_51 q1_50 d1_50 wen1_50 weny1_50 weny0_50 wen0_50 d0_50 q0_50 q1_49
+  d1_49 wen1_49 weny1_49 weny0_49 wen0_49 d0_49 q0_49 q1_48 d1_48 wen1_48
+  weny1_48 weny0_48 wen0_48 d0_48 q0_48 q1_47 d1_47 wen1_47 weny1_47 weny0_47
+  wen0_47 d0_47 q0_47 q1_46 d1_46 wen1_46 weny1_46 weny0_46 wen0_46 d0_46
+  q0_46 q1_45 d1_45 wen1_45 weny1_45 weny0_45 wen0_45 d0_45 q0_45 q1_44 d1_44
+  wen1_44 weny1_44 weny0_44 wen0_44 d0_44 q0_44 q1_43 d1_43 wen1_43 weny1_43
+  weny0_43 wen0_43 d0_43 q0_43 q1_42 d1_42 wen1_42 weny1_42 weny0_42 wen0_42
+  d0_42 q0_42 q1_41 d1_41 wen1_41 weny1_41 weny0_41 wen0_41 d0_41 q0_41 q1_40
+  d1_40 wen1_40 weny1_40 weny0_40 wen0_40 d0_40 q0_40 q1_39 d1_39 wen1_39
+  weny1_39 weny0_39 wen0_39 d0_39 q0_39 q1_38 d1_38 wen1_38 weny1_38 weny0_38
+  wen0_38 d0_38 q0_38 q1_37 d1_37 wen1_37 weny1_37 weny0_37 wen0_37 d0_37
+  q0_37 q1_36 d1_36 wen1_36 weny1_36 weny0_36 wen0_36 d0_36 q0_36 q1_35 d1_35
+  wen1_35 weny1_35 weny0_35 wen0_35 d0_35 q0_35 q1_34 d1_34 wen1_34 weny1_34
+  weny0_34 wen0_34 d0_34 q0_34 q1_33 d1_33 wen1_33 weny1_33 weny0_33 wen0_33
+  d0_33 q0_33 q1_32 d1_32 wen1_32 weny1_32 weny0_32 wen0_32 d0_32 q0_32 penso
+  pso1 pso0 log1 wablm1 wablm0 wabl rawlm1 rawlm0 rawl a1 emas emaw0 emaw1 a1
+  gwen cen clk a0 a1 a1 a3 a4 a5 a6 a7 a1 a1 a1 q0_31 d0_31 wen0_31 weny0_31
+  weny1_31 wen1_31 d1_31 q1_31 q0_30 d0_30 wen0_30 weny0_30 weny1_30 wen1_30
+  d1_30 q1_30 q0_29 d0_29 wen0_29 weny0_29 weny1_29 wen1_29 d1_29 q1_29 q0_28
+  d0_28 wen0_28 weny0_28 weny1_28 wen1_28 d1_28 vddpe q1_28 q0_27 d0_27
+  wen0_27 weny0_27 weny1_27 wen1_27 d1_27 q1_27 q0_26 d0_26 wen0_26 weny0_26
+  weny1_26 wen1_26 d1_26 q1_26 q0_25 d0_25 wen0_25 weny0_25 weny1_25 wen1_25
+  d1_25 q1_25 q0_24 d0_24 wen0_24 weny0_24 weny1_24 wen1_24 d1_24 q1_24 q0_23
+  d0_23 wen0_23 weny0_23 weny1_23 wen1_23 d1_23 q1_23 q0_22 d0_22 wen0_22
+  weny0_22 weny1_22 wen1_22 d1_22 q1_22 q0_21 d0_21 wen0_21 weny0_21 weny1_21
+  wen1_21 d1_21 q1_21 q0_20 d0_20 wen0_20 weny0_20 weny1_20 wen1_20 d1_20
+  q1_20 q0_19 d0_19 wen0_19 weny0_19 weny1_19 wen1_19 d1_19 q1_19 q0_18 d0_18
+  wen0_18 weny0_18 weny1_18 wen1_18 d1_18 q1_18 q0_17 d0_17 wen0_17 weny0_17
+  weny1_17 wen1_17 d1_17 q1_17 q0_16 d0_16 wen0_16 weny0_16 weny1_16 wen1_16
+  d1_16 q1_16 q0_15 d0_15 wen0_15 weny0_15 weny1_15 wen1_15 d1_15 q1_15 q0_14
+  d0_14 wen0_14 weny0_14 weny1_14 wen1_14 d1_14 q1_14 q0_13 d0_13 wen0_13
+  weny0_13 weny1_13 wen1_13 d1_13 q1_13 q0_12 d0_12 wen0_12 weny0_12 weny1_12
+  wen1_12 d1_12 q1_12 q0_11 d0_11 wen0_11 weny0_11 weny1_11 wen1_11 d1_11
+  q1_11 q0_10 d0_10 wen0_10 weny0_10 weny1_10 wen1_10 d1_10 q1_10 q0_9 d0_9
+  wen0_9 weny0_9 weny1_9 wen1_9 d1_9 q1_9 q0_8 d0_8 wen0_8 weny0_8 weny1_8
+  wen1_8 d1_8 q1_8 q0_7 d0_7 wen0_7 weny0_7 weny1_7 wen1_7 d1_7 q1_7 q0_6
+  d0_6 wen0_6 weny0_6 weny1_6 wen1_6 d1_6 q1_6 q0_5 d0_5 wen0_5 weny0_5
+  weny1_5 wen1_5 d1_5 q1_5 q0_4 d0_4 wen0_4 weny0_4 weny1_4 wen1_4 d1_4 q1_4
+  q0_3 d0_3 wen0_3 weny0_3 weny1_3 wen1_3 d1_3 q1_3 q0_2 d0_2 wen0_2 weny0_2
+  weny1_2 wen1_2 d1_2 q1_2 q0_1 d0_1 wen0_1 weny0_1 weny1_1 wen1_1 d1_1 q1_1
+  q0_0 d0_0 wen0_0 weny0_0 weny1_0 wen1_0 d1_0 q1_0 rf64x128io_slice
xmemslice nbl_term[2]_63 bl_term[1]_63 bl_term[0]_63 bl_term[3]_62
+  nbl_term[3]_62 nbl_term[2]_62 bl_term[2]_62 bl_term[1]_62 nbl_term[0]_62
+  bl_term[3]_61 nbl_term[2]_61 bl_term[2]_61 nbl_term[0]_61 bl_term[3]_60
+  nbl_term[2]_60 bl_term[2]_60 nbl_term[0]_60 bl_term[0]_60 bl_term[3]_59
+  nbl_term[2]_59 bl_term[2]_59 nbl_term[0]_59 bl_term[0]_59 bl_term[3]_58
+  nbl_term[2]_58 bl_term[2]_58 nbl_term[0]_58 bl_term[0]_58 bl_term[3]_57
+  nbl_term[2]_57 bl_term[2]_57 nbl_term[0]_57 bl_term[2]_56 nbl_term[0]_56
+  bl_term[2]_55 nbl_term[0]_55 bl_term[2]_54 nbl_term[0]_54 bl_term[2]_53
+  nbl_term[0]_53 bl_term[2]_52 nbl_term[0]_52 nbl_term[1]_51 nbl_term[0]_51
+  bl_term[3]_50 nbl_term[3]_50 bl_term[1]_50 nbl_term[1]_50 nbl_term[0]_50
+  nbl_term[3]_49 bl_term[1]_49 nbl_term[1]_49 nbl_term[0]_49 bl_term[3]_48
+  nbl_term[3]_48 bl_term[1]_48 nbl_term[1]_48 nbl_term[0]_48 nbl_term[3]_47
+  bl_term[1]_47 nbl_term[1]_47 nbl_term[0]_47 bl_term[3]_46 nbl_term[3]_46
+  bl_term[1]_46 nbl_term[1]_46 nbl_term[0]_46 bl_term[3]_45 nbl_term[3]_45
+  bl_term[1]_45 nbl_term[1]_45 bl_term[3]_44 nbl_term[3]_44 bl_term[1]_44
+  bl_term[0]_44 bl_term[3]_43 nbl_term[3]_43 nbl_term[2]_43 bl_term[2]_43
+  bl_term[1]_43 nbl_term[0]_43 bl_term[0]_43 bl_term[3]_42 nbl_term[3]_42
+  nbl_term[2]_42 bl_term[2]_42 bl_term[1]_42 nbl_term[0]_42 bl_term[0]_42
+  bl_term[3]_41 nbl_term[3]_41 nbl_term[2]_41 bl_term[2]_41 bl_term[1]_41
+  nbl_term[0]_41 bl_term[0]_41 bl_term[3]_40 nbl_term[3]_40 nbl_term[2]_40
+  bl_term[2]_40 bl_term[1]_40 nbl_term[1]_40 nbl_term[0]_40 bl_term[0]_40
+  bl_term[3]_39 nbl_term[2]_39 bl_term[2]_39 nbl_term[1]_39 nbl_term[0]_39
+  bl_term[0]_39 bl_term[3]_38 nbl_term[2]_38 bl_term[2]_38 nbl_term[1]_38
+  nbl_term[0]_38 bl_term[3]_37 bl_term[2]_37 vddce nbl_term[0]_37
+  bl_term[3]_36 bl_term[2]_36 nbl_term[0]_36 bl_term[3]_35 bl_term[2]_35
+  nbl_term[0]_35 bl_term[3]_34 bl_term[2]_34 nbl_term[1]_34 nbl_term[0]_34
+  bl_term[3]_33 bl_term[2]_33 nbl_term[1]_33 nbl_term[0]_33 bl_term[3]_32
+  bl_term[2]_32 nbl_term[1]_32 nbl_term[0]_32 ret a1 a1 vddc_wl vddpe
+  nbl_term[0]_31 bl_term[3]_31 nbl_term[0]_30 nbl_term[1]_30 bl_term[3]_30
+  nbl_term[0]_29 nbl_term[1]_29 nbl_term[3]_29 bl_term[3]_29 nbl_term[0]_28
+  nbl_term[1]_28 nbl_term[3]_28 bl_term[3]_28 nbl_term[0]_27 nbl_term[1]_27
+  nbl_term[3]_27 bl_term[3]_27 nbl_term[0]_26 nbl_term[1]_26 nbl_term[3]_26
+  bl_term[3]_26 nbl_term[0]_25 bl_term[1]_25 nbl_term[3]_25 bl_term[3]_25
+  nbl_term[1]_24 bl_term[1]_24 nbl_term[3]_24 bl_term[3]_24 nbl_term[1]_23
+  bl_term[1]_23 nbl_term[3]_23 bl_term[3]_23 nbl_term[1]_22 bl_term[1]_22
+  nbl_term[3]_22 bl_term[3]_22 nbl_term[1]_21 bl_term[1]_21 bl_term[2]_21
+  nbl_term[3]_21 bl_term[3]_21 nbl_term[1]_20 bl_term[1]_20 bl_term[2]_20
+  nbl_term[3]_20 bl_term[3]_20 nbl_term[1]_19 bl_term[2]_19 nbl_term[2]_19
+  bl_term[3]_19 nbl_term[0]_18 nbl_term[1]_18 bl_term[2]_18 bl_term[3]_18
+  nbl_term[0]_17 nbl_term[1]_17 bl_term[2]_17 bl_term[3]_17 nbl_term[0]_16
+  nbl_term[1]_16 bl_term[2]_16 bl_term[3]_16 nbl_term[0]_15 nbl_term[1]_15
+  bl_term[2]_15 bl_term[3]_15 nbl_term[0]_14 nbl_term[1]_14 bl_term[2]_14
+  bl_term[0]_13 nbl_term[0]_13 nbl_term[1]_13 bl_term[2]_13 nbl_term[2]_13
+  bl_term[0]_12 nbl_term[0]_12 nbl_term[1]_12 bl_term[2]_12 nbl_term[0]_11
+  nbl_term[1]_11 nbl_term[0]_10 nbl_term[1]_10 nbl_term[0]_9 nbl_term[1]_9
+  nbl_term[0]_8 nbl_term[1]_8 nbl_term[2]_8 bl_term[0]_7 bl_term[1]_7
+  nbl_term[2]_7 bl_term[0]_6 bl_term[1]_6 nbl_term[2]_6 bl_term[0]_5
+  nbl_term[2]_5 nbl_term[3]_5 bl_term[3]_5 bl_term[0]_4 nbl_term[3]_4
+  bl_term[3]_4 bl_term[0]_3 nbl_term[2]_3 nbl_term[3]_3 bl_term[3]_3
+  bl_term[0]_2 nbl_term[2]_2 bl_term[3]_2 bl_term[0]_1 nbl_term[2]_1
+  bl_term[3]_1 bl_term[0]_0 nbl_term[2]_0 bl_term[3]_0 vddpe vddpe
+  bl_term[3]_63 nbl_term[3]_63 bl_term[2]_63 nbl_term[1]_63 nbl_term[0]_63
+  nbl_term[1]_62 bl_term[0]_62 nbl_term[3]_61 bl_term[1]_61 nbl_term[1]_61
+  bl_term[0]_61 nbl_term[3]_60 bl_term[1]_60 nbl_term[1]_60 nbl_term[3]_59
+  bl_term[1]_59 nbl_term[1]_59 nbl_term[3]_58 bl_term[1]_58 nbl_term[1]_58
+  nbl_term[3]_57 bl_term[1]_57 nbl_term[1]_57 bl_term[0]_57 bl_term[3]_56
+  nbl_term[3]_56 nbl_term[2]_56 bl_term[1]_56 nbl_term[1]_56 bl_term[0]_56
+  bl_term[3]_55 nbl_term[3]_55 nbl_term[2]_55 bl_term[1]_55 nbl_term[1]_55
+  bl_term[0]_55 bl_term[3]_54 nbl_term[3]_54 nbl_term[2]_54 bl_term[1]_54
+  nbl_term[1]_54 bl_term[0]_54 bl_term[3]_53 nbl_term[3]_53 nbl_term[2]_53
+  bl_term[1]_53 nbl_term[1]_53 bl_term[0]_53 bl_term[3]_52 nbl_term[3]_52
+  nbl_term[2]_52 bl_term[1]_52 nbl_term[1]_52 bl_term[0]_52 bl_term[3]_51
+  nbl_term[3]_51 nbl_term[2]_51 bl_term[2]_51 bl_term[1]_51 bl_term[0]_51
+  nbl_term[2]_50 bl_term[2]_50 bl_term[0]_50 bl_term[3]_49 nbl_term[2]_49
+  bl_term[2]_49 bl_term[0]_49 nbl_term[2]_48 bl_term[2]_48 bl_term[0]_48
+  bl_term[3]_47 nbl_term[2]_47 bl_term[2]_47 bl_term[0]_47 nbl_term[2]_46
+  bl_term[2]_46 bl_term[0]_46 nbl_term[2]_45 bl_term[2]_45 nbl_term[0]_45
+  bl_term[0]_45 nbl_term[2]_44 bl_term[2]_44 nbl_term[1]_44 nbl_term[0]_44
+  nbl_term[1]_43 nbl_term[1]_42 nbl_term[1]_41 nbl_term[3]_39 bl_term[1]_39
+  nbl_term[3]_38 bl_term[1]_38 bl_term[0]_38 nbl_term[3]_37 nbl_term[2]_37
+  bl_term[1]_37 nbl_term[1]_37 bl_term[0]_37 nbl_term[3]_36 nbl_term[2]_36
+  bl_term[1]_36 nbl_term[1]_36 bl_term[0]_36 nbl_term[3]_35 nbl_term[2]_35
+  bl_term[1]_35 nbl_term[1]_35 bl_term[0]_35 nbl_term[3]_34 nbl_term[2]_34
+  bl_term[1]_34 bl_term[0]_34 nbl_term[3]_33 nbl_term[2]_33 bl_term[1]_33
+  bl_term[0]_33 nbl_term[3]_32 nbl_term[2]_32 bl_term[1]_32 bl_term[0]_32
+  vddpe dbl_nbl_wa_turn nact_cc a1 vddp_nor vddpe log1 a1 log0_sa dbl dwl gtp
+  gtp nla_p2[1] nla_p2[0] la_p2[1] la_p2[0] nra_p2[5] nra_p2[4] nra_p2[3]
+  nra_p2[2] nra_p2[1] nra_p2[0] ra_p2[5] ra_p2[4] ra_p2[3] ra_p2[2] ra_p2[1]
+  ra_p2[0] rawlm1 rawlm0 rawl cen_p2 nret ret1n ema0 ema1 ema2 dbl dwl
+  bl_term[0]_31 nbl_term[1]_31 bl_term[1]_31 bl_term[2]_31 nbl_term[2]_31
+  nbl_term[3]_31 bl_term[0]_30 bl_term[1]_30 bl_term[2]_30 nbl_term[2]_30
+  nbl_term[3]_30 bl_term[0]_29 bl_term[1]_29 bl_term[2]_29 nbl_term[2]_29
+  bl_term[0]_28 bl_term[1]_28 bl_term[2]_28 nbl_term[2]_28 bl_term[0]_27
+  bl_term[1]_27 bl_term[2]_27 nbl_term[2]_27 bl_term[0]_26 bl_term[1]_26
+  bl_term[2]_26 nbl_term[2]_26 bl_term[0]_25 nbl_term[1]_25 bl_term[2]_25
+  nbl_term[2]_25 bl_term[0]_24 nbl_term[0]_24 vpw bl_term[2]_24
+  nbl_term[2]_24 bl_term[0]_23 nbl_term[0]_23 bl_term[2]_23 nbl_term[2]_23
+  bl_term[0]_22 nbl_term[0]_22 bl_term[2]_22 nbl_term[2]_22 bl_term[0]_21
+  nbl_term[0]_21 nbl_term[2]_21 bl_term[0]_20 nbl_term[0]_20 nbl_term[2]_20
+  bl_term[0]_19 nbl_term[0]_19 bl_term[1]_19 nbl_term[3]_19 bl_term[0]_18
+  bl_term[1]_18 nbl_term[2]_18 nbl_term[3]_18 bl_term[0]_17 bl_term[1]_17
+  nbl_term[2]_17 nbl_term[3]_17 bl_term[0]_16 bl_term[1]_16 nbl_term[2]_16
+  nbl_term[3]_16 bl_term[0]_15 bl_term[1]_15 nbl_term[2]_15 nbl_term[3]_15
+  bl_term[0]_14 bl_term[1]_14 nbl_term[2]_14 nbl_term[3]_14 bl_term[3]_14
+  bl_term[1]_13 nbl_term[3]_13 bl_term[3]_13 bl_term[1]_12 nbl_term[2]_12
+  nbl_term[3]_12 bl_term[3]_12 bl_term[0]_11 bl_term[1]_11 bl_term[2]_11
+  nbl_term[2]_11 nbl_term[3]_11 bl_term[3]_11 bl_term[0]_10 bl_term[1]_10
+  bl_term[2]_10 nbl_term[2]_10 nbl_term[3]_10 bl_term[3]_10 bl_term[0]_9
+  bl_term[1]_9 bl_term[2]_9 nbl_term[2]_9 nbl_term[3]_9 bl_term[3]_9
+  bl_term[0]_8 bl_term[1]_8 bl_term[2]_8 nbl_term[3]_8 bl_term[3]_8
+  nbl_term[0]_7 nbl_term[1]_7 bl_term[2]_7 nbl_term[3]_7 bl_term[3]_7
+  nbl_term[0]_6 nbl_term[1]_6 bl_term[2]_6 nbl_term[3]_6 bl_term[3]_6
+  nbl_term[0]_5 nbl_term[1]_5 bl_term[1]_5 bl_term[2]_5 nbl_term[0]_4
+  nbl_term[1]_4 bl_term[1]_4 bl_term[2]_4 nbl_term[2]_4 nbl_term[0]_3
+  nbl_term[1]_3 bl_term[1]_3 bl_term[2]_3 nbl_term[0]_2 nbl_term[1]_2
+  bl_term[1]_2 bl_term[2]_2 nbl_term[3]_2 nbl_term[0]_1 nbl_term[1]_1
+  bl_term[1]_1 bl_term[2]_1 nbl_term[3]_1 nbl_term[0]_0 nbl_term[1]_0
+  bl_term[1]_0 bl_term[2]_0 nbl_term[3]_0 rf64x128mem_slice
.ends rf64x128TILE_TOP
****
.subckt rf64x128 VDDCE VDDPE VSSE q[127] q[126] q[125] q[124] q[123] q[122]
+  q[121] q[120] q[119] q[118] q[117] q[116] q[115] q[114] q[113] q[112]
+  q[111] q[110] q[109] q[108] q[107] q[106] q[105] q[104] q[103] q[102]
+  q[101] q[100] q[99] q[98] q[97] q[96] q[95] q[94] q[93] q[92] q[91] q[90]
+  q[89] q[88] q[87] q[86] q[85] q[84] q[83] q[82] q[81] q[80] q[79] q[78]
+  q[77] q[76] q[75] q[74] q[73] q[72] q[71] q[70] q[69] q[68] q[67] q[66]
+  q[65] q[64] q[63] q[62] q[61] q[60] q[59] q[58] q[57] q[56] q[55] q[54]
+  q[53] q[52] q[51] q[50] q[49] q[48] q[47] q[46] q[45] q[44] q[43] q[42]
+  q[41] q[40] q[39] q[38] q[37] q[36] q[35] q[34] q[33] q[32] q[31] q[30]
+  q[29] q[28] q[27] q[26] q[25] q[24] q[23] q[22] q[21] q[20] q[19] q[18]
+  q[17] q[16] q[15] q[14] q[13] q[12] q[11] q[10] q[9] q[8] q[7] q[6] q[5]
+  q[4] q[3] q[2] q[1] q[0] clk cen wen[127] wen[126] wen[125] wen[124]
+  wen[123] wen[122] wen[121] wen[120] wen[119] wen[118] wen[117] wen[116]
+  wen[115] wen[114] wen[113] wen[112] wen[111] wen[110] wen[109] wen[108]
+  wen[107] wen[106] wen[105] wen[104] wen[103] wen[102] wen[101] wen[100]
+  wen[99] wen[98] wen[97] wen[96] wen[95] wen[94] wen[93] wen[92] wen[91]
+  wen[90] wen[89] wen[88] wen[87] wen[86] wen[85] wen[84] wen[83] wen[82]
+  wen[81] wen[80] wen[79] wen[78] wen[77] wen[76] wen[75] wen[74] wen[73]
+  wen[72] wen[71] wen[70] wen[69] wen[68] wen[67] wen[66] wen[65] wen[64]
+  wen[63] wen[62] wen[61] wen[60] wen[59] wen[58] wen[57] wen[56] wen[55]
+  wen[54] wen[53] wen[52] wen[51] wen[50] wen[49] wen[48] wen[47] wen[46]
+  wen[45] wen[44] wen[43] wen[42] wen[41] wen[40] wen[39] wen[38] wen[37]
+  wen[36] wen[35] wen[34] wen[33] wen[32] wen[31] wen[30] wen[29] wen[28]
+  wen[27] wen[26] wen[25] wen[24] wen[23] wen[22] wen[21] wen[20] wen[19]
+  wen[18] wen[17] wen[16] wen[15] wen[14] wen[13] wen[12] wen[11] wen[10]
+  wen[9] wen[8] wen[7] wen[6] wen[5] wen[4] wen[3] wen[2] wen[1] wen[0] a[5]
+  a[4] a[3] a[2] a[1] a[0] d[127] d[126] d[125] d[124] d[123] d[122] d[121]
+  d[120] d[119] d[118] d[117] d[116] d[115] d[114] d[113] d[112] d[111]
+  d[110] d[109] d[108] d[107] d[106] d[105] d[104] d[103] d[102] d[101]
+  d[100] d[99] d[98] d[97] d[96] d[95] d[94] d[93] d[92] d[91] d[90] d[89]
+  d[88] d[87] d[86] d[85] d[84] d[83] d[82] d[81] d[80] d[79] d[78] d[77]
+  d[76] d[75] d[74] d[73] d[72] d[71] d[70] d[69] d[68] d[67] d[66] d[65]
+  d[64] d[63] d[62] d[61] d[60] d[59] d[58] d[57] d[56] d[55] d[54] d[53]
+  d[52] d[51] d[50] d[49] d[48] d[47] d[46] d[45] d[44] d[43] d[42] d[41]
+  d[40] d[39] d[38] d[37] d[36] d[35] d[34] d[33] d[32] d[31] d[30] d[29]
+  d[28] d[27] d[26] d[25] d[24] d[23] d[22] d[21] d[20] d[19] d[18] d[17]
+  d[16] d[15] d[14] d[13] d[12] d[11] d[10] d[9] d[8] d[7] d[6] d[5] d[4]
+  d[3] d[2] d[1] d[0] ema[2] ema[1] ema[0] emaw[1] emaw[0] emas gwen ret1n
+  wabl wablm[1] wablm[0] rawl rawlm[1] rawlm[0]
** rf64x128: 69681 flat devices **
xi0 VDDPE q[127] d[127] wen[127] weny1_63 weny0_63 wen[126] d[126] q[126]
+  q[125] d[125] wen[125] weny1_62 weny0_62 wen[124] d[124] q[124] q[123]
+  d[123] wen[123] weny1_61 weny0_61 wen[122] d[122] q[122] q[121] d[121]
+  wen[121] weny1_60 weny0_60 wen[120] d[120] q[120] q[119] d[119] wen[119]
+  weny1_59 weny0_59 wen[118] d[118] q[118] q[117] d[117] wen[117] weny1_58
+  weny0_58 wen[116] d[116] q[116] q[115] d[115] wen[115] weny1_57 weny0_57
+  wen[114] d[114] q[114] q[113] d[113] wen[113] weny1_56 weny0_56 wen[112]
+  d[112] q[112] q[111] d[111] wen[111] weny1_55 weny0_55 wen[110] d[110]
+  q[110] q[109] d[109] wen[109] weny1_54 weny0_54 wen[108] d[108] q[108]
+  q[107] d[107] wen[107] weny1_53 weny0_53 wen[106] d[106] q[106] q[105]
+  d[105] wen[105] weny1_52 weny0_52 wen[104] d[104] q[104] q[103] d[103]
+  wen[103] weny1_51 weny0_51 wen[102] d[102] q[102] q[101] d[101] wen[101]
+  weny1_50 weny0_50 wen[100] d[100] q[100] q[99] d[99] wen[99] weny1_49
+  weny0_49 wen[98] d[98] q[98] q[97] d[97] wen[97] weny1_48 weny0_48 wen[96]
+  d[96] q[96] q[95] d[95] wen[95] weny1_47 weny0_47 wen[94] d[94] q[94] q[93]
+  d[93] wen[93] weny1_46 weny0_46 wen[92] d[92] q[92] q[91] d[91] wen[91]
+  weny1_45 weny0_45 wen[90] d[90] q[90] q[89] d[89] wen[89] weny1_44 weny0_44
+  wen[88] d[88] q[88] q[87] d[87] wen[87] weny1_43 weny0_43 wen[86] d[86]
+  q[86] q[85] d[85] wen[85] weny1_42 weny0_42 wen[84] d[84] q[84] q[83] d[83]
+  wen[83] weny1_41 weny0_41 wen[82] d[82] q[82] q[81] d[81] wen[81] weny1_40
+  weny0_40 wen[80] d[80] q[80] q[79] d[79] wen[79] weny1_39 weny0_39 wen[78]
+  d[78] q[78] q[77] d[77] wen[77] weny1_38 weny0_38 wen[76] d[76] q[76] q[75]
+  d[75] wen[75] weny1_37 weny0_37 wen[74] d[74] q[74] q[73] d[73] wen[73]
+  weny1_36 weny0_36 wen[72] d[72] q[72] q[71] d[71] wen[71] weny1_35 weny0_35
+  wen[70] d[70] q[70] q[69] d[69] wen[69] weny1_34 weny0_34 wen[68] d[68]
+  q[68] q[67] d[67] wen[67] weny1_33 weny0_33 wen[66] d[66] q[66] q[65] d[65]
+  wen[65] weny1_32 weny0_32 wen[64] d[64] q[64] penso pso1 pso0 wablm[1]
+  wablm[0] wabl rawlm[1] rawlm[0] rawl emas ema[0] ema[1] ema[2] emaw[0]
+  emaw[1] ret1n gwen cen clk a[0] a[1] a[2] a[3] a[4] a[5] a1 q[63] d[63]
+  wen[63] weny0_31 weny1_31 wen[62] d[62] q[62] q[61] d[61] wen[61] weny0_30
+  weny1_30 wen[60] d[60] q[60] q[59] d[59] wen[59] weny0_29 weny1_29 wen[58]
+  d[58] q[58] q[57] d[57] wen[57] weny0_28 weny1_28 wen[56] d[56] q[56] q[55]
+  d[55] wen[55] weny0_27 weny1_27 wen[54] d[54] q[54] q[53] d[53] wen[53]
+  weny0_26 weny1_26 wen[52] d[52] q[52] q[51] d[51] wen[51] weny0_25 weny1_25
+  wen[50] d[50] q[50] q[49] d[49] wen[49] weny0_24 weny1_24 wen[48] d[48]
+  q[48] q[47] d[47] wen[47] weny0_23 weny1_23 wen[46] d[46] q[46] q[45] d[45]
+  wen[45] weny0_22 weny1_22 wen[44] d[44] q[44] q[43] d[43] wen[43] weny0_21
+  weny1_21 wen[42] d[42] q[42] q[41] d[41] wen[41] weny0_20 weny1_20 wen[40]
+  d[40] q[40] q[39] d[39] wen[39] weny0_19 weny1_19 wen[38] d[38] q[38] q[37]
+  d[37] wen[37] weny0_18 weny1_18 wen[36] d[36] q[36] q[35] d[35] wen[35]
+  weny0_17 weny1_17 wen[34] d[34] q[34] q[33] d[33] wen[33] weny0_16 weny1_16
+  wen[32] d[32] q[32] q[31] d[31] wen[31] weny0_15 weny1_15 wen[30] d[30]
+  q[30] q[29] d[29] wen[29] weny0_14 weny1_14 wen[28] d[28] q[28] q[27] d[27]
+  wen[27] weny0_13 weny1_13 wen[26] d[26] q[26] q[25] d[25] wen[25] weny0_12
+  weny1_12 wen[24] d[24] q[24] q[23] d[23] wen[23] weny0_11 weny1_11 wen[22]
+  d[22] q[22] q[21] d[21] wen[21] weny0_10 weny1_10 wen[20] d[20] q[20] q[19]
+  d[19] wen[19] weny0_9 weny1_9 wen[18] d[18] q[18] q[17] d[17] wen[17]
+  weny0_8 weny1_8 wen[16] d[16] q[16] q[15] d[15] wen[15] weny0_7 weny1_7
+  wen[14] d[14] q[14] q[13] d[13] wen[13] weny0_6 weny1_6 wen[12] d[12] VSSE
+  q[12] q[11] d[11] wen[11] weny0_5 weny1_5 wen[10] d[10] q[10] q[9] d[9]
+  wen[9] weny0_4 weny1_4 wen[8] d[8] q[8] q[7] d[7] wen[7] weny0_3 weny1_3
+  wen[6] d[6] q[6] q[5] d[5] wen[5] weny0_2 weny1_2 wen[4] d[4] q[4] q[3]
+  d[3] wen[3] weny0_1 weny1_1 wen[2] d[2] q[2] q[1] VDDCE d[1] wen[1] weny0_0
+  weny1_0 wen[0] d[0] q[0] rf64x128TILE_TOP
.ends rf64x128

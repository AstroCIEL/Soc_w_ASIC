* 
* Copyright (c) 1993 - 2026 ARM. All Rights Reserved
* This file has been provided pursuant to a License Agreement
* containing restrictions on its use.  This file contains valuable
* trade secrets and proprietary information of ARM,
* and is protected by patents, copyright law
* and international treaties
* 
* Generated by bif2cdl 3.24.0
* Version: r0p0
* Name: High Density Single Port Register File SVT MVT Compiler | CLN22ULL-GL 22nm Process, 256 Rows Per Bit Line, 0.192um^2 BitCell
* Comment: This is a memory instance
* Configuration:  -activity_factor 50 -atf off -back_biasing off -b\
* Configuration: its 128 -bmux off -bus_notation on -check_instname\
* Configuration:  on -diodes on -drive 6 -ema on -frequency 1.0 -in\
* Configuration: stname rf64x128 -left_bus_delim "[" -mux 2 -mvt BA\
* Configuration: SE -name_case lower -power_gating off -power_type \
* Configuration: otc -pwr_gnd_rename vddpe:VDDPE,vddce:VDDCE,vsse:V\
* Configuration: SSE -rcols 2 -redundancy off -retention on -right_\
* Configuration: bus_delim "]" -rrows 0 -ser none -site_def off -to\
* Configuration: p_layer m5-m10 -vmin_assist on -words 64 -wp_size \
* Configuration: 1 -write_mask on -write_thru off -corners ffg_cbes\
* Configuration: tt_0p88v_0p88v_m40c,ssg_cworstt_0p72v_0p72v_125c,s\
* Configuration: sg_cworstt_0p72v_0p72v_m40c,tt_typical_0p80v_0p80v\
* Configuration: _25c
* Codefile: 
* 
*
*.BIPOLAR
*.DIOAREA
*.DIOPERI
*
****
.subckt rf64x128botcap2x2 q0 q1 weny0 weny1 vddce vddpe vnwp vpw vss vsse d0
+  d1 td0 td1 twen0 twen1 wen0 wen1
** rf64x128botcap2x2: 8 flat devices **
di0.d_diode_x_dio vpw wen0 ndio_ll AREA=0.018P PJ=0.54U
di4.d_diode_x_dio vpw twen0 ndio_ll AREA=0.018P PJ=0.54U
di5.d_diode_x_dio vpw td0 ndio_ll AREA=0.018P PJ=0.54U
di6.d_diode_x_dio vpw d1 ndio_ll AREA=0.018P PJ=0.54U
di7.d_diode_x_dio vpw wen1 ndio_ll AREA=0.018P PJ=0.54U
di8.d_diode_x_dio vpw td1 ndio_ll AREA=0.018P PJ=0.54U
di82.d_diode_x_dio vpw d0 ndio_ll AREA=0.018P PJ=0.54U
di9.d_diode_x_dio vpw twen1 ndio_ll AREA=0.018P PJ=0.54U
.ends rf64x128botcap2x2
****
.subckt rf64x128botcap2x2_rpt vnwp vpw weny1 twen1 vddpe vddce vss q1 q0 d0
+  td0 wen0 twen0 weny0 wen1 td1 d1
** rf64x128botcap2x2_rpt: 8 flat devices **
xbcap q0 q1 weny0 weny1 vddce vddpe vnwp vpw vss vss d0 d1 td0 td1 twen0 twen1
+  wen0 wen1 rf64x128botcap2x2
.ends rf64x128botcap2x2_rpt
****
.subckt rf64x128midbot ay0 ay1 ay2 ay3 ay4 ay5 ay6 ay7 ay8 ay9 ay10 ceny gweny
+  log0 log1 penso prdyn pso0 pso1 so0 so1 vddce vddpe vnwc vnwp vpw vss vsse
+  a0 a1 a2 a3 a4 a5 a6 a7 a8 a9 a10 cen clk cre1 cre2 dftrambyp ema0 ema1
+  ema2 emas emaw0 emaw1 fca1_0 fca1_1 fca1_2 fca1_3 fca1_4 fca1_5 fca1_6
+  fca2_0 fca2_1 fca2_2 fca2_3 fca2_4 fca2_5 fca2_6 gwen pen pensi pgen rawl
+  rawlm0 rawlm1 rdt ret1n ret2n se ta0 ta1 ta2 ta3 ta4 ta5 ta6 ta7 ta8 ta9
+  ta10 tcen ten tgwen tpen wabl wablm0 wablm1
** rf64x128midbot: 65 flat devices **
di113.d_diode_x_dio vpw dftrambyp ndio_ll AREA=0.018P PJ=0.54U
di114.d_diode_x_dio vpw emaw1 ndio_ll AREA=0.018P PJ=0.54U
di115.d_diode_x_dio vpw emaw0 ndio_ll AREA=0.018P PJ=0.54U
di116.d_diode_x_dio vpw rdt ndio_ll AREA=0.018P PJ=0.54U
di121.d_diode_x_dio vpw clk ndio_ll AREA=0.018P PJ=0.54U
di137.d_diode_x_dio vpw ta0 ndio_ll AREA=0.018P PJ=0.54U
di138.d_diode_x_dio vpw ta1 ndio_ll AREA=0.018P PJ=0.54U
di139.d_diode_x_dio vpw ta4 ndio_ll AREA=0.018P PJ=0.54U
di140.d_diode_x_dio vpw ta5 ndio_ll AREA=0.018P PJ=0.54U
di141.d_diode_x_dio vpw ta2 ndio_ll AREA=0.018P PJ=0.54U
di142.d_diode_x_dio vpw ta3 ndio_ll AREA=0.018P PJ=0.54U
di143.d_diode_x_dio vpw ta6 ndio_ll AREA=0.018P PJ=0.54U
di144.d_diode_x_dio vpw ta7 ndio_ll AREA=0.018P PJ=0.54U
di145.d_diode_x_dio vpw ta8 ndio_ll AREA=0.018P PJ=0.54U
di146.d_diode_x_dio vpw ta9 ndio_ll AREA=0.018P PJ=0.54U
di147.d_diode_x_dio vpw ta10 ndio_ll AREA=0.018P PJ=0.54U
di159.d_diode_x_dio vpw tcen ndio_ll AREA=0.018P PJ=0.54U
di160.d_diode_x_dio vpw tgwen ndio_ll AREA=0.018P PJ=0.54U
di163.d_diode_x_dio vpw ten ndio_ll AREA=0.018P PJ=0.54U
di176.d_diode_x_dio vpw cre1 ndio_ll AREA=0.018P PJ=0.54U
di177.d_diode_x_dio vpw fca1_0 ndio_ll AREA=0.018P PJ=0.54U
di178.d_diode_x_dio vpw fca1_1 ndio_ll AREA=0.018P PJ=0.54U
di179.d_diode_x_dio vpw fca1_2 ndio_ll AREA=0.018P PJ=0.54U
di180.d_diode_x_dio vpw fca1_3 ndio_ll AREA=0.018P PJ=0.54U
di181.d_diode_x_dio vpw fca1_4 ndio_ll AREA=0.018P PJ=0.54U
di182.d_diode_x_dio vpw fca1_5 ndio_ll AREA=0.018P PJ=0.54U
di183.d_diode_x_dio vpw fca1_6 ndio_ll AREA=0.018P PJ=0.54U
di184.d_diode_x_dio vpw cre2 ndio_ll AREA=0.018P PJ=0.54U
di185.d_diode_x_dio vpw fca2_0 ndio_ll AREA=0.018P PJ=0.54U
di186.d_diode_x_dio vpw fca2_1 ndio_ll AREA=0.018P PJ=0.54U
di187.d_diode_x_dio vpw fca2_2 ndio_ll AREA=0.018P PJ=0.54U
di188.d_diode_x_dio vpw fca2_3 ndio_ll AREA=0.018P PJ=0.54U
di189.d_diode_x_dio vpw fca2_4 ndio_ll AREA=0.018P PJ=0.54U
di190.d_diode_x_dio vpw fca2_5 ndio_ll AREA=0.018P PJ=0.54U
di191.d_diode_x_dio vpw fca2_6 ndio_ll AREA=0.018P PJ=0.54U
di192.d_diode_x_dio vpw pen ndio_ll AREA=0.018P PJ=0.54U
di193.d_diode_x_dio vpw tpen ndio_ll AREA=0.018P PJ=0.54U
di194.d_diode_x_dio vpw pensi ndio_ll AREA=0.018P PJ=0.54U
di196.d_diode_x_dio vpw pgen ndio_ll AREA=0.018P PJ=0.54U
di197.d_diode_x_dio vpw ret2n ndio_ll AREA=0.018P PJ=0.54U
di198.d_diode_x_dio vpw wablm1 ndio_ll AREA=0.018P PJ=0.54U
di199.d_diode_x_dio vpw wablm0 ndio_ll AREA=0.018P PJ=0.54U
di200.d_diode_x_dio vpw wabl ndio_ll AREA=0.018P PJ=0.54U
di201.d_diode_x_dio vpw rawlm1 ndio_ll AREA=0.018P PJ=0.54U
di202.d_diode_x_dio vpw rawlm0 ndio_ll AREA=0.018P PJ=0.54U
di203.d_diode_x_dio vpw rawl ndio_ll AREA=0.018P PJ=0.54U
di59.d_diode_x_dio vpw cen ndio_ll AREA=0.018P PJ=0.54U
di60.d_diode_x_dio vpw gwen ndio_ll AREA=0.018P PJ=0.54U
di61.d_diode_x_dio vpw ret1n ndio_ll AREA=0.018P PJ=0.54U
di62.d_diode_x_dio vpw emas ndio_ll AREA=0.018P PJ=0.54U
di63.d_diode_x_dio vpw ema0 ndio_ll AREA=0.018P PJ=0.54U
di64.d_diode_x_dio vpw ema1 ndio_ll AREA=0.018P PJ=0.54U
di65.d_diode_x_dio vpw ema2 ndio_ll AREA=0.018P PJ=0.54U
di85.d_diode_x_dio vpw se ndio_ll AREA=0.018P PJ=0.54U
di86.d_diode_x_dio vpw a0 ndio_ll AREA=0.018P PJ=0.54U
di87.d_diode_x_dio vpw a1 ndio_ll AREA=0.018P PJ=0.54U
di88.d_diode_x_dio vpw a2 ndio_ll AREA=0.018P PJ=0.54U
di89.d_diode_x_dio vpw a3 ndio_ll AREA=0.018P PJ=0.54U
di90.d_diode_x_dio vpw a4 ndio_ll AREA=0.018P PJ=0.54U
di91.d_diode_x_dio vpw a5 ndio_ll AREA=0.018P PJ=0.54U
di92.d_diode_x_dio vpw a6 ndio_ll AREA=0.018P PJ=0.54U
di93.d_diode_x_dio vpw a7 ndio_ll AREA=0.018P PJ=0.54U
di94.d_diode_x_dio vpw a8 ndio_ll AREA=0.018P PJ=0.54U
di95.d_diode_x_dio vpw a9 ndio_ll AREA=0.018P PJ=0.54U
di96.d_diode_x_dio vpw a10 ndio_ll AREA=0.018P PJ=0.54U
.ends rf64x128midbot
****
.subckt rf64x128midbot_pgm prdyn fca2_6 fca2_5 fca2_4 fca2_3 fca2_2 fca2_1
+  cre2 fca1_0 vss pensi pso1 pso0 se so0 log1 dftrambyp ret1n gwen clk a6 a7
+  tgwen tcen ta0 ta1 ta2 ta3 ta4 ta5 gweny ay0 ay1 ay2 ay3 ay4 ay5 fca2_0
+  fca1_6 fca1_5 fca1_4 fca1_3 fca1_2 fca1_1 cre1 vpw vnwp vnwc vsse vddce
+  vddpe penso tpen pen so1 wablm1 wablm0 wabl rawlm1 rawlm0 rawl ten emas
+  ema0 ema1 ema2 emaw0 emaw1 ret2n pgen cen a0 a3 a4 a5 a1 ta6 ta7 ta8 ta9
+  ta10 ceny ay6 ay7 ay8 ay9 ay10
** rf64x128midbot_pgm: 65 flat devices **
xmidbot_pgm ay0 ay1 ay2 ay3 ay4 ay5 ay6 ay7 ay8 ay9 ay10 ceny gweny a1 log1
+  penso prdyn pso0 pso1 so0 so1 vddce vddpe vnwc vnwp vpw vss vsse a0 a1 a1
+  a3 a4 a5 a6 a7 a1 a1 a1 cen clk cre1 cre2 dftrambyp ema0 ema1 ema2 emas
+  emaw0 emaw1 fca1_0 fca1_1 fca1_2 fca1_3 fca1_4 fca1_5 fca1_6 fca2_0 fca2_1
+  fca2_2 fca2_3 fca2_4 fca2_5 fca2_6 gwen pen pensi pgen rawl rawlm0 rawlm1
+  a1 ret1n ret2n se ta0 ta1 ta2 ta3 ta4 ta5 ta6 ta7 ta8 ta9 ta10 tcen ten
+  tgwen tpen wabl wablm0 wablm1 rf64x128midbot
.ends rf64x128midbot_pgm
****
.subckt rf64x128botcorner vnwc vnwp vpw vss vsse psi si
** rf64x128botcorner: 2 flat devices **
di0.d_diode_x_dio vpw psi ndio_ll AREA=0.018P PJ=0.54U
di62.d_diode_x_dio vpw si ndio_ll AREA=0.018P PJ=0.54U
.ends rf64x128botcorner
****
.subckt rf64x128botcaprow vsse_2 si_1 psi_1 q1_63 vddce_64 vddpe_64 weny1_63
+  wen1_62 twen1_62 d0_62 vddce_63 vddpe_63 d1_61 wen1_61 twen1_61 d0_61
+  vddce_62 vddpe_62 d1_60 wen1_60 twen1_60 d0_60 vddce_61 vddpe_61 d1_59
+  wen1_59 twen1_59 weny0_59 twen0_59 wen0_59 d0_59 vddpe_60 vnwp q0_59
+  vddce_59 wen1_58 twen1_58 weny1_58 weny0_58 twen0_58 wen0_58 td0_58 d0_58
+  vddpe_59 q0_58 vddce_58 wen1_57 twen1_57 weny1_57 weny0_57 twen0_57 wen0_57
+  td0_57 d0_57 vddpe_58 q0_57 vddce_57 vddpe_57 wen1_56 twen1_56 weny1_56
+  weny0_56 twen0_56 wen0_56 td0_56 d0_56 vddpe_56 wen1_55 twen1_55 weny0_55
+  wen0_55 td0_55 d0_55 q1_54 vddpe_55 wen1_54 twen1_54 weny0_54 wen0_54 d0_54
+  q1_53 weny1_53 weny0_53 twen0_53 wen0_53 td0_53 q0_53 q1_52 weny1_52
+  weny0_52 twen0_52 wen0_52 td0_52 q1_51 td1_51 weny0_51 wen0_51 d0_51 q0_51
+  q1_50 td1_50 weny0_50 wen0_50 d0_50 q0_50 q1_49 td1_49 weny0_49 wen0_49
+  q0_49 q1_48 td1_48 weny0_48 wen0_48 d1_47 td1_47 twen0_47 wen0_47 td0_47
+  d0_47 d1_46 td1_46 twen0_46 wen0_46 td0_46 d0_46 d1_45 td1_45 twen1_45
+  twen0_45 wen0_45 td0_45 d0_45 d1_44 td1_44 twen1_44 twen0_44 wen0_44 d0_44
+  vddpe_45 vddce_44 vddpe_44 d1_43 td1_43 wen1_43 twen1_43 weny0_43 vddce_43
+  vddpe_43 d1_42 td1_42 wen1_42 twen1_42 weny0_42 twen0_42 wen0_42 d0_42
+  vddce_42 vddpe_42 d1_41 wen1_41 twen1_41 weny0_41 twen0_41 wen0_41 d0_41
+  vddce_41 vddpe_41 d1_40 wen1_40 twen1_40 weny0_40 twen0_40 wen0_40 d0_40
+  q1_39 vddce_40 vddpe_40 wen1_39 twen1_39 weny0_39 td0_39 q1_38 vddpe_39
+  wen1_38 twen1_38 weny0_38 td0_38 q1_37 vddpe_38 wen1_37 twen1_37 weny0_37
+  td0_37 vpw q1_36 weny0_36 twen0_36 wen0_36 d0_36 q0_36 q1_35 td1_35
+  weny0_35 d0_35 q0_35 q1_34 td1_34 weny0_34 d0_34 q0_34 q1_33 td1_33
+  weny0_33 twen0_33 d0_33 q0_33 q1_32 td1_32 weny0_32 twen0_32 d0_32 q0_32
+  prdyn fca2_6 fca2_5 fca2_4 fca2_3 fca2_2 fca2_1 cre2 fca1_0 vnwc_1 vddce_32
+  vddpe_32 pensi pso1 pso0 se so0 log1 dftrambyp ret1n gwen clk a6 a7 tgwen
+  tcen ta0 ta1 ta2 ta3 ta4 ta5 gweny ceny ay0 ay1 ay2 ay3 ay4 ay5 weny1_31
+  twen1_31 wen1_31 td1_31 d1_31 vddpe_31 vddce_31 q1_31 weny0_30 twen1_30
+  wen1_30 td1_30 d1_30 vddpe_30 vddce_30 weny0_29 twen1_29 wen1_29 td1_29
+  d1_29 vddpe_29 vddce_29 weny0_28 twen1_28 wen1_28 td1_28 d1_28 vddpe_28
+  vddce_28 d0_27 td0_27 wen0_27 twen0_27 twen1_27 wen1_27 d1_27 vddpe_27
+  vddce_27 d0_26 td0_26 wen0_26 twen0_26 twen1_26 wen1_26 d1_26 vddpe_26
+  vddce_26 q0_25 d0_25 td0_25 wen0_25 twen0_25 twen1_25 wen1_25 vddpe_25
+  vddce_25 q0_24 d0_24 td0_24 wen0_24 twen0_24 twen1_24 wen1_24 vddpe_24
+  q1_24 q0_23 d0_23 td0_23 wen0_23 twen0_23 weny0_23 twen1_23 wen1_23
+  vddpe_23 q1_23 q0_22 d0_22 td0_22 wen0_22 twen0_22 weny0_22 twen1_22
+  wen1_22 vddpe_22 q1_22 q0_21 d0_21 td0_21 wen0_21 twen0_21 weny0_21
+  twen1_21 wen1_21 vddpe_21 q1_21 q0_20 d0_20 td0_20 wen0_20 twen0_20
+  weny0_20 weny1_20 twen1_20 wen1_20 vddpe_20 q1_20 q0_19 d0_19 wen0_19
+  twen0_19 weny0_19 weny1_19 td1_19 d1_19 q1_19 q0_18 wen0_18 twen0_18
+  weny0_18 weny1_18 td1_18 d1_18 q1_18 q0_17 wen0_17 twen0_17 weny0_17
+  weny1_17 td1_17 d1_17 q1_17 q0_16 wen0_16 twen0_16 weny0_16 weny1_16 td1_16
+  d1_16 q1_16 q0_15 vddpe_15 td0_15 wen0_15 twen0_15 weny0_15 weny1_15
+  twen1_15 wen1_15 td1_15 d1_15 vddce_15 q1_15 q0_14 vddpe_14 td0_14 wen0_14
+  twen0_14 weny0_14 weny1_14 twen1_14 wen1_14 td1_14 d1_14 vddce_14 q1_14
+  vddpe_13 d0_13 td0_13 weny1_13 twen1_13 wen1_13 td1_13 d1_13 vddce_13 q1_13
+  vddpe_12 d0_12 td0_12 weny1_12 twen1_12 wen1_12 td1_12 d1_12 vddce_12 q1_12
+  q0_11 d0_11 td0_11 wen0_11 twen0_11 weny1_11 twen1_11 wen1_11 td1_11 d1_11
+  vddpe_11 vddce_11 q1_11 q0_10 d0_10 td0_10 wen0_10 twen0_10 weny0_10
+  weny1_10 twen1_10 wen1_10 td1_10 d1_10 vddpe_10 vddce_10 q1_10 q0_9 d0_9
+  td0_9 wen0_9 twen0_9 weny0_9 weny1_9 twen1_9 wen1_9 td1_9 d1_9 vddpe_9
+  vddce_9 q1_9 q0_8 d0_8 td0_8 wen0_8 twen0_8 weny0_8 twen1_8 wen1_8 d1_8
+  vddpe_8 vddce_8 q1_8 q0_7 d0_7 td0_7 wen0_7 twen0_7 weny0_7 weny1_7 twen1_7
+  wen1_7 d1_7 vddpe_7 vddce_7 q1_7 q0_6 d0_6 td0_6 wen0_6 twen0_6 weny0_6
+  weny1_6 twen1_6 wen1_6 td1_6 d1_6 vddpe_6 vddce_6 q1_6 q0_5 d0_5 td0_5
+  wen0_5 twen0_5 weny0_5 weny1_5 twen1_5 wen1_5 td1_5 d1_5 vddpe_5 vddce_5
+  q1_5 q0_4 d0_4 td0_4 wen0_4 twen0_4 weny0_4 weny1_4 twen1_4 wen1_4 td1_4
+  d1_4 vddpe_4 vddce_4 d1_3 q1_3 q0_2 d0_2 td0_2 wen0_2 twen0_2 weny0_2
+  weny1_2 twen1_2 wen1_2 td1_2 d1_2 vddpe_2 q1_2 q0_1 vddce_1 d0_1 td0_1
+  wen0_1 twen0_1 weny0_1 weny1_1 twen1_1 wen1_1 td1_1 d1_1 vddpe_1 q1_1 q0_0
+  vddce_0 weny1_0 vddpe_0 vnwc_2 d1_63 td1_63 wen1_63 twen1_63 weny0_63
+  twen0_63 wen0_63 td0_63 d0_63 q0_63 q1_62 d1_62 td1_62 weny1_62 weny0_62
+  twen0_62 wen0_62 td0_62 q0_62 q1_61 td1_61 weny1_61 weny0_61 twen0_61
+  wen0_61 td0_61 q0_61 q1_60 td1_60 weny1_60 weny0_60 twen0_60 wen0_60 td0_60
+  q0_60 q1_59 td1_59 weny1_59 td0_59 vddce_60 q1_58 d1_58 td1_58 q1_57 d1_57
+  td1_57 q1_56 d1_56 td1_56 q0_56 q1_55 vddce_56 d1_55 td1_55 weny1_55
+  twen0_55 q0_55 vddce_55 d1_54 td1_54 weny1_54 twen0_54 td0_54 q0_54
+  vddce_54 d1_53 td1_53 wen1_53 twen1_53 d0_53 vddpe_54 vddce_53 vddpe_53
+  d1_52 td1_52 wen1_52 twen1_52 d0_52 q0_52 vddce_52 vddpe_52 d1_51 wen1_51
+  twen1_51 weny1_51 twen0_51 td0_51 vddce_51 vddpe_51 d1_50 wen1_50 twen1_50
+  weny1_50 twen0_50 td0_50 vddce_50 vddpe_50 d1_49 wen1_49 twen1_49 weny1_49
+  twen0_49 td0_49 d0_49 vddce_49 vddpe_49 d1_48 wen1_48 twen1_48 weny1_48
+  twen0_48 td0_48 d0_48 q0_48 q1_47 vddce_48 vddpe_48 wen1_47 twen1_47
+  weny1_47 weny0_47 q0_47 q1_46 vddce_47 vddpe_47 wen1_46 twen1_46 weny1_46
+  weny0_46 q0_46 q1_45 vddce_46 vddpe_46 wen1_45 weny1_45 weny0_45 q0_45
+  q1_44 vddce_45 wen1_44 weny1_44 weny0_44 td0_44 q0_44 q1_43 weny1_43
+  twen0_43 wen0_43 td0_43 d0_43 q0_43 q1_42 weny1_42 td0_42 q0_42 q1_41
+  td1_41 weny1_41 td0_41 q0_41 q1_40 td1_40 weny1_40 td0_40 q0_40 d1_39
+  td1_39 weny1_39 twen0_39 wen0_39 d0_39 q0_39 d1_38 td1_38 weny1_38 twen0_38
+  wen0_38 d0_38 vddce_39 q0_38 d1_37 td1_37 weny1_37 twen0_37 wen0_37 d0_37
+  vddce_38 q0_37 vddce_37 d1_36 td1_36 wen1_36 twen1_36 weny1_36 td0_36
+  vddpe_37 vddce_36 d1_35 wen1_35 twen1_35 weny1_35 twen0_35 wen0_35 td0_35
+  vddpe_36 vss vddce_35 d1_34 wen1_34 twen1_34 weny1_34 twen0_34 wen0_34
+  td0_34 vddpe_35 vddce_34 d1_33 wen1_33 twen1_33 weny1_33 wen0_33 td0_33
+  vddpe_34 vddce_33 vddpe_33 d1_32 wen1_32 twen1_32 weny1_32 wen0_32 td0_32
+  fca2_0 fca1_6 fca1_5 fca1_4 fca1_3 fca1_2 fca1_1 cre1 vsse_1 penso tpen pen
+  so1 wablm1 wablm0 wabl rawlm1 rawlm0 rawl ten emas ema0 ema1 ema2 emaw0
+  emaw1 ret2n pgen cen a0 a3 a4 a5 a1 ta6 ta7 ta8 ta9 ta10 ay6 ay7 ay8 ay9
+  ay10 q0_31 d0_31 td0_31 wen0_31 twen0_31 weny0_31 q0_30 d0_30 td0_30
+  wen0_30 twen0_30 weny1_30 q1_30 q0_29 d0_29 td0_29 wen0_29 twen0_29
+  weny1_29 q1_29 q0_28 d0_28 td0_28 wen0_28 twen0_28 weny1_28 q1_28 q0_27
+  weny0_27 weny1_27 td1_27 q1_27 q0_26 weny0_26 weny1_26 td1_26 q1_26
+  weny0_25 weny1_25 td1_25 d1_25 q1_25 vddce_24 weny0_24 weny1_24 td1_24
+  d1_24 vddce_23 weny1_23 td1_23 d1_23 vddce_22 weny1_22 td1_22 d1_22
+  vddce_21 weny1_21 td1_21 d1_21 td1_20 d1_20 vddce_20 vddce_19 td0_19
+  twen1_19 wen1_19 vddpe_19 d0_18 td0_18 twen1_18 wen1_18 vddpe_18 vddce_18
+  d0_17 td0_17 twen1_17 wen1_17 vddpe_17 vddce_17 d0_16 td0_16 twen1_16
+  wen1_16 vddpe_16 vddce_16 d0_15 d0_14 q0_13 wen0_13 twen0_13 weny0_13 q0_12
+  wen0_12 twen0_12 weny0_12 weny0_11 weny1_8 td1_8 td1_7 q1_4 q0_3 vddce_3
+  d0_3 td0_3 wen0_3 twen0_3 weny0_3 weny1_3 twen1_3 wen1_3 td1_3 vddpe_3
+  vddce_2 d0_0 td0_0 wen0_0 twen0_0 weny0_0 twen1_0 wen1_0 td1_0 d1_0 q1_0
+  psi_0 si_0 vnwc_0 vsse_0
** rf64x128botcaprow: 581 flat devices **
xcentre prdyn fca2_6 fca2_5 fca2_4 fca2_3 fca2_2 fca2_1 cre2 fca1_0 vss pensi
+  pso1 pso0 se so0 log1 dftrambyp ret1n gwen clk a6 a7 tgwen tcen ta0 ta1 ta2
+  ta3 ta4 ta5 gweny ay0 ay1 ay2 ay3 ay4 ay5 fca2_0 fca1_6 fca1_5 fca1_4
+  fca1_3 fca1_2 fca1_1 cre1 vpw vnwp vnwc_1 vsse_1 vddce_32 vddpe_32 penso
+  tpen pen so1 wablm1 wablm0 wabl rawlm1 rawlm0 rawl ten emas ema0 ema1 ema2
+  emaw0 emaw1 ret2n pgen cen a0 a3 a4 a5 a1 ta6 ta7 ta8 ta9 ta10 ceny ay6 ay7
+  ay8 ay9 ay10 rf64x128midbot_pgm
xleft vnwc_0 vnwp vpw vss vsse_0 psi_0 si_0 rf64x128botcorner
xleft_col_0 vnwp vpw weny1_0 twen1_0 vddpe_0 vddce_0 vss q1_0 q0_0 d0_0 td0_0
+  wen0_0 twen0_0 weny0_0 wen1_0 td1_0 d1_0 rf64x128botcap2x2_rpt
xleft_col_1 vnwp vpw weny1_1 twen1_1 vddpe_1 vddce_1 vss q1_1 q0_1 d0_1 td0_1
+  wen0_1 twen0_1 weny0_1 wen1_1 td1_1 d1_1 rf64x128botcap2x2_rpt
xleft_col_10 vnwp vpw weny1_10 twen1_10 vddpe_10 vddce_10 vss q1_10 q0_10
+  d0_10 td0_10 wen0_10 twen0_10 weny0_10 wen1_10 td1_10 d1_10
+  rf64x128botcap2x2_rpt
xleft_col_11 vnwp vpw weny1_11 twen1_11 vddpe_11 vddce_11 vss q1_11 q0_11
+  d0_11 td0_11 wen0_11 twen0_11 weny0_11 wen1_11 td1_11 d1_11
+  rf64x128botcap2x2_rpt
xleft_col_12 vnwp vpw weny1_12 twen1_12 vddpe_12 vddce_12 vss q1_12 q0_12
+  d0_12 td0_12 wen0_12 twen0_12 weny0_12 wen1_12 td1_12 d1_12
+  rf64x128botcap2x2_rpt
xleft_col_13 vnwp vpw weny1_13 twen1_13 vddpe_13 vddce_13 vss q1_13 q0_13
+  d0_13 td0_13 wen0_13 twen0_13 weny0_13 wen1_13 td1_13 d1_13
+  rf64x128botcap2x2_rpt
xleft_col_14 vnwp vpw weny1_14 twen1_14 vddpe_14 vddce_14 vss q1_14 q0_14
+  d0_14 td0_14 wen0_14 twen0_14 weny0_14 wen1_14 td1_14 d1_14
+  rf64x128botcap2x2_rpt
xleft_col_15 vnwp vpw weny1_15 twen1_15 vddpe_15 vddce_15 vss q1_15 q0_15
+  d0_15 td0_15 wen0_15 twen0_15 weny0_15 wen1_15 td1_15 d1_15
+  rf64x128botcap2x2_rpt
xleft_col_16 vnwp vpw weny1_16 twen1_16 vddpe_16 vddce_16 vss q1_16 q0_16
+  d0_16 td0_16 wen0_16 twen0_16 weny0_16 wen1_16 td1_16 d1_16
+  rf64x128botcap2x2_rpt
xleft_col_17 vnwp vpw weny1_17 twen1_17 vddpe_17 vddce_17 vss q1_17 q0_17
+  d0_17 td0_17 wen0_17 twen0_17 weny0_17 wen1_17 td1_17 d1_17
+  rf64x128botcap2x2_rpt
xleft_col_18 vnwp vpw weny1_18 twen1_18 vddpe_18 vddce_18 vss q1_18 q0_18
+  d0_18 td0_18 wen0_18 twen0_18 weny0_18 wen1_18 td1_18 d1_18
+  rf64x128botcap2x2_rpt
xleft_col_19 vnwp vpw weny1_19 twen1_19 vddpe_19 vddce_19 vss q1_19 q0_19
+  d0_19 td0_19 wen0_19 twen0_19 weny0_19 wen1_19 td1_19 d1_19
+  rf64x128botcap2x2_rpt
xleft_col_2 vnwp vpw weny1_2 twen1_2 vddpe_2 vddce_2 vss q1_2 q0_2 d0_2 td0_2
+  wen0_2 twen0_2 weny0_2 wen1_2 td1_2 d1_2 rf64x128botcap2x2_rpt
xleft_col_20 vnwp vpw weny1_20 twen1_20 vddpe_20 vddce_20 vss q1_20 q0_20
+  d0_20 td0_20 wen0_20 twen0_20 weny0_20 wen1_20 td1_20 d1_20
+  rf64x128botcap2x2_rpt
xleft_col_21 vnwp vpw weny1_21 twen1_21 vddpe_21 vddce_21 vss q1_21 q0_21
+  d0_21 td0_21 wen0_21 twen0_21 weny0_21 wen1_21 td1_21 d1_21
+  rf64x128botcap2x2_rpt
xleft_col_22 vnwp vpw weny1_22 twen1_22 vddpe_22 vddce_22 vss q1_22 q0_22
+  d0_22 td0_22 wen0_22 twen0_22 weny0_22 wen1_22 td1_22 d1_22
+  rf64x128botcap2x2_rpt
xleft_col_23 vnwp vpw weny1_23 twen1_23 vddpe_23 vddce_23 vss q1_23 q0_23
+  d0_23 td0_23 wen0_23 twen0_23 weny0_23 wen1_23 td1_23 d1_23
+  rf64x128botcap2x2_rpt
xleft_col_24 vnwp vpw weny1_24 twen1_24 vddpe_24 vddce_24 vss q1_24 q0_24
+  d0_24 td0_24 wen0_24 twen0_24 weny0_24 wen1_24 td1_24 d1_24
+  rf64x128botcap2x2_rpt
xleft_col_25 vnwp vpw weny1_25 twen1_25 vddpe_25 vddce_25 vss q1_25 q0_25
+  d0_25 td0_25 wen0_25 twen0_25 weny0_25 wen1_25 td1_25 d1_25
+  rf64x128botcap2x2_rpt
xleft_col_26 vnwp vpw weny1_26 twen1_26 vddpe_26 vddce_26 vss q1_26 q0_26
+  d0_26 td0_26 wen0_26 twen0_26 weny0_26 wen1_26 td1_26 d1_26
+  rf64x128botcap2x2_rpt
xleft_col_27 vnwp vpw weny1_27 twen1_27 vddpe_27 vddce_27 vss q1_27 q0_27
+  d0_27 td0_27 wen0_27 twen0_27 weny0_27 wen1_27 td1_27 d1_27
+  rf64x128botcap2x2_rpt
xleft_col_28 vnwp vpw weny1_28 twen1_28 vddpe_28 vddce_28 vss q1_28 q0_28
+  d0_28 td0_28 wen0_28 twen0_28 weny0_28 wen1_28 td1_28 d1_28
+  rf64x128botcap2x2_rpt
xleft_col_29 vnwp vpw weny1_29 twen1_29 vddpe_29 vddce_29 vss q1_29 q0_29
+  d0_29 td0_29 wen0_29 twen0_29 weny0_29 wen1_29 td1_29 d1_29
+  rf64x128botcap2x2_rpt
xleft_col_3 vnwp vpw weny1_3 twen1_3 vddpe_3 vddce_3 vss q1_3 q0_3 d0_3 td0_3
+  wen0_3 twen0_3 weny0_3 wen1_3 td1_3 d1_3 rf64x128botcap2x2_rpt
xleft_col_30 vnwp vpw weny1_30 twen1_30 vddpe_30 vddce_30 vss q1_30 q0_30
+  d0_30 td0_30 wen0_30 twen0_30 weny0_30 wen1_30 td1_30 d1_30
+  rf64x128botcap2x2_rpt
xleft_col_31 vnwp vpw weny1_31 twen1_31 vddpe_31 vddce_31 vss q1_31 q0_31
+  d0_31 td0_31 wen0_31 twen0_31 weny0_31 wen1_31 td1_31 d1_31
+  rf64x128botcap2x2_rpt
xleft_col_4 vnwp vpw weny1_4 twen1_4 vddpe_4 vddce_4 vss q1_4 q0_4 d0_4 td0_4
+  wen0_4 twen0_4 weny0_4 wen1_4 td1_4 d1_4 rf64x128botcap2x2_rpt
xleft_col_5 vnwp vpw weny1_5 twen1_5 vddpe_5 vddce_5 vss q1_5 q0_5 d0_5 td0_5
+  wen0_5 twen0_5 weny0_5 wen1_5 td1_5 d1_5 rf64x128botcap2x2_rpt
xleft_col_6 vnwp vpw weny1_6 twen1_6 vddpe_6 vddce_6 vss q1_6 q0_6 d0_6 td0_6
+  wen0_6 twen0_6 weny0_6 wen1_6 td1_6 d1_6 rf64x128botcap2x2_rpt
xleft_col_7 vnwp vpw weny1_7 twen1_7 vddpe_7 vddce_7 vss q1_7 q0_7 d0_7 td0_7
+  wen0_7 twen0_7 weny0_7 wen1_7 td1_7 d1_7 rf64x128botcap2x2_rpt
xleft_col_8 vnwp vpw weny1_8 twen1_8 vddpe_8 vddce_8 vss q1_8 q0_8 d0_8 td0_8
+  wen0_8 twen0_8 weny0_8 wen1_8 td1_8 d1_8 rf64x128botcap2x2_rpt
xleft_col_9 vnwp vpw weny1_9 twen1_9 vddpe_9 vddce_9 vss q1_9 q0_9 d0_9 td0_9
+  wen0_9 twen0_9 weny0_9 wen1_9 td1_9 d1_9 rf64x128botcap2x2_rpt
xright vnwc_2 vnwp vpw vss vsse_2 psi_1 si_1 rf64x128botcorner
xright_col_0 vnwp vpw weny1_32 twen1_32 vddpe_33 vddce_33 vss q1_32 q0_32
+  d0_32 td0_32 wen0_32 twen0_32 weny0_32 wen1_32 td1_32 d1_32
+  rf64x128botcap2x2_rpt
xright_col_1 vnwp vpw weny1_33 twen1_33 vddpe_34 vddce_34 vss q1_33 q0_33
+  d0_33 td0_33 wen0_33 twen0_33 weny0_33 wen1_33 td1_33 d1_33
+  rf64x128botcap2x2_rpt
xright_col_10 vnwp vpw weny1_42 twen1_42 vddpe_43 vddce_43 vss q1_42 q0_42
+  d0_42 td0_42 wen0_42 twen0_42 weny0_42 wen1_42 td1_42 d1_42
+  rf64x128botcap2x2_rpt
xright_col_11 vnwp vpw weny1_43 twen1_43 vddpe_44 vddce_44 vss q1_43 q0_43
+  d0_43 td0_43 wen0_43 twen0_43 weny0_43 wen1_43 td1_43 d1_43
+  rf64x128botcap2x2_rpt
xright_col_12 vnwp vpw weny1_44 twen1_44 vddpe_45 vddce_45 vss q1_44 q0_44
+  d0_44 td0_44 wen0_44 twen0_44 weny0_44 wen1_44 td1_44 d1_44
+  rf64x128botcap2x2_rpt
xright_col_13 vnwp vpw weny1_45 twen1_45 vddpe_46 vddce_46 vss q1_45 q0_45
+  d0_45 td0_45 wen0_45 twen0_45 weny0_45 wen1_45 td1_45 d1_45
+  rf64x128botcap2x2_rpt
xright_col_14 vnwp vpw weny1_46 twen1_46 vddpe_47 vddce_47 vss q1_46 q0_46
+  d0_46 td0_46 wen0_46 twen0_46 weny0_46 wen1_46 td1_46 d1_46
+  rf64x128botcap2x2_rpt
xright_col_15 vnwp vpw weny1_47 twen1_47 vddpe_48 vddce_48 vss q1_47 q0_47
+  d0_47 td0_47 wen0_47 twen0_47 weny0_47 wen1_47 td1_47 d1_47
+  rf64x128botcap2x2_rpt
xright_col_16 vnwp vpw weny1_48 twen1_48 vddpe_49 vddce_49 vss q1_48 q0_48
+  d0_48 td0_48 wen0_48 twen0_48 weny0_48 wen1_48 td1_48 d1_48
+  rf64x128botcap2x2_rpt
xright_col_17 vnwp vpw weny1_49 twen1_49 vddpe_50 vddce_50 vss q1_49 q0_49
+  d0_49 td0_49 wen0_49 twen0_49 weny0_49 wen1_49 td1_49 d1_49
+  rf64x128botcap2x2_rpt
xright_col_18 vnwp vpw weny1_50 twen1_50 vddpe_51 vddce_51 vss q1_50 q0_50
+  d0_50 td0_50 wen0_50 twen0_50 weny0_50 wen1_50 td1_50 d1_50
+  rf64x128botcap2x2_rpt
xright_col_19 vnwp vpw weny1_51 twen1_51 vddpe_52 vddce_52 vss q1_51 q0_51
+  d0_51 td0_51 wen0_51 twen0_51 weny0_51 wen1_51 td1_51 d1_51
+  rf64x128botcap2x2_rpt
xright_col_2 vnwp vpw weny1_34 twen1_34 vddpe_35 vddce_35 vss q1_34 q0_34
+  d0_34 td0_34 wen0_34 twen0_34 weny0_34 wen1_34 td1_34 d1_34
+  rf64x128botcap2x2_rpt
xright_col_20 vnwp vpw weny1_52 twen1_52 vddpe_53 vddce_53 vss q1_52 q0_52
+  d0_52 td0_52 wen0_52 twen0_52 weny0_52 wen1_52 td1_52 d1_52
+  rf64x128botcap2x2_rpt
xright_col_21 vnwp vpw weny1_53 twen1_53 vddpe_54 vddce_54 vss q1_53 q0_53
+  d0_53 td0_53 wen0_53 twen0_53 weny0_53 wen1_53 td1_53 d1_53
+  rf64x128botcap2x2_rpt
xright_col_22 vnwp vpw weny1_54 twen1_54 vddpe_55 vddce_55 vss q1_54 q0_54
+  d0_54 td0_54 wen0_54 twen0_54 weny0_54 wen1_54 td1_54 d1_54
+  rf64x128botcap2x2_rpt
xright_col_23 vnwp vpw weny1_55 twen1_55 vddpe_56 vddce_56 vss q1_55 q0_55
+  d0_55 td0_55 wen0_55 twen0_55 weny0_55 wen1_55 td1_55 d1_55
+  rf64x128botcap2x2_rpt
xright_col_24 vnwp vpw weny1_56 twen1_56 vddpe_57 vddce_57 vss q1_56 q0_56
+  d0_56 td0_56 wen0_56 twen0_56 weny0_56 wen1_56 td1_56 d1_56
+  rf64x128botcap2x2_rpt
xright_col_25 vnwp vpw weny1_57 twen1_57 vddpe_58 vddce_58 vss q1_57 q0_57
+  d0_57 td0_57 wen0_57 twen0_57 weny0_57 wen1_57 td1_57 d1_57
+  rf64x128botcap2x2_rpt
xright_col_26 vnwp vpw weny1_58 twen1_58 vddpe_59 vddce_59 vss q1_58 q0_58
+  d0_58 td0_58 wen0_58 twen0_58 weny0_58 wen1_58 td1_58 d1_58
+  rf64x128botcap2x2_rpt
xright_col_27 vnwp vpw weny1_59 twen1_59 vddpe_60 vddce_60 vss q1_59 q0_59
+  d0_59 td0_59 wen0_59 twen0_59 weny0_59 wen1_59 td1_59 d1_59
+  rf64x128botcap2x2_rpt
xright_col_28 vnwp vpw weny1_60 twen1_60 vddpe_61 vddce_61 vss q1_60 q0_60
+  d0_60 td0_60 wen0_60 twen0_60 weny0_60 wen1_60 td1_60 d1_60
+  rf64x128botcap2x2_rpt
xright_col_29 vnwp vpw weny1_61 twen1_61 vddpe_62 vddce_62 vss q1_61 q0_61
+  d0_61 td0_61 wen0_61 twen0_61 weny0_61 wen1_61 td1_61 d1_61
+  rf64x128botcap2x2_rpt
xright_col_3 vnwp vpw weny1_35 twen1_35 vddpe_36 vddce_36 vss q1_35 q0_35
+  d0_35 td0_35 wen0_35 twen0_35 weny0_35 wen1_35 td1_35 d1_35
+  rf64x128botcap2x2_rpt
xright_col_30 vnwp vpw weny1_62 twen1_62 vddpe_63 vddce_63 vss q1_62 q0_62
+  d0_62 td0_62 wen0_62 twen0_62 weny0_62 wen1_62 td1_62 d1_62
+  rf64x128botcap2x2_rpt
xright_col_31 vnwp vpw weny1_63 twen1_63 vddpe_64 vddce_64 vss q1_63 q0_63
+  d0_63 td0_63 wen0_63 twen0_63 weny0_63 wen1_63 td1_63 d1_63
+  rf64x128botcap2x2_rpt
xright_col_4 vnwp vpw weny1_36 twen1_36 vddpe_37 vddce_37 vss q1_36 q0_36
+  d0_36 td0_36 wen0_36 twen0_36 weny0_36 wen1_36 td1_36 d1_36
+  rf64x128botcap2x2_rpt
xright_col_5 vnwp vpw weny1_37 twen1_37 vddpe_38 vddce_38 vss q1_37 q0_37
+  d0_37 td0_37 wen0_37 twen0_37 weny0_37 wen1_37 td1_37 d1_37
+  rf64x128botcap2x2_rpt
xright_col_6 vnwp vpw weny1_38 twen1_38 vddpe_39 vddce_39 vss q1_38 q0_38
+  d0_38 td0_38 wen0_38 twen0_38 weny0_38 wen1_38 td1_38 d1_38
+  rf64x128botcap2x2_rpt
xright_col_7 vnwp vpw weny1_39 twen1_39 vddpe_40 vddce_40 vss q1_39 q0_39
+  d0_39 td0_39 wen0_39 twen0_39 weny0_39 wen1_39 td1_39 d1_39
+  rf64x128botcap2x2_rpt
xright_col_8 vnwp vpw weny1_40 twen1_40 vddpe_41 vddce_41 vss q1_40 q0_40
+  d0_40 td0_40 wen0_40 twen0_40 weny0_40 wen1_40 td1_40 d1_40
+  rf64x128botcap2x2_rpt
xright_col_9 vnwp vpw weny1_41 twen1_41 vddpe_42 vddce_42 vss q1_41 q0_41
+  d0_41 td0_41 wen0_41 twen0_41 weny0_41 wen1_41 td1_41 d1_41
+  rf64x128botcap2x2_rpt
.ends rf64x128botcaprow
****
.subckt rf64x128colm2x2_std_nbl_ast q0 q1 bl0 bl1 bl2 bl3 blprech cap_ctrl0
+  cap_ctrl1 cap_ctrl_bot0 cap_ctrl_bot1 d0 d1 dwl_main dwl_mainbreak dwl_turn
+  dwl_turnbreak iwclk0 iwclk1 log0 log0_sa nact_cc nbl0 nbl1 nbl2 nbl3 nsae
+  nyr0 nyr1 nyr2 nyr3 rdmux saprech vddc vddce vddp vddpe vnwp vpw vss vsse
+  wa_en wablm0 wen0 wen1 weny0_term weny1_term wtdft yw0 yw1 yw2 yw3
** rf64x128colm2x2_std_nbl_ast: 286 flat devices **
mi20.mxna1 nd0 d0 vss vpw nch_mac W=0.15U L=0.03U NF=1
mi20.mxpa1 nd0 d0 vddp vnwp pch_mac W=0.3U L=0.03U NF=1
mi46.mxna1 q1 sao1 vss vpw nch_mac W=1.5U L=0.03U NF=4
mi46.mxpa1 q1 sao1 vddpe vnwp pch_mac W=2.4U L=0.03U NF=4
mi47.mxna1 nd1 d1 vss vpw nch_mac W=0.15U L=0.03U NF=1
mi47.mxpa1 nd1 d1 vddp vnwp pch_mac W=0.3U L=0.03U NF=1
mi48.mxna1 nwen1 wen1 vss vpw nch_mac W=0.15U L=0.03U NF=1
mi48.mxpa1 nwen1 wen1 vddp vnwp pch_mac W=0.3U L=0.03U NF=1
mi52.mxn4_0 vss dwl_main vss vpw nch_mac W=0.27U L=0.03U NF=1
mi52.mxn4_1 vss dwl_main vss vpw nch_mac W=0.27U L=0.03U NF=1
mi55.mxna1 q0 sao0 vss vpw nch_mac W=1.5U L=0.03U NF=4
mi55.mxpa1 q0 sao0 vddpe vnwp pch_mac W=2.4U L=0.03U NF=4
mi58.mxna1 nwen0 wen0 vss vpw nch_mac W=0.15U L=0.03U NF=1
mi58.mxpa1 nwen0 wen0 vddp vnwp pch_mac W=0.3U L=0.03U NF=1
micd.i_add.mxna1 icd.net47 wtdft vss vpw nch_mac W=0.2U L=0.03U NF=1
micd.i_add.mxpa1 icd.net47 wtdft vddp vnwp pch_mac W=0.2U L=0.03U NF=1
micd.icdrw0._mx0.mxn0 nbl0 yw0 wrzero0 vpw nch_mac W=0.78U L=0.03U NF=2
micd.icdrw0._mx0.mxn1 bl0 yw0 wrone0 vpw nch_mac W=0.78U L=0.03U NF=2
micd.icdrw0._mx0.mxp1 nbl0 icd.nblprech vddp vnwp pch_mac W=0.5U L=0.03U NF=1
micd.icdrw0._mx0.mxp10 icd.icdrw0._mx0.vvdp nact_cc vddp vnwp pch_mac W=0.49U
+  L=0.03U NF=1
micd.icdrw0._mx0.mxp3 icd.nsd0 nyr0 nbl0 vnwp pch_mac W=0.45U L=0.035U NF=1
micd.icdrw0._mx0.mxp4 icd.sd0 nyr0 bl0 vnwp pch_mac W=0.45U L=0.035U NF=1
micd.icdrw0._mx0.mxp5 nbl0 bl0 icd.icdrw0._mx0.vvdp vnwp pch_mac W=0.28U
+  L=0.035U NF=1
micd.icdrw0._mx0.mxp7 bl0 icd.nblprech vddp vnwp pch_mac W=0.5U L=0.03U NF=1
micd.icdrw0._mx0.mxp8 nbl0 icd.nblprech bl0 vnwp pch_mac W=0.5U L=0.03U NF=1
micd.icdrw0._mx0.mxp9 bl0 nbl0 icd.icdrw0._mx0.vvdp vnwp pch_mac W=0.28U
+  L=0.035U NF=1
micd.icdrw0._mx1.mxn0 nbl1 yw1 wrzero0 vpw nch_mac W=0.78U L=0.03U NF=2
micd.icdrw0._mx1.mxn1 bl1 yw1 wrone0 vpw nch_mac W=0.78U L=0.03U NF=2
micd.icdrw0._mx1.mxp1 nbl1 icd.nblprech vddp vnwp pch_mac W=0.5U L=0.03U NF=1
micd.icdrw0._mx1.mxp10 icd.icdrw0._mx1.vvdp nact_cc vddp vnwp pch_mac W=0.49U
+  L=0.03U NF=1
micd.icdrw0._mx1.mxp3 icd.nsd0 nyr1 nbl1 vnwp pch_mac W=0.45U L=0.035U NF=1
micd.icdrw0._mx1.mxp4 icd.sd0 nyr1 bl1 vnwp pch_mac W=0.45U L=0.035U NF=1
micd.icdrw0._mx1.mxp5 nbl1 bl1 icd.icdrw0._mx1.vvdp vnwp pch_mac W=0.28U
+  L=0.035U NF=1
micd.icdrw0._mx1.mxp7 bl1 icd.nblprech vddp vnwp pch_mac W=0.5U L=0.03U NF=1
micd.icdrw0._mx1.mxp8 nbl1 icd.nblprech bl1 vnwp pch_mac W=0.5U L=0.03U NF=1
micd.icdrw0._mx1.mxp9 bl1 nbl1 icd.icdrw0._mx1.vvdp vnwp pch_mac W=0.28U
+  L=0.035U NF=1
micd.icdrw1._mx0.mxn0 nbl2 yw2 wrzero1 vpw nch_mac W=0.78U L=0.03U NF=2
micd.icdrw1._mx0.mxn1 bl2 yw2 wrone1 vpw nch_mac W=0.78U L=0.03U NF=2
micd.icdrw1._mx0.mxp1 nbl2 icd.nblprech vddp vnwp pch_mac W=0.5U L=0.03U NF=1
micd.icdrw1._mx0.mxp10 icd.icdrw1._mx0.vvdp nact_cc vddp vnwp pch_mac W=0.49U
+  L=0.03U NF=1
micd.icdrw1._mx0.mxp3 icd.nsd1 nyr2 nbl2 vnwp pch_mac W=0.45U L=0.035U NF=1
micd.icdrw1._mx0.mxp4 icd.sd1 nyr2 bl2 vnwp pch_mac W=0.45U L=0.035U NF=1
micd.icdrw1._mx0.mxp5 nbl2 bl2 icd.icdrw1._mx0.vvdp vnwp pch_mac W=0.28U
+  L=0.035U NF=1
micd.icdrw1._mx0.mxp7 bl2 icd.nblprech vddp vnwp pch_mac W=0.5U L=0.03U NF=1
micd.icdrw1._mx0.mxp8 nbl2 icd.nblprech bl2 vnwp pch_mac W=0.5U L=0.03U NF=1
micd.icdrw1._mx0.mxp9 bl2 nbl2 icd.icdrw1._mx0.vvdp vnwp pch_mac W=0.28U
+  L=0.035U NF=1
micd.icdrw1._mx1.mxn0 nbl3 yw3 wrzero1 vpw nch_mac W=0.78U L=0.03U NF=2
micd.icdrw1._mx1.mxn1 bl3 yw3 wrone1 vpw nch_mac W=0.78U L=0.03U NF=2
micd.icdrw1._mx1.mxp1 nbl3 icd.nblprech vddp vnwp pch_mac W=0.5U L=0.03U NF=1
micd.icdrw1._mx1.mxp10 icd.icdrw1._mx1.vvdp nact_cc vddp vnwp pch_mac W=0.49U
+  L=0.03U NF=1
micd.icdrw1._mx1.mxp3 icd.nsd1 nyr3 nbl3 vnwp pch_mac W=0.45U L=0.035U NF=1
micd.icdrw1._mx1.mxp4 icd.sd1 nyr3 bl3 vnwp pch_mac W=0.45U L=0.035U NF=1
micd.icdrw1._mx1.mxp5 nbl3 bl3 icd.icdrw1._mx1.vvdp vnwp pch_mac W=0.28U
+  L=0.035U NF=1
micd.icdrw1._mx1.mxp7 bl3 icd.nblprech vddp vnwp pch_mac W=0.5U L=0.03U NF=1
micd.icdrw1._mx1.mxp8 nbl3 icd.nblprech bl3 vnwp pch_mac W=0.5U L=0.03U NF=1
micd.icdrw1._mx1.mxp9 bl3 nbl3 icd.icdrw1._mx1.vvdp vnwp pch_mac W=0.28U
+  L=0.035U NF=1
micd.isa.isa0.mxn17 icd.nsd0 icd.sd0 icd.isa.saint0 vpw nch_mac W=1.68U
+  L=0.06U NF=2
micd.isa.isa0.mxn18 icd.isa.saint0 icd.sae vss vpw nch_mac W=0.84U L=0.035U
+  NF=1
micd.isa.isa0.mxn19 icd.sd0 icd.nsd0 icd.isa.saint0 vpw nch_mac W=1.68U
+  L=0.06U NF=2
micd.isa.isa0.mxp24 icd.nsd0 icd.isa.nsaprech vddp vnwp pch_mac W=0.28U
+  L=0.03U NF=1
micd.isa.isa0.mxp25 icd.nsd0 icd.isa.nsaprech icd.sd0 vnwp pch_mac W=0.28U
+  L=0.03U NF=2
micd.isa.isa0.mxp26 icd.sd0 icd.isa.nsaprech vddp vnwp pch_mac W=0.28U L=0.03U
+  NF=1
micd.isa.isa0.mxp27 icd.nsd0 icd.sd0 vddp vnwp pch_mac W=0.28U L=0.03U NF=1
micd.isa.isa0.mxp28 icd.sd0 icd.nsd0 vddp vnwp pch_mac W=0.28U L=0.03U NF=1
micd.isa.isa1.mxn17 icd.nsd1 icd.sd1 icd.isa.saint1 vpw nch_mac W=1.68U
+  L=0.06U NF=2
micd.isa.isa1.mxn18 icd.isa.saint1 icd.sae vss vpw nch_mac W=0.84U L=0.035U
+  NF=1
micd.isa.isa1.mxn19 icd.sd1 icd.nsd1 icd.isa.saint1 vpw nch_mac W=1.68U
+  L=0.06U NF=2
micd.isa.isa1.mxp24 icd.nsd1 icd.isa.nsaprech vddp vnwp pch_mac W=0.28U
+  L=0.03U NF=1
micd.isa.isa1.mxp25 icd.nsd1 icd.isa.nsaprech icd.sd1 vnwp pch_mac W=0.28U
+  L=0.03U NF=2
micd.isa.isa1.mxp26 icd.sd1 icd.isa.nsaprech vddp vnwp pch_mac W=0.28U L=0.03U
+  NF=1
micd.isa.isa1.mxp27 icd.nsd1 icd.sd1 vddp vnwp pch_mac W=0.28U L=0.03U NF=1
micd.isa.isa1.mxp28 icd.sd1 icd.nsd1 vddp vnwp pch_mac W=0.28U L=0.03U NF=1
micd.isa.mxn0 icd.isa.nsaprech saprech icd.isa.n1 vpw nch_mac W=0.27U L=0.03U
+  NF=1
micd.isa.mxn1 icd.isa.n1 nsae vss vpw nch_mac W=0.27U L=0.03U NF=1
micd.isa.mxn15 icd.sae nsae vss vpw nch_mac W=0.4U L=0.03U NF=2
micd.isa.mxp0 icd.isa.nsaprech saprech vddp vnwp pch_mac W=0.32U L=0.03U NF=1
micd.isa.mxp1 icd.isa.nsaprech nsae vddp vnwp pch_mac W=0.32U L=0.03U NF=1
micd.isa.mxp15 icd.sae nsae vddp vnwp pch_mac W=0.5U L=0.03U NF=2
micd.isasdl0.i68.mxna1 icd.isasdl0.iwclk_wt icd.net47 vss vpw nch_mac W=0.1U
+  L=0.03U NF=1
micd.isasdl0.i68.mxpa1 icd.isasdl0.iwclk_wt icd.net47 vddp vnwp pch_mac
+  W=0.15U L=0.03U NF=1
micd.isasdl0.i69.mxna1 icd.isasdl0.i69.n1 nd_wt0 vss vpw nch_mac W=0.27U
+  L=0.03U NF=1
micd.isasdl0.i69.mxnoe icd.isasdl0.sd_lat icd.isasdl0.iwclk_wt
+  icd.isasdl0.i69.n1 vpw nch_mac W=0.27U L=0.03U NF=1
micd.isasdl0.i69.mxpa1 icd.isasdl0.i69.p1 nd_wt0 vddp vnwp pch_mac W=0.48U
+  L=0.03U NF=1
micd.isasdl0.i69.mxpoen icd.isasdl0.sd_lat icd.net47 icd.isasdl0.i69.p1 vnwp
+  pch_mac W=0.48U L=0.03U NF=1
micd.isasdl0.i70.mxna1 icd.isasdl0.i70.n1 sao0 vss vpw nch_mac W=0.27U L=0.03U
+  NF=1
micd.isasdl0.i70.mxnoe icd.isasdl0.sd_lat icd.net47 icd.isasdl0.i70.n1 vpw
+  nch_mac W=0.27U L=0.03U NF=1
micd.isasdl0.i70.mxpa1 icd.isasdl0.i70.p1 sao0 vddp vnwp pch_mac W=0.48U
+  L=0.03U NF=1
micd.isasdl0.i70.mxpoen icd.isasdl0.sd_lat icd.isasdl0.iwclk_wt
+  icd.isasdl0.i70.p1 vnwp pch_mac W=0.48U L=0.03U NF=1
micd.isasdl0.mxn0 sao0 icd.nsd0 sao0 vpw nch_mac W=0.52U L=0.03U NF=2
micd.isasdl0.mxn3 icd.isasdl0.n1 icd.sae vss vpw nch_mac W=0.8U L=0.03U NF=2
micd.isasdl0.mxn9 icd.isasdl0.n1 icd.isasdl0.sd_lat vss vpw nch_mac W=0.45U
+  L=0.03U NF=1
micd.isasdl0.mxp4 sao0 icd.nsd0 sao0 vnwp pch_mac W=0.52U L=0.03U NF=2
micd.isasdl0.mxp5 sao0 icd.isasdl0.sd_lat icd.isasdl0.p1 vnwp pch_mac W=0.49U
+  L=0.03U NF=1
micd.isasdl0.mxp6 icd.isasdl0.p1 icd.sae vddp vnwp pch_mac W=0.49U L=0.03U
+  NF=1
micd.isasdl0.mx_sd_n sao0 icd.sd0 icd.isasdl0.n1 vpw nch_mac W=0.8U L=0.03U
+  NF=2
micd.isasdl0.mx_sd_p sao0 icd.sd0 vddp vnwp pch_mac W=0.98U L=0.03U NF=2
micd.isasdl1.i68.mxna1 icd.isasdl1.iwclk_wt icd.net47 vss vpw nch_mac W=0.1U
+  L=0.03U NF=1
micd.isasdl1.i68.mxpa1 icd.isasdl1.iwclk_wt icd.net47 vddp vnwp pch_mac
+  W=0.15U L=0.03U NF=1
micd.isasdl1.i69.mxna1 icd.isasdl1.i69.n1 nd_wt1 vss vpw nch_mac W=0.27U
+  L=0.03U NF=1
micd.isasdl1.i69.mxnoe icd.isasdl1.sd_lat icd.isasdl1.iwclk_wt
+  icd.isasdl1.i69.n1 vpw nch_mac W=0.27U L=0.03U NF=1
micd.isasdl1.i69.mxpa1 icd.isasdl1.i69.p1 nd_wt1 vddp vnwp pch_mac W=0.48U
+  L=0.03U NF=1
micd.isasdl1.i69.mxpoen icd.isasdl1.sd_lat icd.net47 icd.isasdl1.i69.p1 vnwp
+  pch_mac W=0.48U L=0.03U NF=1
micd.isasdl1.i70.mxna1 icd.isasdl1.i70.n1 sao1 vss vpw nch_mac W=0.27U L=0.03U
+  NF=1
micd.isasdl1.i70.mxnoe icd.isasdl1.sd_lat icd.net47 icd.isasdl1.i70.n1 vpw
+  nch_mac W=0.27U L=0.03U NF=1
micd.isasdl1.i70.mxpa1 icd.isasdl1.i70.p1 sao1 vddp vnwp pch_mac W=0.48U
+  L=0.03U NF=1
micd.isasdl1.i70.mxpoen icd.isasdl1.sd_lat icd.isasdl1.iwclk_wt
+  icd.isasdl1.i70.p1 vnwp pch_mac W=0.48U L=0.03U NF=1
micd.isasdl1.mxn0 sao1 icd.nsd1 sao1 vpw nch_mac W=0.52U L=0.03U NF=2
micd.isasdl1.mxn3 icd.isasdl1.n1 icd.sae vss vpw nch_mac W=0.8U L=0.03U NF=2
micd.isasdl1.mxn9 icd.isasdl1.n1 icd.isasdl1.sd_lat vss vpw nch_mac W=0.45U
+  L=0.03U NF=1
micd.isasdl1.mxp4 sao1 icd.nsd1 sao1 vnwp pch_mac W=0.52U L=0.03U NF=2
micd.isasdl1.mxp5 sao1 icd.isasdl1.sd_lat icd.isasdl1.p1 vnwp pch_mac W=0.49U
+  L=0.03U NF=1
micd.isasdl1.mxp6 icd.isasdl1.p1 icd.sae vddp vnwp pch_mac W=0.49U L=0.03U
+  NF=1
micd.isasdl1.mx_sd_n sao1 icd.sd1 icd.isasdl1.n1 vpw nch_mac W=0.8U L=0.03U
+  NF=2
micd.isasdl1.mx_sd_p sao1 icd.sd1 vddp vnwp pch_mac W=0.98U L=0.03U NF=2
micd.mxn15 icd.nblprech blprech vss vpw nch_mac W=0.34U L=0.035U NF=2
micd.mxp15 icd.nblprech blprech vddp vnwp pch_mac W=0.675U L=0.035U NF=4
miwr.i0.mxna1 iwr.iwrzero1 iwr.id_lat1 iwr.i0.n1 vpw nch_mac W=0.12U L=0.035U
+  NF=1
miwr.i0.mxna2 iwr.i0.n1 iwr.we_lat1 vss vpw nch_mac W=0.12U L=0.035U NF=1
miwr.i0.mxpa1 iwr.iwrzero1 iwr.id_lat1 vddp vnwp pch_mac W=0.12U L=0.035U NF=1
miwr.i0.mxpa2 iwr.iwrzero1 iwr.we_lat1 vddp vnwp pch_mac W=0.12U L=0.035U NF=1
miwr.i221.mxna1 nwclk iwclk0 vss vpw nch_mac W=0.8U L=0.03U NF=2
miwr.i221.mxpa1 nwclk iwclk0 vddp vnwp pch_mac W=1U L=0.03U NF=2
miwr.i224.mxna1 iwr.wclk nwclk vss vpw nch_mac W=0.55U L=0.03U NF=2
miwr.i224.mxpa1 iwr.wclk nwclk vddp vnwp pch_mac W=1.1U L=0.03U NF=2
miwr.i235.i48.mxnoe iwr.we_lat1 nwclk nwen1 vpw nch_mac W=0.14U L=0.035U NF=1
miwr.i235.i48.mxpoen iwr.we_lat1 iwr.wclk nwen1 vnwp pch_mac W=0.14U L=0.035U
+  NF=1
miwr.i235.i50.mxna1 wen_lat1 iwr.we_lat1 vss vpw nch_mac W=0.1U L=0.035U NF=1
miwr.i235.i50.mxpa1 wen_lat1 iwr.we_lat1 vddp vnwp pch_mac W=0.1U L=0.035U
+  NF=1
miwr.i235.i55.mxna1 iwr.i235.i55.n1 wen_lat1 vss vpw nch_mac W=0.1U L=0.035U
+  NF=1
miwr.i235.i55.mxnoe iwr.we_lat1 iwr.wclk iwr.i235.i55.n1 vpw nch_mac W=0.1U
+  L=0.035U NF=1
miwr.i235.i55.mxpa1 iwr.i235.i55.p1 wen_lat1 vddp vnwp pch_mac W=0.1U L=0.035U
+  NF=1
miwr.i235.i55.mxpoen iwr.we_lat1 nwclk iwr.i235.i55.p1 vnwp pch_mac W=0.1U
+  L=0.035U NF=1
miwr.i237.mxna1 nd_wt0 iwr.d_lat0 vss vpw nch_mac W=0.2U L=0.03U NF=1
miwr.i237.mxpa1 nd_wt0 iwr.d_lat0 vddp vnwp pch_mac W=0.2U L=0.03U NF=1
miwr.i238.mxna1 nd_wt1 iwr.d_lat1 vss vpw nch_mac W=0.2U L=0.03U NF=1
miwr.i238.mxpa1 nd_wt1 iwr.d_lat1 vddp vnwp pch_mac W=0.2U L=0.03U NF=1
miwr.i4.mxna1 iwr.iwrone0 iwr.ind_lat0 iwr.i4.n1 vpw nch_mac W=0.12U L=0.035U
+  NF=1
miwr.i4.mxna2 iwr.i4.n1 iwr.we_lat0 vss vpw nch_mac W=0.12U L=0.035U NF=1
miwr.i4.mxpa1 iwr.iwrone0 iwr.ind_lat0 vddp vnwp pch_mac W=0.12U L=0.035U NF=1
miwr.i4.mxpa2 iwr.iwrone0 iwr.we_lat0 vddp vnwp pch_mac W=0.12U L=0.035U NF=1
miwr.i6.mxna1 iwr.iwrzero0 iwr.id_lat0 iwr.i6.n1 vpw nch_mac W=0.12U L=0.035U
+  NF=1
miwr.i6.mxna2 iwr.i6.n1 iwr.we_lat0 vss vpw nch_mac W=0.12U L=0.035U NF=1
miwr.i6.mxpa1 iwr.iwrzero0 iwr.id_lat0 vddp vnwp pch_mac W=0.12U L=0.035U NF=1
miwr.i6.mxpa2 iwr.iwrzero0 iwr.we_lat0 vddp vnwp pch_mac W=0.12U L=0.035U NF=1
miwr.i7.mxna1 iwr.iwrone1 iwr.ind_lat1 iwr.i7.n1 vpw nch_mac W=0.12U L=0.035U
+  NF=1
miwr.i7.mxna2 iwr.i7.n1 iwr.we_lat1 vss vpw nch_mac W=0.12U L=0.035U NF=1
miwr.i7.mxpa1 iwr.iwrone1 iwr.ind_lat1 vddp vnwp pch_mac W=0.12U L=0.035U NF=1
miwr.i7.mxpa2 iwr.iwrone1 iwr.we_lat1 vddp vnwp pch_mac W=0.12U L=0.035U NF=1
miwr._dlat0.i48.mxnoe iwr.ind_lat0 nwclk nd0 vpw nch_mac W=0.14U L=0.035U NF=1
miwr._dlat0.i48.mxpoen iwr.ind_lat0 iwr.wclk nd0 vnwp pch_mac W=0.14U L=0.035U
+  NF=1
miwr._dlat0.i50.mxna1 iwr.id_lat0 iwr.ind_lat0 vss vpw nch_mac W=0.12U
+  L=0.035U NF=2
miwr._dlat0.i50.mxpa1 iwr.id_lat0 iwr.ind_lat0 vddp vnwp pch_mac W=0.15U
+  L=0.035U NF=2
miwr._dlat0.i55.mxna1 iwr._dlat0.i55.n1 iwr.id_lat0 vss vpw nch_mac W=0.1U
+  L=0.035U NF=1
miwr._dlat0.i55.mxnoe iwr.ind_lat0 iwr.wclk iwr._dlat0.i55.n1 vpw nch_mac
+  W=0.1U L=0.035U NF=1
miwr._dlat0.i55.mxpa1 iwr._dlat0.i55.p1 iwr.id_lat0 vddp vnwp pch_mac W=0.1U
+  L=0.035U NF=1
miwr._dlat0.i55.mxpoen iwr.ind_lat0 nwclk iwr._dlat0.i55.p1 vnwp pch_mac
+  W=0.1U L=0.035U NF=1
miwr._dlat1.i48.mxnoe iwr.ind_lat1 nwclk nd1 vpw nch_mac W=0.14U L=0.035U NF=1
miwr._dlat1.i48.mxpoen iwr.ind_lat1 iwr.wclk nd1 vnwp pch_mac W=0.14U L=0.035U
+  NF=1
miwr._dlat1.i50.mxna1 iwr.id_lat1 iwr.ind_lat1 vss vpw nch_mac W=0.12U
+  L=0.035U NF=2
miwr._dlat1.i50.mxpa1 iwr.id_lat1 iwr.ind_lat1 vddp vnwp pch_mac W=0.15U
+  L=0.035U NF=2
miwr._dlat1.i55.mxna1 iwr._dlat1.i55.n1 iwr.id_lat1 vss vpw nch_mac W=0.1U
+  L=0.035U NF=1
miwr._dlat1.i55.mxnoe iwr.ind_lat1 iwr.wclk iwr._dlat1.i55.n1 vpw nch_mac
+  W=0.1U L=0.035U NF=1
miwr._dlat1.i55.mxpa1 iwr._dlat1.i55.p1 iwr.id_lat1 vddp vnwp pch_mac W=0.1U
+  L=0.035U NF=1
miwr._dlat1.i55.mxpoen iwr.ind_lat1 nwclk iwr._dlat1.i55.p1 vnwp pch_mac
+  W=0.1U L=0.035U NF=1
miwr._solat0.i47.mxna1 iwr._solat0.nd iwr.id_lat0 vss vpw nch_mac W=0.2U
+  L=0.035U NF=1
miwr._solat0.i47.mxpa1 iwr._solat0.nd iwr.id_lat0 vddp vnwp pch_mac W=0.2U
+  L=0.035U NF=1
miwr._solat0.i48.mxnoe iwr.nd_latq0 iwr.wclk iwr._solat0.nd vpw nch_mac
+  W=0.14U L=0.035U NF=1
miwr._solat0.i48.mxpoen iwr.nd_latq0 nwclk iwr._solat0.nd vnwp pch_mac W=0.14U
+  L=0.035U NF=1
miwr._solat0.i50.mxna1 iwr.d_lat0 iwr.nd_latq0 vss vpw nch_mac W=0.2U L=0.035U
+  NF=1
miwr._solat0.i50.mxpa1 iwr.d_lat0 iwr.nd_latq0 vddp vnwp pch_mac W=0.2U
+  L=0.035U NF=1
miwr._solat0.i55.mxna1 iwr._solat0.i55.n1 iwr.d_lat0 vss vpw nch_mac W=0.1U
+  L=0.035U NF=1
miwr._solat0.i55.mxnoe iwr.nd_latq0 nwclk iwr._solat0.i55.n1 vpw nch_mac
+  W=0.1U L=0.035U NF=1
miwr._solat0.i55.mxpa1 iwr._solat0.i55.p1 iwr.d_lat0 vddp vnwp pch_mac W=0.1U
+  L=0.035U NF=1
miwr._solat0.i55.mxpoen iwr.nd_latq0 iwr.wclk iwr._solat0.i55.p1 vnwp pch_mac
+  W=0.1U L=0.035U NF=1
miwr._solat1.i47.mxna1 iwr._solat1.nd iwr.id_lat1 vss vpw nch_mac W=0.2U
+  L=0.035U NF=1
miwr._solat1.i47.mxpa1 iwr._solat1.nd iwr.id_lat1 vddp vnwp pch_mac W=0.2U
+  L=0.035U NF=1
miwr._solat1.i48.mxnoe iwr.nd_latq1 iwr.wclk iwr._solat1.nd vpw nch_mac
+  W=0.14U L=0.035U NF=1
miwr._solat1.i48.mxpoen iwr.nd_latq1 nwclk iwr._solat1.nd vnwp pch_mac W=0.14U
+  L=0.035U NF=1
miwr._solat1.i50.mxna1 iwr.d_lat1 iwr.nd_latq1 vss vpw nch_mac W=0.2U L=0.035U
+  NF=1
miwr._solat1.i50.mxpa1 iwr.d_lat1 iwr.nd_latq1 vddp vnwp pch_mac W=0.2U
+  L=0.035U NF=1
miwr._solat1.i55.mxna1 iwr._solat1.i55.n1 iwr.d_lat1 vss vpw nch_mac W=0.1U
+  L=0.035U NF=1
miwr._solat1.i55.mxnoe iwr.nd_latq1 nwclk iwr._solat1.i55.n1 vpw nch_mac
+  W=0.1U L=0.035U NF=1
miwr._solat1.i55.mxpa1 iwr._solat1.i55.p1 iwr.d_lat1 vddp vnwp pch_mac W=0.1U
+  L=0.035U NF=1
miwr._solat1.i55.mxpoen iwr.nd_latq1 iwr.wclk iwr._solat1.i55.p1 vnwp pch_mac
+  W=0.1U L=0.035U NF=1
miwr._tri0.mxn0 wrone0 wrpd0[1] vss vpw nch_mac W=2.08U L=0.035U NF=4
miwr._tri0.mxn1 wrzero0 wrpd0[0] vss vpw nch_mac W=2.08U L=0.035U NF=4
miwr._tri0.mxn3 nwrpu0[1] iwr.iwrone0 vss vpw nch_mac W=0.19U L=0.035U NF=1
miwr._tri0.mxn4 nwrpu0[0] iwr.iwrzero0 vss vpw nch_mac W=0.19U L=0.035U NF=1
miwr._tri0.mxn6 nwrpu0[0] nwclk vss vpw nch_mac W=0.19U L=0.035U NF=1
miwr._tri0.mxn7 nwrpu0[1] nwclk vss vpw nch_mac W=0.19U L=0.035U NF=1
miwr._tri0.mxp1 wrone0 iwr.wclk vddp vnwp pch_mac W=0.3U L=0.035U NF=1
miwr._tri0.mxp2 wrzero0 iwr.wclk vddp vnwp pch_mac W=0.3U L=0.035U NF=1
miwr._tri0.mxp4 iwr._tri0.p1 nwclk vddp vnwp pch_mac W=0.48U L=0.035U NF=1
miwr._tri0.mxp5 nwrpu0[0] iwr.iwrzero0 iwr._tri0.p1 vnwp pch_mac W=0.48U
+  L=0.035U NF=1
miwr._tri0.mxp6 nwrpu0[1] iwr.iwrone0 iwr._tri0.p1 vnwp pch_mac W=0.48U
+  L=0.035U NF=1
miwr._tri1.mxn0 wrone1 wrpd1[1] vss vpw nch_mac W=2.08U L=0.035U NF=4
miwr._tri1.mxn1 wrzero1 wrpd1[0] vss vpw nch_mac W=2.08U L=0.035U NF=4
miwr._tri1.mxn3 nwrpu1[1] iwr.iwrone1 vss vpw nch_mac W=0.19U L=0.035U NF=1
miwr._tri1.mxn4 nwrpu1[0] iwr.iwrzero1 vss vpw nch_mac W=0.19U L=0.035U NF=1
miwr._tri1.mxn6 nwrpu1[0] nwclk vss vpw nch_mac W=0.19U L=0.035U NF=1
miwr._tri1.mxn7 nwrpu1[1] nwclk vss vpw nch_mac W=0.19U L=0.035U NF=1
miwr._tri1.mxp1 wrone1 iwr.wclk vddp vnwp pch_mac W=0.3U L=0.035U NF=1
miwr._tri1.mxp2 wrzero1 iwr.wclk vddp vnwp pch_mac W=0.3U L=0.035U NF=1
miwr._tri1.mxp4 iwr._tri1.p1 nwclk vddp vnwp pch_mac W=0.48U L=0.035U NF=1
miwr._tri1.mxp5 nwrpu1[0] iwr.iwrzero1 iwr._tri1.p1 vnwp pch_mac W=0.48U
+  L=0.035U NF=1
miwr._tri1.mxp6 nwrpu1[1] iwr.iwrone1 iwr._tri1.p1 vnwp pch_mac W=0.48U
+  L=0.035U NF=1
miwr._wenlat.i48.mxnoe iwr.we_lat0 nwclk nwen0 vpw nch_mac W=0.14U L=0.035U
+  NF=1
miwr._wenlat.i48.mxpoen iwr.we_lat0 iwr.wclk nwen0 vnwp pch_mac W=0.14U
+  L=0.035U NF=1
miwr._wenlat.i50.mxna1 wen_lat0 iwr.we_lat0 vss vpw nch_mac W=0.1U L=0.035U
+  NF=1
miwr._wenlat.i50.mxpa1 wen_lat0 iwr.we_lat0 vddp vnwp pch_mac W=0.1U L=0.035U
+  NF=1
miwr._wenlat.i55.mxna1 iwr._wenlat.i55.n1 wen_lat0 vss vpw nch_mac W=0.1U
+  L=0.035U NF=1
miwr._wenlat.i55.mxnoe iwr.we_lat0 iwr.wclk iwr._wenlat.i55.n1 vpw nch_mac
+  W=0.1U L=0.035U NF=1
miwr._wenlat.i55.mxpa1 iwr._wenlat.i55.p1 wen_lat0 vddp vnwp pch_mac W=0.1U
+  L=0.035U NF=1
miwr._wenlat.i55.mxpoen iwr.we_lat0 nwclk iwr._wenlat.i55.p1 vnwp pch_mac
+  W=0.1U L=0.035U NF=1
m_nbl_ast0.i180.mxna1 _nbl_ast0.we_wclk nwclk vss vpw nch_mac W=0.2U L=0.035U
+  NF=1
m_nbl_ast0.i180.mxna2 _nbl_ast0.we_wclk wen_lat0 vss vpw nch_mac W=0.2U
+  L=0.035U NF=1
m_nbl_ast0.i180.mxpa1 _nbl_ast0.we_wclk nwclk _nbl_ast0.i180.p1 vnwp pch_mac
+  W=0.2U L=0.035U NF=1
m_nbl_ast0.i180.mxpa2 _nbl_ast0.i180.p1 wen_lat0 vddp vnwp pch_mac W=0.2U
+  L=0.035U NF=1
m_nbl_ast0.i28.mxna1 _nbl_ast0.net32 _nbl_ast0.net018 _nbl_ast0.i28.n1 vpw
+  nch_mac W=0.34U L=0.035U NF=1
m_nbl_ast0.i28.mxna2 _nbl_ast0.i28.n1 wablm0 vss vpw nch_mac W=0.34U L=0.035U
+  NF=1
m_nbl_ast0.i28.mxpa1 _nbl_ast0.net32 _nbl_ast0.net018 vddp vnwp pch_mac W=0.2U
+  L=0.035U NF=1
m_nbl_ast0.i28.mxpa2 _nbl_ast0.net32 wablm0 vddp vnwp pch_mac W=0.2U L=0.035U
+  NF=1
m_nbl_ast0.i29.mxn1 cap_ctrl_bot0 _nbl_ast0.net017 vss vpw nch_mac W=0.6U
+  L=0.035U NF=1
m_nbl_ast0.i29.mxna1 cap_ctrl0 _nbl_ast0.net017 cap_ctrl_bot0 vpw nch_mac
+  W=0.6U L=0.035U NF=1
m_nbl_ast0.i29.mxp0 cap_ctrl_bot0 _nbl_ast0.net017 vddp vnwp pch_mac W=0.42U
+  L=0.035U NF=1
m_nbl_ast0.i29.mxpa1 cap_ctrl0 _nbl_ast0.net017 vddp vnwp pch_mac W=0.42U
+  L=0.035U NF=1
m_nbl_ast0.i30.mxna1 _nbl_ast0.cap_ctrl1 _nbl_ast0.net32 vss vpw nch_mac
+  W=0.44U L=0.035U NF=1
m_nbl_ast0.i30.mxpa1 _nbl_ast0.cap_ctrl1 _nbl_ast0.net32 vddp vnwp pch_mac
+  W=0.3U L=0.035U NF=1
m_nbl_ast0.i32.mxna1 _nbl_ast0.net018 _nbl_ast0.nft_ctl vss vpw nch_mac
+  W=0.38U L=0.035U NF=1
m_nbl_ast0.i32.mxpa1 _nbl_ast0.net018 _nbl_ast0.nft_ctl vddp vnwp pch_mac
+  W=0.25U L=0.035U NF=1
m_nbl_ast0.i33.mxna1 _nbl_ast0.net017 _nbl_ast0.net018 vss vpw nch_mac W=0.15U
+  L=0.035U NF=1
m_nbl_ast0.i33.mxpa1 _nbl_ast0.net017 _nbl_ast0.net018 vddp vnwp pch_mac
+  W=0.28U L=0.035U NF=1
m_nbl_ast0.i74.mxna1 _nbl_ast0.nft_ctl _nbl_ast0.ft_ctl vss vpw nch_mac W=0.3U
+  L=0.035U NF=1
m_nbl_ast0.i74.mxpa1 _nbl_ast0.nft_ctl _nbl_ast0.ft_ctl vddp vnwp pch_mac
+  W=0.5U L=0.035U NF=1
m_nbl_ast0.i83.mxna1 _nbl_ast0.ft_ctl wa_en _nbl_ast0.i83.n1 vpw nch_mac
+  W=0.35U L=0.035U NF=1
m_nbl_ast0.i83.mxna2 _nbl_ast0.i83.n1 _nbl_ast0.we_wclk vss vpw nch_mac
+  W=0.35U L=0.035U NF=1
m_nbl_ast0.i83.mxpa1 _nbl_ast0.ft_ctl wa_en vddp vnwp pch_mac W=0.15U L=0.035U
+  NF=1
m_nbl_ast0.i83.mxpa2 _nbl_ast0.ft_ctl _nbl_ast0.we_wclk vddp vnwp pch_mac
+  W=0.15U L=0.035U NF=1
m_nbl_ast0._boost_cap.mxm0 wrpd0[0] _nbl_ast0.nft_ctl vss vpw nch_mac W=0.38U
+  L=0.035U NF=1
m_nbl_ast0._boost_cap.mxm1 wrpd0[1] _nbl_ast0.nft_ctl vss vpw nch_mac W=0.38U
+  L=0.035U NF=1
m_nbl_ast0._boost_cap.mxm11 _nbl_ast0.cap_ctrl1 _nbl_ast0._boost_cap.vss_ast
+  _nbl_ast0.cap_ctrl1 vnwp pch_mac W=13U L=0.035U NF=6
m_nbl_ast0._boost_cap.mxm12 nwrpu0[0] _nbl_ast0.ft_ctl wrpd0[0] vpw nch_mac
+  W=0.54U L=0.035U NF=1
m_nbl_ast0._boost_cap.mxm14 _nbl_ast0._boost_cap.vss_ast _nbl_ast0.ft_ctl vss
+  vpw nch_mac W=0.34U L=0.035U NF=1
m_nbl_ast0._boost_cap.mxm2 nwrpu0[0] _nbl_ast0.nft_ctl wrpd0[0] vnwp pch_mac
+  W=0.55U L=0.035U NF=1
m_nbl_ast0._boost_cap.mxm3 nwrpu0[1] _nbl_ast0.ft_ctl wrpd0[1] vpw nch_mac
+  W=0.54U L=0.035U NF=1
m_nbl_ast0._boost_cap.mxm4 wrzero0 nwrpu0[0] _nbl_ast0._boost_cap.vss_ast vpw
+  nch_mac W=0.65U L=0.035U NF=1
m_nbl_ast0._boost_cap.mxm5 nwrpu0[1] _nbl_ast0.nft_ctl wrpd0[1] vnwp pch_mac
+  W=0.55U L=0.035U NF=1
m_nbl_ast0._boost_cap.mxm6 wrone0 nwrpu0[1] _nbl_ast0._boost_cap.vss_ast vpw
+  nch_mac W=0.65U L=0.035U NF=1
m_nbl_ast0._boost_cap.mxm7 cap_ctrl0 _nbl_ast0._boost_cap.vss_ast cap_ctrl0
+  vnwp pch_mac W=9U L=0.035U NF=17
m_nbl_ast0._boost_cap.mxp0 cap_ctrl_bot0 _nbl_ast0._boost_cap.vss_ast
+  cap_ctrl_bot0 vnwp pch_mac W=7.2U L=0.035U NF=17
m_nbl_ast1.i180.mxna1 _nbl_ast1.we_wclk nwclk vss vpw nch_mac W=0.2U L=0.035U
+  NF=1
m_nbl_ast1.i180.mxna2 _nbl_ast1.we_wclk wen_lat1 vss vpw nch_mac W=0.2U
+  L=0.035U NF=1
m_nbl_ast1.i180.mxpa1 _nbl_ast1.we_wclk nwclk _nbl_ast1.i180.p1 vnwp pch_mac
+  W=0.2U L=0.035U NF=1
m_nbl_ast1.i180.mxpa2 _nbl_ast1.i180.p1 wen_lat1 vddp vnwp pch_mac W=0.2U
+  L=0.035U NF=1
m_nbl_ast1.i28.mxna1 _nbl_ast1.net32 _nbl_ast1.net018 _nbl_ast1.i28.n1 vpw
+  nch_mac W=0.34U L=0.035U NF=1
m_nbl_ast1.i28.mxna2 _nbl_ast1.i28.n1 wablm0 vss vpw nch_mac W=0.34U L=0.035U
+  NF=1
m_nbl_ast1.i28.mxpa1 _nbl_ast1.net32 _nbl_ast1.net018 vddp vnwp pch_mac W=0.2U
+  L=0.035U NF=1
m_nbl_ast1.i28.mxpa2 _nbl_ast1.net32 wablm0 vddp vnwp pch_mac W=0.2U L=0.035U
+  NF=1
m_nbl_ast1.i29.mxn1 cap_ctrl_bot1 _nbl_ast1.net017 vss vpw nch_mac W=0.6U
+  L=0.035U NF=1
m_nbl_ast1.i29.mxna1 cap_ctrl1 _nbl_ast1.net017 cap_ctrl_bot1 vpw nch_mac
+  W=0.6U L=0.035U NF=1
m_nbl_ast1.i29.mxp0 cap_ctrl_bot1 _nbl_ast1.net017 vddp vnwp pch_mac W=0.42U
+  L=0.035U NF=1
m_nbl_ast1.i29.mxpa1 cap_ctrl1 _nbl_ast1.net017 vddp vnwp pch_mac W=0.42U
+  L=0.035U NF=1
m_nbl_ast1.i30.mxna1 _nbl_ast1.cap_ctrl1 _nbl_ast1.net32 vss vpw nch_mac
+  W=0.44U L=0.035U NF=1
m_nbl_ast1.i30.mxpa1 _nbl_ast1.cap_ctrl1 _nbl_ast1.net32 vddp vnwp pch_mac
+  W=0.3U L=0.035U NF=1
m_nbl_ast1.i32.mxna1 _nbl_ast1.net018 _nbl_ast1.nft_ctl vss vpw nch_mac
+  W=0.38U L=0.035U NF=1
m_nbl_ast1.i32.mxpa1 _nbl_ast1.net018 _nbl_ast1.nft_ctl vddp vnwp pch_mac
+  W=0.25U L=0.035U NF=1
m_nbl_ast1.i33.mxna1 _nbl_ast1.net017 _nbl_ast1.net018 vss vpw nch_mac W=0.15U
+  L=0.035U NF=1
m_nbl_ast1.i33.mxpa1 _nbl_ast1.net017 _nbl_ast1.net018 vddp vnwp pch_mac
+  W=0.28U L=0.035U NF=1
m_nbl_ast1.i74.mxna1 _nbl_ast1.nft_ctl _nbl_ast1.ft_ctl vss vpw nch_mac W=0.3U
+  L=0.035U NF=1
m_nbl_ast1.i74.mxpa1 _nbl_ast1.nft_ctl _nbl_ast1.ft_ctl vddp vnwp pch_mac
+  W=0.5U L=0.035U NF=1
m_nbl_ast1.i83.mxna1 _nbl_ast1.ft_ctl wa_en _nbl_ast1.i83.n1 vpw nch_mac
+  W=0.35U L=0.035U NF=1
m_nbl_ast1.i83.mxna2 _nbl_ast1.i83.n1 _nbl_ast1.we_wclk vss vpw nch_mac
+  W=0.35U L=0.035U NF=1
m_nbl_ast1.i83.mxpa1 _nbl_ast1.ft_ctl wa_en vddp vnwp pch_mac W=0.15U L=0.035U
+  NF=1
m_nbl_ast1.i83.mxpa2 _nbl_ast1.ft_ctl _nbl_ast1.we_wclk vddp vnwp pch_mac
+  W=0.15U L=0.035U NF=1
m_nbl_ast1._boost_cap.mxm0 wrpd1[0] _nbl_ast1.nft_ctl vss vpw nch_mac W=0.38U
+  L=0.035U NF=1
m_nbl_ast1._boost_cap.mxm1 wrpd1[1] _nbl_ast1.nft_ctl vss vpw nch_mac W=0.38U
+  L=0.035U NF=1
m_nbl_ast1._boost_cap.mxm11 _nbl_ast1.cap_ctrl1 _nbl_ast1._boost_cap.vss_ast
+  _nbl_ast1.cap_ctrl1 vnwp pch_mac W=13U L=0.035U NF=6
m_nbl_ast1._boost_cap.mxm12 nwrpu1[0] _nbl_ast1.ft_ctl wrpd1[0] vpw nch_mac
+  W=0.54U L=0.035U NF=1
m_nbl_ast1._boost_cap.mxm14 _nbl_ast1._boost_cap.vss_ast _nbl_ast1.ft_ctl vss
+  vpw nch_mac W=0.34U L=0.035U NF=1
m_nbl_ast1._boost_cap.mxm2 nwrpu1[0] _nbl_ast1.nft_ctl wrpd1[0] vnwp pch_mac
+  W=0.55U L=0.035U NF=1
m_nbl_ast1._boost_cap.mxm3 nwrpu1[1] _nbl_ast1.ft_ctl wrpd1[1] vpw nch_mac
+  W=0.54U L=0.035U NF=1
m_nbl_ast1._boost_cap.mxm4 wrzero1 nwrpu1[0] _nbl_ast1._boost_cap.vss_ast vpw
+  nch_mac W=0.65U L=0.035U NF=1
m_nbl_ast1._boost_cap.mxm5 nwrpu1[1] _nbl_ast1.nft_ctl wrpd1[1] vnwp pch_mac
+  W=0.55U L=0.035U NF=1
m_nbl_ast1._boost_cap.mxm6 wrone1 nwrpu1[1] _nbl_ast1._boost_cap.vss_ast vpw
+  nch_mac W=0.65U L=0.035U NF=1
m_nbl_ast1._boost_cap.mxm7 cap_ctrl1 _nbl_ast1._boost_cap.vss_ast cap_ctrl1
+  vnwp pch_mac W=9U L=0.035U NF=17
m_nbl_ast1._boost_cap.mxp0 cap_ctrl_bot1 _nbl_ast1._boost_cap.vss_ast
+  cap_ctrl_bot1 vnwp pch_mac W=7.2U L=0.035U NF=17
.ends rf64x128colm2x2_std_nbl_ast
****
.subckt rf64x128iocdm_l bl0_31 nbl0_31 nbl1_31 bl1_31 vddc_31 bl2_31 nbl2_31
+  nbl3_31 bl3_31 bl0_30 nbl0_30 nbl1_30 bl1_30 vddc_30 bl2_30 nbl2_30 nbl3_30
+  bl3_30 bl0_29 nbl0_29 nbl1_29 bl1_29 vddc_29 bl2_29 nbl2_29 nbl3_29 bl3_29
+  bl0_28 nbl0_28 nbl1_28 bl1_28 vddc_28 bl2_28 nbl2_28 nbl3_28 bl3_28 bl0_27
+  nbl0_27 nbl1_27 bl1_27 vddc_27 bl2_27 nbl2_27 nbl3_27 bl3_27 bl0_26 nbl0_26
+  nbl1_26 bl1_26 vddc_26 bl2_26 nbl2_26 nbl3_26 bl3_26 bl0_25 nbl0_25 nbl1_25
+  bl1_25 vddc_25 bl2_25 nbl2_25 nbl3_25 bl3_25 bl0_24 nbl0_24 nbl1_24 bl1_24
+  vddc_24 bl2_24 nbl2_24 nbl3_24 bl3_24 bl0_23 nbl0_23 nbl1_23 bl1_23 vddc_23
+  bl2_23 nbl2_23 nbl3_23 bl3_23 bl0_22 nbl0_22 nbl1_22 bl1_22 vddc_22 bl2_22
+  nbl2_22 nbl3_22 bl3_22 bl0_21 nbl0_21 nbl1_21 bl1_21 vddc_21 bl2_21 nbl2_21
+  nbl3_21 bl3_21 bl0_20 nbl0_20 nbl1_20 bl1_20 vddc_20 bl2_20 nbl2_20 nbl3_20
+  bl3_20 bl0_19 nbl0_19 nbl1_19 bl1_19 vddc_19 bl2_19 nbl2_19 nbl3_19 bl3_19
+  bl0_18 nbl0_18 nbl1_18 bl1_18 vddc_18 bl2_18 nbl2_18 nbl3_18 bl3_18 bl0_17
+  nbl0_17 nbl1_17 bl1_17 vddc_17 bl2_17 nbl2_17 nbl3_17 bl3_17 bl0_16 nbl0_16
+  nbl1_16 bl1_16 vddc_16 bl2_16 nbl2_16 nbl3_16 bl3_16 bl0_15 nbl0_15 nbl1_15
+  bl1_15 vddc_15 bl2_15 nbl2_15 nbl3_15 bl3_15 bl0_14 nbl0_14 nbl1_14 bl1_14
+  vddc_14 bl2_14 nbl2_14 nbl3_14 bl3_14 bl0_13 nbl0_13 nbl1_13 bl1_13 vddc_13
+  bl2_13 nbl2_13 nbl3_13 bl3_13 bl0_12 nbl0_12 nbl1_12 bl1_12 vddc_12 bl2_12
+  nbl2_12 nbl3_12 bl3_12 bl0_11 nbl0_11 nbl1_11 bl1_11 vddc_11 bl2_11 nbl2_11
+  nbl3_11 bl3_11 bl0_10 nbl0_10 nbl1_10 bl1_10 vddc_10 bl2_10 nbl2_10 nbl3_10
+  bl3_10 bl0_9 nbl0_9 nbl1_9 bl1_9 vddc_9 bl2_9 nbl2_9 nbl3_9 bl3_9 bl0_8
+  nbl0_8 nbl1_8 bl1_8 vddc_8 bl2_8 nbl2_8 nbl3_8 bl3_8 bl0_7 nbl0_7 nbl1_7
+  bl1_7 vddc_7 bl2_7 nbl2_7 nbl3_7 bl3_7 bl0_6 nbl0_6 nbl1_6 bl1_6 vddc_6
+  bl2_6 nbl2_6 nbl3_6 bl3_6 bl0_5 nbl0_5 nbl1_5 bl1_5 vddc_5 bl2_5 nbl2_5
+  nbl3_5 bl3_5 bl0_4 nbl0_4 nbl1_4 bl1_4 vddc_4 bl2_4 nbl2_4 nbl3_4 bl3_4
+  bl0_3 nbl0_3 nbl1_3 bl1_3 vddc_3 bl2_3 nbl2_3 nbl3_3 bl3_3 bl0_2 nbl0_2
+  nbl1_2 bl1_2 vddc_2 bl2_2 nbl2_2 nbl3_2 bl3_2 bl0_1 nbl0_1 nbl1_1 bl1_1
+  vddc_1 bl2_1 nbl2_1 nbl3_1 bl3_1 bl0_0 nbl0_0 nbl1_0 bl1_0 vddce vddc_0
+  bl2_0 nbl2_0 nbl3_0 bl3_0 q0_31 d0_31 wen0_31 weny0_term_31 weny1_term_31
+  wen1_31 d1_31 q1_31 q0_30 d0_30 wen0_30 weny0_term_30 weny1_term_30 wen1_30
+  d1_30 q1_30 q0_29 d0_29 wen0_29 weny0_term_29 weny1_term_29 wen1_29 d1_29
+  q1_29 q0_28 d0_28 wen0_28 weny0_term_28 weny1_term_28 wen1_28 d1_28 q1_28
+  q0_27 d0_27 wen0_27 weny0_term_27 weny1_term_27 wen1_27 d1_27 q1_27 q0_26
+  d0_26 wen0_26 weny0_term_26 weny1_term_26 wen1_26 d1_26 q1_26 q0_25 d0_25
+  wen0_25 weny0_term_25 weny1_term_25 wen1_25 d1_25 q1_25 q0_24 d0_24 wen0_24
+  weny0_term_24 weny1_term_24 wen1_24 d1_24 q1_24 q0_23 d0_23 wen0_23
+  weny0_term_23 weny1_term_23 wen1_23 d1_23 q1_23 q0_22 d0_22 wen0_22
+  weny0_term_22 weny1_term_22 wen1_22 d1_22 q1_22 q0_21 d0_21 wen0_21
+  weny0_term_21 weny1_term_21 wen1_21 d1_21 q1_21 q0_20 d0_20 wen0_20
+  weny0_term_20 weny1_term_20 wen1_20 d1_20 q1_20 q0_19 d0_19 wen0_19
+  weny0_term_19 weny1_term_19 wen1_19 d1_19 q1_19 q0_18 d0_18 wen0_18
+  weny0_term_18 weny1_term_18 wen1_18 d1_18 q1_18 q0_17 d0_17 vpw wen0_17
+  weny0_term_17 weny1_term_17 wen1_17 d1_17 q1_17 q0_16 d0_16 wen0_16
+  weny0_term_16 weny1_term_16 wen1_16 d1_16 q1_16 q0_15 d0_15 wen0_15
+  weny0_term_15 weny1_term_15 wen1_15 d1_15 q1_15 q0_14 d0_14 wen0_14
+  weny0_term_14 weny1_term_14 wen1_14 d1_14 q1_14 q0_13 d0_13 wen0_13
+  weny0_term_13 weny1_term_13 wen1_13 d1_13 q1_13 q0_12 d0_12 wen0_12
+  weny0_term_12 weny1_term_12 wen1_12 d1_12 q1_12 q0_11 d0_11 wen0_11
+  weny0_term_11 weny1_term_11 wen1_11 d1_11 q1_11 q0_10 d0_10 wen0_10
+  weny0_term_10 weny1_term_10 wen1_10 d1_10 q1_10 q0_9 d0_9 wen0_9
+  weny0_term_9 weny1_term_9 wen1_9 d1_9 q1_9 q0_8 d0_8 wen0_8 weny0_term_8
+  weny1_term_8 wen1_8 d1_8 q1_8 q0_7 d0_7 wen0_7 weny0_term_7 weny1_term_7
+  wen1_7 d1_7 q1_7 q0_6 d0_6 wen0_6 weny0_term_6 weny1_term_6 wen1_6 d1_6
+  q1_6 q0_5 d0_5 wen0_5 weny0_term_5 weny1_term_5 wen1_5 d1_5 q1_5 q0_4 d0_4
+  wen0_4 weny0_term_4 weny1_term_4 wen1_4 d1_4 q1_4 q0_3 d0_3 wen0_3
+  weny0_term_3 weny1_term_3 wen1_3 d1_3 q1_3 q0_2 d0_2 wen0_2 weny0_term_2
+  weny1_term_2 wen1_2 d1_2 q1_2 q0_1 d0_1 wen0_1 weny0_term_1 weny1_term_1
+  wen1_1 d1_1 q1_1 q0_0 d0_0 wen0_0 weny0_term_0 weny1_term_0 wen1_0 d1_0
+  vddp q1_0 yw3 yw2 nyr3 nyr2 wtdft log0 dwl_mainbreak wablm0 wa_en blprech
+  nact_cc yw1 yw0 nyr1 nyr0 rdmux nsae saprech log0_sa iwclk0 iwclk1 dwl_main
+  dwl_turn
** rf64x128iocdm_l: 9152 flat devices **
xl_io_1 q0_1 q1_1 bl0_1 bl1_1 bl2_1 bl3_1 blprech cap_ctrl0_86 cap_ctrl1_88
+  cap_ctrl0_86 cap_ctrl1_88 d0_1 d1_1 dwl_main dwl_main dwl_turn dwl_turn
+  iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_1 nbl1_1 nbl2_1 nbl3_1 nsae nyr0
+  nyr1 nyr2 nyr3 rdmux saprech vddc_1 vddce vddp vddp vddp vpw vpw vpw wa_en
+  wablm0 wen0_1 wen1_1 weny0_term_1 weny1_term_1 wtdft yw0 yw1 yw2 yw3
+  rf64x128colm2x2_std_nbl_ast
xl_io_10 q0_10 q1_10 bl0_10 bl1_10 bl2_10 bl3_10 blprech cap_ctrl0 cap_ctrl1
+  cap_ctrl0 cap_ctrl1 d0_10 d1_10 dwl_main dwl_main dwl_turn dwl_turn iwclk0
+  iwclk1 log0 log0_sa nact_cc nbl0_10 nbl1_10 nbl2_10 nbl3_10 nsae nyr0 nyr1
+  nyr2 nyr3 rdmux saprech vddc_10 vddce vddp vddp vddp vpw vpw vpw wa_en
+  wablm0 wen0_10 wen1_10 weny0_term_10 weny1_term_10 wtdft yw0 yw1 yw2 yw3
+  rf64x128colm2x2_std_nbl_ast
xl_io_11 q0_11 q1_11 bl0_11 bl1_11 bl2_11 bl3_11 blprech cap_ctrl0_2
+  cap_ctrl1_4 cap_ctrl0_2 cap_ctrl1_4 d0_11 d1_11 dwl_main dwl_main dwl_turn
+  dwl_turn iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_11 nbl1_11 nbl2_11 nbl3_11
+  nsae nyr0 nyr1 nyr2 nyr3 rdmux saprech vddc_11 vddce vddp vddp vddp vpw vpw
+  vpw wa_en wablm0 wen0_11 wen1_11 weny0_term_11 weny1_term_11 wtdft yw0 yw1
+  yw2 yw3 rf64x128colm2x2_std_nbl_ast
xl_io_12 q0_12 q1_12 bl0_12 bl1_12 bl2_12 bl3_12 blprech cap_ctrl0_10
+  cap_ctrl1_12 cap_ctrl0_10 cap_ctrl1_12 d0_12 d1_12 dwl_main dwl_main
+  dwl_turn dwl_turn iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_12 nbl1_12
+  nbl2_12 nbl3_12 nsae nyr0 nyr1 nyr2 nyr3 rdmux saprech vddc_12 vddce vddp
+  vddp vddp vpw vpw vpw wa_en wablm0 wen0_12 wen1_12 weny0_term_12
+  weny1_term_12 wtdft yw0 yw1 yw2 yw3 rf64x128colm2x2_std_nbl_ast
xl_io_13 q0_13 q1_13 bl0_13 bl1_13 bl2_13 bl3_13 blprech cap_ctrl0_14
+  cap_ctrl1_16 cap_ctrl0_14 cap_ctrl1_16 d0_13 d1_13 dwl_main dwl_main
+  dwl_turn dwl_turn iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_13 nbl1_13
+  nbl2_13 nbl3_13 nsae nyr0 nyr1 nyr2 nyr3 rdmux saprech vddc_13 vddce vddp
+  vddp vddp vpw vpw vpw wa_en wablm0 wen0_13 wen1_13 weny0_term_13
+  weny1_term_13 wtdft yw0 yw1 yw2 yw3 rf64x128colm2x2_std_nbl_ast
xl_io_14 q0_14 q1_14 bl0_14 bl1_14 bl2_14 bl3_14 blprech cap_ctrl0_18
+  cap_ctrl1_20 cap_ctrl0_18 cap_ctrl1_20 d0_14 d1_14 dwl_main dwl_main
+  dwl_turn dwl_turn iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_14 nbl1_14
+  nbl2_14 nbl3_14 nsae nyr0 nyr1 nyr2 nyr3 rdmux saprech vddc_14 vddce vddp
+  vddp vddp vpw vpw vpw wa_en wablm0 wen0_14 wen1_14 weny0_term_14
+  weny1_term_14 wtdft yw0 yw1 yw2 yw3 rf64x128colm2x2_std_nbl_ast
xl_io_15 q0_15 q1_15 bl0_15 bl1_15 bl2_15 bl3_15 blprech cap_ctrl0_22
+  cap_ctrl1_24 cap_ctrl0_22 cap_ctrl1_24 d0_15 d1_15 dwl_main dwl_mainbreak
+  dwl_turn dwl_mainbreak iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_15 nbl1_15
+  nbl2_15 nbl3_15 nsae nyr0 nyr1 nyr2 nyr3 rdmux saprech vddc_15 vddce vddp
+  vddp vddp vpw vpw vpw wa_en wablm0 wen0_15 wen1_15 weny0_term_15
+  weny1_term_15 wtdft yw0 yw1 yw2 yw3 rf64x128colm2x2_std_nbl_ast
xl_io_16 q0_16 q1_16 bl0_16 bl1_16 bl2_16 bl3_16 blprech cap_ctrl0_26
+  cap_ctrl1_28 cap_ctrl0_26 cap_ctrl1_28 d0_16 d1_16 dwl_mainbreak
+  dwl_mainbreak dwl_mainbreak dwl_mainbreak iwclk0 iwclk1 log0 log0_sa
+  nact_cc nbl0_16 nbl1_16 nbl2_16 nbl3_16 nsae nyr0 nyr1 nyr2 nyr3 rdmux
+  saprech vddc_16 vddce vddp vddp vddp vpw vpw vpw wa_en wablm0 wen0_16
+  wen1_16 weny0_term_16 weny1_term_16 wtdft yw0 yw1 yw2 yw3
+  rf64x128colm2x2_std_nbl_ast
xl_io_17 q0_17 q1_17 bl0_17 bl1_17 bl2_17 bl3_17 blprech cap_ctrl0_30
+  cap_ctrl1_32 cap_ctrl0_30 cap_ctrl1_32 d0_17 d1_17 dwl_mainbreak
+  dwl_mainbreak dwl_mainbreak dwl_mainbreak iwclk0 iwclk1 log0 log0_sa
+  nact_cc nbl0_17 nbl1_17 nbl2_17 nbl3_17 nsae nyr0 nyr1 nyr2 nyr3 rdmux
+  saprech vddc_17 vddce vddp vddp vddp vpw vpw vpw wa_en wablm0 wen0_17
+  wen1_17 weny0_term_17 weny1_term_17 wtdft yw0 yw1 yw2 yw3
+  rf64x128colm2x2_std_nbl_ast
xl_io_18 q0_18 q1_18 bl0_18 bl1_18 bl2_18 bl3_18 blprech cap_ctrl0_34
+  cap_ctrl1_36 cap_ctrl0_34 cap_ctrl1_36 d0_18 d1_18 dwl_mainbreak
+  dwl_mainbreak dwl_mainbreak dwl_mainbreak iwclk0 iwclk1 log0 log0_sa
+  nact_cc nbl0_18 nbl1_18 nbl2_18 nbl3_18 nsae nyr0 nyr1 nyr2 nyr3 rdmux
+  saprech vddc_18 vddce vddp vddp vddp vpw vpw vpw wa_en wablm0 wen0_18
+  wen1_18 weny0_term_18 weny1_term_18 wtdft yw0 yw1 yw2 yw3
+  rf64x128colm2x2_std_nbl_ast
xl_io_19 q0_19 q1_19 bl0_19 bl1_19 bl2_19 bl3_19 blprech cap_ctrl0_38
+  cap_ctrl1_40 cap_ctrl0_38 cap_ctrl1_40 d0_19 d1_19 dwl_mainbreak
+  dwl_mainbreak dwl_mainbreak dwl_mainbreak iwclk0 iwclk1 log0 log0_sa
+  nact_cc nbl0_19 nbl1_19 nbl2_19 nbl3_19 nsae nyr0 nyr1 nyr2 nyr3 rdmux
+  saprech vddc_19 vddce vddp vddp vddp vpw vpw vpw wa_en wablm0 wen0_19
+  wen1_19 weny0_term_19 weny1_term_19 wtdft yw0 yw1 yw2 yw3
+  rf64x128colm2x2_std_nbl_ast
xl_io_2 q0_2 q1_2 bl0_2 bl1_2 bl2_2 bl3_2 blprech cap_ctrl0_94 cap_ctrl1_96
+  cap_ctrl0_94 cap_ctrl1_96 d0_2 d1_2 dwl_main dwl_main dwl_turn dwl_turn
+  iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_2 nbl1_2 nbl2_2 nbl3_2 nsae nyr0
+  nyr1 nyr2 nyr3 rdmux saprech vddc_2 vddce vddp vddp vddp vpw vpw vpw wa_en
+  wablm0 wen0_2 wen1_2 weny0_term_2 weny1_term_2 wtdft yw0 yw1 yw2 yw3
+  rf64x128colm2x2_std_nbl_ast
xl_io_20 q0_20 q1_20 bl0_20 bl1_20 bl2_20 bl3_20 blprech cap_ctrl0_42
+  cap_ctrl1_44 cap_ctrl0_42 cap_ctrl1_44 d0_20 d1_20 dwl_mainbreak
+  dwl_mainbreak dwl_mainbreak dwl_mainbreak iwclk0 iwclk1 log0 log0_sa
+  nact_cc nbl0_20 nbl1_20 nbl2_20 nbl3_20 nsae nyr0 nyr1 nyr2 nyr3 rdmux
+  saprech vddc_20 vddce vddp vddp vddp vpw vpw vpw wa_en wablm0 wen0_20
+  wen1_20 weny0_term_20 weny1_term_20 wtdft yw0 yw1 yw2 yw3
+  rf64x128colm2x2_std_nbl_ast
xl_io_21 q0_21 q1_21 bl0_21 bl1_21 bl2_21 bl3_21 blprech cap_ctrl0_46
+  cap_ctrl1_48 cap_ctrl0_46 cap_ctrl1_48 d0_21 d1_21 dwl_mainbreak
+  dwl_mainbreak dwl_mainbreak dwl_mainbreak iwclk0 iwclk1 log0 log0_sa
+  nact_cc nbl0_21 nbl1_21 nbl2_21 nbl3_21 nsae nyr0 nyr1 nyr2 nyr3 rdmux
+  saprech vddc_21 vddce vddp vddp vddp vpw vpw vpw wa_en wablm0 wen0_21
+  wen1_21 weny0_term_21 weny1_term_21 wtdft yw0 yw1 yw2 yw3
+  rf64x128colm2x2_std_nbl_ast
xl_io_22 q0_22 q1_22 bl0_22 bl1_22 bl2_22 bl3_22 blprech cap_ctrl0_50
+  cap_ctrl1_52 cap_ctrl0_50 cap_ctrl1_52 d0_22 d1_22 dwl_mainbreak
+  dwl_mainbreak dwl_mainbreak dwl_mainbreak iwclk0 iwclk1 log0 log0_sa
+  nact_cc nbl0_22 nbl1_22 nbl2_22 nbl3_22 nsae nyr0 nyr1 nyr2 nyr3 rdmux
+  saprech vddc_22 vddce vddp vddp vddp vpw vpw vpw wa_en wablm0 wen0_22
+  wen1_22 weny0_term_22 weny1_term_22 wtdft yw0 yw1 yw2 yw3
+  rf64x128colm2x2_std_nbl_ast
xl_io_23 q0_23 q1_23 bl0_23 bl1_23 bl2_23 bl3_23 blprech cap_ctrl0_54
+  cap_ctrl1_56 cap_ctrl0_54 cap_ctrl1_56 d0_23 d1_23 dwl_mainbreak
+  dwl_mainbreak dwl_mainbreak dwl_mainbreak iwclk0 iwclk1 log0 log0_sa
+  nact_cc nbl0_23 nbl1_23 nbl2_23 nbl3_23 nsae nyr0 nyr1 nyr2 nyr3 rdmux
+  saprech vddc_23 vddce vddp vddp vddp vpw vpw vpw wa_en wablm0 wen0_23
+  wen1_23 weny0_term_23 weny1_term_23 wtdft yw0 yw1 yw2 yw3
+  rf64x128colm2x2_std_nbl_ast
xl_io_24 q0_24 q1_24 bl0_24 bl1_24 bl2_24 bl3_24 blprech cap_ctrl0_58
+  cap_ctrl1_60 cap_ctrl0_58 cap_ctrl1_60 d0_24 d1_24 dwl_mainbreak
+  dwl_mainbreak dwl_mainbreak dwl_mainbreak iwclk0 iwclk1 log0 log0_sa
+  nact_cc nbl0_24 nbl1_24 nbl2_24 nbl3_24 nsae nyr0 nyr1 nyr2 nyr3 rdmux
+  saprech vddc_24 vddce vddp vddp vddp vpw vpw vpw wa_en wablm0 wen0_24
+  wen1_24 weny0_term_24 weny1_term_24 wtdft yw0 yw1 yw2 yw3
+  rf64x128colm2x2_std_nbl_ast
xl_io_25 q0_25 q1_25 bl0_25 bl1_25 bl2_25 bl3_25 blprech cap_ctrl0_62
+  cap_ctrl1_64 cap_ctrl0_62 cap_ctrl1_64 d0_25 d1_25 dwl_mainbreak
+  dwl_mainbreak dwl_mainbreak dwl_mainbreak iwclk0 iwclk1 log0 log0_sa
+  nact_cc nbl0_25 nbl1_25 nbl2_25 nbl3_25 nsae nyr0 nyr1 nyr2 nyr3 rdmux
+  saprech vddc_25 vddce vddp vddp vddp vpw vpw vpw wa_en wablm0 wen0_25
+  wen1_25 weny0_term_25 weny1_term_25 wtdft yw0 yw1 yw2 yw3
+  rf64x128colm2x2_std_nbl_ast
xl_io_26 q0_26 q1_26 bl0_26 bl1_26 bl2_26 bl3_26 blprech cap_ctrl0_66
+  cap_ctrl1_68 cap_ctrl0_66 cap_ctrl1_68 d0_26 d1_26 dwl_mainbreak
+  dwl_mainbreak dwl_mainbreak dwl_mainbreak iwclk0 iwclk1 log0 log0_sa
+  nact_cc nbl0_26 nbl1_26 nbl2_26 nbl3_26 nsae nyr0 nyr1 nyr2 nyr3 rdmux
+  saprech vddc_26 vddce vddp vddp vddp vpw vpw vpw wa_en wablm0 wen0_26
+  wen1_26 weny0_term_26 weny1_term_26 wtdft yw0 yw1 yw2 yw3
+  rf64x128colm2x2_std_nbl_ast
xl_io_27 q0_27 q1_27 bl0_27 bl1_27 bl2_27 bl3_27 blprech cap_ctrl0_70
+  cap_ctrl1_72 cap_ctrl0_70 cap_ctrl1_72 d0_27 d1_27 dwl_mainbreak
+  dwl_mainbreak dwl_mainbreak dwl_mainbreak iwclk0 iwclk1 log0 log0_sa
+  nact_cc nbl0_27 nbl1_27 nbl2_27 nbl3_27 nsae nyr0 nyr1 nyr2 nyr3 rdmux
+  saprech vddc_27 vddce vddp vddp vddp vpw vpw vpw wa_en wablm0 wen0_27
+  wen1_27 weny0_term_27 weny1_term_27 wtdft yw0 yw1 yw2 yw3
+  rf64x128colm2x2_std_nbl_ast
xl_io_28 q0_28 q1_28 bl0_28 bl1_28 bl2_28 bl3_28 blprech cap_ctrl0_74
+  cap_ctrl1_76 cap_ctrl0_74 cap_ctrl1_76 d0_28 d1_28 dwl_mainbreak
+  dwl_mainbreak dwl_mainbreak dwl_mainbreak iwclk0 iwclk1 log0 log0_sa
+  nact_cc nbl0_28 nbl1_28 nbl2_28 nbl3_28 nsae nyr0 nyr1 nyr2 nyr3 rdmux
+  saprech vddc_28 vddce vddp vddp vddp vpw vpw vpw wa_en wablm0 wen0_28
+  wen1_28 weny0_term_28 weny1_term_28 wtdft yw0 yw1 yw2 yw3
+  rf64x128colm2x2_std_nbl_ast
xl_io_29 q0_29 q1_29 bl0_29 bl1_29 bl2_29 bl3_29 blprech cap_ctrl0_78
+  cap_ctrl1_80 cap_ctrl0_78 cap_ctrl1_80 d0_29 d1_29 dwl_mainbreak
+  dwl_mainbreak dwl_mainbreak dwl_mainbreak iwclk0 iwclk1 log0 log0_sa
+  nact_cc nbl0_29 nbl1_29 nbl2_29 nbl3_29 nsae nyr0 nyr1 nyr2 nyr3 rdmux
+  saprech vddc_29 vddce vddp vddp vddp vpw vpw vpw wa_en wablm0 wen0_29
+  wen1_29 weny0_term_29 weny1_term_29 wtdft yw0 yw1 yw2 yw3
+  rf64x128colm2x2_std_nbl_ast
xl_io_3 q0_3 q1_3 bl0_3 bl1_3 bl2_3 bl3_3 blprech cap_ctrl0_98 cap_ctrl1_100
+  cap_ctrl0_98 cap_ctrl1_100 d0_3 d1_3 dwl_main dwl_main dwl_turn dwl_turn
+  iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_3 nbl1_3 nbl2_3 nbl3_3 nsae nyr0
+  nyr1 nyr2 nyr3 rdmux saprech vddc_3 vddce vddp vddp vddp vpw vpw vpw wa_en
+  wablm0 wen0_3 wen1_3 weny0_term_3 weny1_term_3 wtdft yw0 yw1 yw2 yw3
+  rf64x128colm2x2_std_nbl_ast
xl_io_30 q0_30 q1_30 bl0_30 bl1_30 bl2_30 bl3_30 blprech cap_ctrl0_6
+  cap_ctrl1_8 cap_ctrl0_6 cap_ctrl1_8 d0_30 d1_30 dwl_mainbreak dwl_mainbreak
+  dwl_mainbreak dwl_mainbreak iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_30
+  nbl1_30 nbl2_30 nbl3_30 nsae nyr0 nyr1 nyr2 nyr3 rdmux saprech vddc_30
+  vddce vddp vddp vddp vpw vpw vpw wa_en wablm0 wen0_30 wen1_30 weny0_term_30
+  weny1_term_30 wtdft yw0 yw1 yw2 yw3 rf64x128colm2x2_std_nbl_ast
xl_io_4 q0_4 q1_4 bl0_4 bl1_4 bl2_4 bl3_4 blprech cap_ctrl0_102 cap_ctrl1_104
+  cap_ctrl0_102 cap_ctrl1_104 d0_4 d1_4 dwl_main dwl_main dwl_turn dwl_turn
+  iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_4 nbl1_4 nbl2_4 nbl3_4 nsae nyr0
+  nyr1 nyr2 nyr3 rdmux saprech vddc_4 vddce vddp vddp vddp vpw vpw vpw wa_en
+  wablm0 wen0_4 wen1_4 weny0_term_4 weny1_term_4 wtdft yw0 yw1 yw2 yw3
+  rf64x128colm2x2_std_nbl_ast
xl_io_5 q0_5 q1_5 bl0_5 bl1_5 bl2_5 bl3_5 blprech cap_ctrl0_106 cap_ctrl1_108
+  cap_ctrl0_106 cap_ctrl1_108 d0_5 d1_5 dwl_main dwl_main dwl_turn dwl_turn
+  iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_5 nbl1_5 nbl2_5 nbl3_5 nsae nyr0
+  nyr1 nyr2 nyr3 rdmux saprech vddc_5 vddce vddp vddp vddp vpw vpw vpw wa_en
+  wablm0 wen0_5 wen1_5 weny0_term_5 weny1_term_5 wtdft yw0 yw1 yw2 yw3
+  rf64x128colm2x2_std_nbl_ast
xl_io_6 q0_6 q1_6 bl0_6 bl1_6 bl2_6 bl3_6 blprech cap_ctrl0_110 cap_ctrl1_112
+  cap_ctrl0_110 cap_ctrl1_112 d0_6 d1_6 dwl_main dwl_main dwl_turn dwl_turn
+  iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_6 nbl1_6 nbl2_6 nbl3_6 nsae nyr0
+  nyr1 nyr2 nyr3 rdmux saprech vddc_6 vddce vddp vddp vddp vpw vpw vpw wa_en
+  wablm0 wen0_6 wen1_6 weny0_term_6 weny1_term_6 wtdft yw0 yw1 yw2 yw3
+  rf64x128colm2x2_std_nbl_ast
xl_io_7 q0_7 q1_7 bl0_7 bl1_7 bl2_7 bl3_7 blprech cap_ctrl0_114 cap_ctrl1_116
+  cap_ctrl0_114 cap_ctrl1_116 d0_7 d1_7 dwl_main dwl_main dwl_turn dwl_turn
+  iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_7 nbl1_7 nbl2_7 nbl3_7 nsae nyr0
+  nyr1 nyr2 nyr3 rdmux saprech vddc_7 vddce vddp vddp vddp vpw vpw vpw wa_en
+  wablm0 wen0_7 wen1_7 weny0_term_7 weny1_term_7 wtdft yw0 yw1 yw2 yw3
+  rf64x128colm2x2_std_nbl_ast
xl_io_8 q0_8 q1_8 bl0_8 bl1_8 bl2_8 bl3_8 blprech cap_ctrl0_118 cap_ctrl1_120
+  cap_ctrl0_118 cap_ctrl1_120 d0_8 d1_8 dwl_main dwl_main dwl_turn dwl_turn
+  iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_8 nbl1_8 nbl2_8 nbl3_8 nsae nyr0
+  nyr1 nyr2 nyr3 rdmux saprech vddc_8 vddce vddp vddp vddp vpw vpw vpw wa_en
+  wablm0 wen0_8 wen1_8 weny0_term_8 weny1_term_8 wtdft yw0 yw1 yw2 yw3
+  rf64x128colm2x2_std_nbl_ast
xl_io_9 q0_9 q1_9 bl0_9 bl1_9 bl2_9 bl3_9 blprech cap_ctrl0_122 cap_ctrl1_124
+  cap_ctrl0_122 cap_ctrl1_124 d0_9 d1_9 dwl_main dwl_main dwl_turn dwl_turn
+  iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_9 nbl1_9 nbl2_9 nbl3_9 nsae nyr0
+  nyr1 nyr2 nyr3 rdmux saprech vddc_9 vddce vddp vddp vddp vpw vpw vpw wa_en
+  wablm0 wen0_9 wen1_9 weny0_term_9 weny1_term_9 wtdft yw0 yw1 yw2 yw3
+  rf64x128colm2x2_std_nbl_ast
xl_io_l q0_0 q1_0 bl0_0 bl1_0 bl2_0 bl3_0 blprech cap_ctrl0_82 cap_ctrl1_84
+  cap_ctrl0_82 cap_ctrl1_84 d0_0 d1_0 dwl_main dwl_main dwl_turn dwl_turn
+  iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_0 nbl1_0 nbl2_0 nbl3_0 nsae nyr0
+  nyr1 nyr2 nyr3 rdmux saprech vddc_0 vddce vddp vddp vddp vpw vpw vpw wa_en
+  wablm0 wen0_0 wen1_0 weny0_term_0 weny1_term_0 wtdft yw0 yw1 yw2 yw3
+  rf64x128colm2x2_std_nbl_ast
xl_io_r q0_31 q1_31 bl0_31 bl1_31 bl2_31 bl3_31 blprech cap_ctrl0_90
+  cap_ctrl1_92 cap_ctrl0_90 cap_ctrl1_92 d0_31 d1_31 dwl_mainbreak
+  dwl_mainbreak dwl_mainbreak dwl_mainbreak iwclk0 iwclk1 log0 log0_sa
+  nact_cc nbl0_31 nbl1_31 nbl2_31 nbl3_31 nsae nyr0 nyr1 nyr2 nyr3 rdmux
+  saprech vddc_31 vddce vddp vddp vddp vpw vpw vpw wa_en wablm0 wen0_31
+  wen1_31 weny0_term_31 weny1_term_31 wtdft yw0 yw1 yw2 yw3
+  rf64x128colm2x2_std_nbl_ast
.ends rf64x128iocdm_l
****
.subckt rf64x128io_row_l bl0_31 nbl0_31 nbl1_31 bl1_31 vddc_31 bl2_31 nbl2_31
+  nbl3_31 bl3_31 bl0_30 nbl0_30 nbl1_30 bl1_30 vddc_30 bl2_30 nbl2_30 nbl3_30
+  bl3_30 bl0_29 nbl0_29 nbl1_29 bl1_29 vddc_29 bl2_29 nbl2_29 nbl3_29 bl3_29
+  bl0_28 nbl0_28 nbl1_28 bl1_28 vddc_28 bl2_28 nbl2_28 nbl3_28 bl3_28 bl0_27
+  nbl0_27 nbl1_27 bl1_27 vddc_27 bl2_27 nbl2_27 nbl3_27 bl3_27 bl0_26 nbl0_26
+  nbl1_26 bl1_26 vddc_26 bl2_26 nbl2_26 nbl3_26 bl3_26 bl0_25 nbl0_25 nbl1_25
+  bl1_25 vddc_25 bl2_25 nbl2_25 nbl3_25 bl3_25 bl0_24 nbl0_24 nbl1_24 bl1_24
+  vddc_24 bl2_24 nbl2_24 nbl3_24 bl3_24 bl0_23 nbl0_23 nbl1_23 bl1_23 vddc_23
+  bl2_23 nbl2_23 nbl3_23 bl3_23 bl0_22 nbl0_22 nbl1_22 bl1_22 vddc_22 bl2_22
+  nbl2_22 nbl3_22 bl3_22 bl0_21 nbl0_21 nbl1_21 bl1_21 vddc_21 bl2_21 nbl2_21
+  nbl3_21 bl3_21 bl0_20 nbl0_20 nbl1_20 bl1_20 vddc_20 bl2_20 nbl2_20 nbl3_20
+  bl3_20 bl0_19 nbl0_19 nbl1_19 bl1_19 vddc_19 bl2_19 nbl2_19 nbl3_19 bl3_19
+  bl0_18 nbl0_18 nbl1_18 bl1_18 vddc_18 bl2_18 nbl2_18 nbl3_18 bl3_18 bl0_17
+  nbl0_17 nbl1_17 bl1_17 vddc_17 bl2_17 nbl2_17 nbl3_17 bl3_17 bl0_16 nbl0_16
+  nbl1_16 bl1_16 vddc_16 bl2_16 nbl2_16 nbl3_16 bl3_16 bl0_15 nbl0_15 nbl1_15
+  bl1_15 vddc_15 bl2_15 nbl2_15 nbl3_15 bl3_15 bl0_14 nbl0_14 nbl1_14 bl1_14
+  vddc_14 bl2_14 nbl2_14 nbl3_14 bl3_14 bl0_13 nbl0_13 nbl1_13 bl1_13 vddc_13
+  bl2_13 nbl2_13 nbl3_13 bl3_13 bl0_12 nbl0_12 nbl1_12 bl1_12 vddc_12 bl2_12
+  nbl2_12 nbl3_12 bl3_12 bl0_11 nbl0_11 nbl1_11 bl1_11 vddc_11 bl2_11 nbl2_11
+  nbl3_11 bl3_11 bl0_10 nbl0_10 nbl1_10 bl1_10 vddc_10 bl2_10 nbl2_10 nbl3_10
+  bl3_10 bl0_9 nbl0_9 nbl1_9 bl1_9 vddc_9 bl2_9 nbl2_9 nbl3_9 bl3_9 bl0_8
+  nbl0_8 nbl1_8 bl1_8 vddc_8 bl2_8 nbl2_8 nbl3_8 bl3_8 bl0_7 nbl0_7 nbl1_7
+  bl1_7 vddc_7 bl2_7 nbl2_7 nbl3_7 bl3_7 bl0_6 nbl0_6 nbl1_6 bl1_6 vddc_6
+  bl2_6 nbl2_6 nbl3_6 bl3_6 bl0_5 nbl0_5 nbl1_5 bl1_5 vddc_5 bl2_5 nbl2_5
+  nbl3_5 bl3_5 bl0_4 nbl0_4 nbl1_4 bl1_4 vddc_4 bl2_4 nbl2_4 nbl3_4 bl3_4
+  bl0_3 nbl0_3 nbl1_3 bl1_3 vddc_3 bl2_3 nbl2_3 nbl3_3 bl3_3 bl0_2 nbl0_2
+  nbl1_2 bl1_2 vddc_2 bl2_2 nbl2_2 nbl3_2 bl3_2 bl0_1 nbl0_1 nbl1_1 bl1_1
+  vddc_1 bl2_1 nbl2_1 nbl3_1 bl3_1 bl0_0 nbl0_0 nbl1_0 bl1_0 vddce vddc_0
+  bl2_0 nbl2_0 nbl3_0 bl3_0 q0_31 d0_31 wen0_31 weny0_term_31 weny1_term_31
+  wen1_31 d1_31 q1_31 q0_30 d0_30 wen0_30 weny0_term_30 weny1_term_30 wen1_30
+  d1_30 q1_30 q0_29 d0_29 wen0_29 weny0_term_29 weny1_term_29 wen1_29 d1_29
+  q1_29 q0_28 d0_28 wen0_28 weny0_term_28 weny1_term_28 wen1_28 d1_28 q1_28
+  q0_27 d0_27 wen0_27 weny0_term_27 weny1_term_27 wen1_27 d1_27 q1_27 q0_26
+  d0_26 wen0_26 weny0_term_26 weny1_term_26 wen1_26 d1_26 q1_26 q0_25 d0_25
+  wen0_25 weny0_term_25 weny1_term_25 wen1_25 d1_25 q1_25 q0_24 d0_24 wen0_24
+  weny0_term_24 weny1_term_24 wen1_24 d1_24 q1_24 q0_23 vddp d0_23 wen0_23
+  weny0_term_23 weny1_term_23 wen1_23 d1_23 q1_23 q0_22 d0_22 wen0_22
+  weny0_term_22 weny1_term_22 wen1_22 d1_22 q1_22 q0_21 d0_21 wen0_21
+  weny0_term_21 weny1_term_21 wen1_21 d1_21 q1_21 q0_20 d0_20 wen0_20
+  weny0_term_20 weny1_term_20 wen1_20 d1_20 q1_20 q0_19 d0_19 wen0_19
+  weny0_term_19 weny1_term_19 wen1_19 d1_19 q1_19 q0_18 d0_18 wen0_18
+  weny0_term_18 weny1_term_18 wen1_18 d1_18 q1_18 q0_17 d0_17 wen0_17
+  weny0_term_17 weny1_term_17 wen1_17 d1_17 q1_17 q0_16 vpw d0_16 wen0_16
+  weny0_term_16 weny1_term_16 wen1_16 d1_16 q1_16 q0_15 d0_15 wen0_15
+  weny0_term_15 weny1_term_15 wen1_15 d1_15 q1_15 q0_14 d0_14 wen0_14
+  weny0_term_14 weny1_term_14 wen1_14 d1_14 q1_14 q0_13 d0_13 wen0_13
+  weny0_term_13 weny1_term_13 wen1_13 d1_13 q1_13 q0_12 d0_12 wen0_12
+  weny0_term_12 weny1_term_12 wen1_12 d1_12 q1_12 q0_11 d0_11 wen0_11
+  weny0_term_11 weny1_term_11 wen1_11 d1_11 q1_11 q0_10 d0_10 wen0_10
+  weny0_term_10 weny1_term_10 wen1_10 d1_10 q1_10 q0_9 d0_9 wen0_9
+  weny0_term_9 weny1_term_9 wen1_9 d1_9 q1_9 q0_8 d0_8 wen0_8 weny0_term_8
+  weny1_term_8 wen1_8 d1_8 q1_8 q0_7 d0_7 wen0_7 weny0_term_7 weny1_term_7
+  wen1_7 d1_7 q1_7 q0_6 d0_6 wen0_6 weny0_term_6 weny1_term_6 wen1_6 d1_6
+  q1_6 q0_5 d0_5 wen0_5 weny0_term_5 weny1_term_5 wen1_5 d1_5 q1_5 q0_4 d0_4
+  wen0_4 weny0_term_4 weny1_term_4 wen1_4 d1_4 q1_4 q0_3 d0_3 wen0_3
+  weny0_term_3 weny1_term_3 wen1_3 d1_3 q1_3 q0_2 d0_2 wen0_2 weny0_term_2
+  weny1_term_2 wen1_2 d1_2 q1_2 q0_1 d0_1 wen0_1 weny0_term_1 weny1_term_1
+  wen1_1 d1_1 q1_1 q0_0 d0_0 wen0_0 weny0_term_0 weny1_term_0 wen1_0 d1_0
+  q1_0 blprech nact_cc yw3 yw2 yw1 yw0 nyr3 nyr2 nyr1 nyr0 rdmux nsae saprech
+  wtdft log0_sa log0 iwclk0 iwclk1 dwl_mainbreak wablm0 wa_en
** rf64x128io_row_l: 9152 flat devices **
xio_cdm_row_l bl0_31 nbl0_31 nbl1_31 bl1_31 vddc_31 bl2_31 nbl2_31 nbl3_31
+  bl3_31 bl0_30 nbl0_30 nbl1_30 bl1_30 vddc_30 bl2_30 nbl2_30 nbl3_30 bl3_30
+  bl0_29 nbl0_29 nbl1_29 bl1_29 vddc_29 bl2_29 nbl2_29 nbl3_29 bl3_29 bl0_28
+  nbl0_28 nbl1_28 bl1_28 vddc_28 bl2_28 nbl2_28 nbl3_28 bl3_28 bl0_27 nbl0_27
+  nbl1_27 bl1_27 vddc_27 bl2_27 nbl2_27 nbl3_27 bl3_27 bl0_26 nbl0_26 nbl1_26
+  bl1_26 vddc_26 bl2_26 nbl2_26 nbl3_26 bl3_26 bl0_25 nbl0_25 nbl1_25 bl1_25
+  vddc_25 bl2_25 nbl2_25 nbl3_25 bl3_25 bl0_24 nbl0_24 nbl1_24 bl1_24 vddc_24
+  bl2_24 nbl2_24 nbl3_24 bl3_24 bl0_23 nbl0_23 nbl1_23 bl1_23 vddc_23 bl2_23
+  nbl2_23 nbl3_23 bl3_23 bl0_22 nbl0_22 nbl1_22 bl1_22 vddc_22 bl2_22 nbl2_22
+  nbl3_22 bl3_22 bl0_21 nbl0_21 nbl1_21 bl1_21 vddc_21 bl2_21 nbl2_21 nbl3_21
+  bl3_21 bl0_20 nbl0_20 nbl1_20 bl1_20 vddc_20 bl2_20 nbl2_20 nbl3_20 bl3_20
+  bl0_19 nbl0_19 nbl1_19 bl1_19 vddc_19 bl2_19 nbl2_19 nbl3_19 bl3_19 bl0_18
+  nbl0_18 nbl1_18 bl1_18 vddc_18 bl2_18 nbl2_18 nbl3_18 bl3_18 bl0_17 nbl0_17
+  nbl1_17 bl1_17 vddc_17 bl2_17 nbl2_17 nbl3_17 bl3_17 bl0_16 nbl0_16 nbl1_16
+  bl1_16 vddc_16 bl2_16 nbl2_16 nbl3_16 bl3_16 bl0_15 nbl0_15 nbl1_15 bl1_15
+  vddc_15 bl2_15 nbl2_15 nbl3_15 bl3_15 bl0_14 nbl0_14 nbl1_14 bl1_14 vddc_14
+  bl2_14 nbl2_14 nbl3_14 bl3_14 bl0_13 nbl0_13 nbl1_13 bl1_13 vddc_13 bl2_13
+  nbl2_13 nbl3_13 bl3_13 bl0_12 nbl0_12 nbl1_12 bl1_12 vddc_12 bl2_12 nbl2_12
+  nbl3_12 bl3_12 bl0_11 nbl0_11 nbl1_11 bl1_11 vddc_11 bl2_11 nbl2_11 nbl3_11
+  bl3_11 bl0_10 nbl0_10 nbl1_10 bl1_10 vddc_10 bl2_10 nbl2_10 nbl3_10 bl3_10
+  bl0_9 nbl0_9 nbl1_9 bl1_9 vddc_9 bl2_9 nbl2_9 nbl3_9 bl3_9 bl0_8 nbl0_8
+  nbl1_8 bl1_8 vddc_8 bl2_8 nbl2_8 nbl3_8 bl3_8 bl0_7 nbl0_7 nbl1_7 bl1_7
+  vddc_7 bl2_7 nbl2_7 nbl3_7 bl3_7 bl0_6 nbl0_6 nbl1_6 bl1_6 vddc_6 bl2_6
+  nbl2_6 nbl3_6 bl3_6 bl0_5 nbl0_5 nbl1_5 bl1_5 vddc_5 bl2_5 nbl2_5 nbl3_5
+  bl3_5 bl0_4 nbl0_4 nbl1_4 bl1_4 vddc_4 bl2_4 nbl2_4 nbl3_4 bl3_4 bl0_3
+  nbl0_3 nbl1_3 bl1_3 vddc_3 bl2_3 nbl2_3 nbl3_3 bl3_3 bl0_2 nbl0_2 nbl1_2
+  bl1_2 vddc_2 bl2_2 nbl2_2 nbl3_2 bl3_2 bl0_1 nbl0_1 nbl1_1 bl1_1 vddc_1
+  bl2_1 nbl2_1 nbl3_1 bl3_1 bl0_0 nbl0_0 nbl1_0 bl1_0 vddce vddc_0 bl2_0
+  nbl2_0 nbl3_0 bl3_0 q0_31 d0_31 wen0_31 weny0_term_31 weny1_term_31 wen1_31
+  d1_31 q1_31 q0_30 d0_30 wen0_30 weny0_term_30 weny1_term_30 wen1_30 d1_30
+  q1_30 q0_29 d0_29 wen0_29 weny0_term_29 weny1_term_29 wen1_29 d1_29 q1_29
+  q0_28 d0_28 wen0_28 weny0_term_28 weny1_term_28 wen1_28 d1_28 q1_28 q0_27
+  d0_27 wen0_27 weny0_term_27 weny1_term_27 wen1_27 d1_27 q1_27 q0_26 d0_26
+  wen0_26 weny0_term_26 weny1_term_26 wen1_26 d1_26 q1_26 q0_25 d0_25 wen0_25
+  weny0_term_25 weny1_term_25 wen1_25 d1_25 q1_25 q0_24 d0_24 wen0_24
+  weny0_term_24 weny1_term_24 wen1_24 d1_24 q1_24 q0_23 d0_23 wen0_23
+  weny0_term_23 weny1_term_23 wen1_23 d1_23 q1_23 q0_22 d0_22 wen0_22
+  weny0_term_22 weny1_term_22 wen1_22 d1_22 q1_22 q0_21 d0_21 wen0_21
+  weny0_term_21 weny1_term_21 wen1_21 d1_21 q1_21 q0_20 d0_20 wen0_20
+  weny0_term_20 weny1_term_20 wen1_20 d1_20 q1_20 q0_19 d0_19 wen0_19
+  weny0_term_19 weny1_term_19 wen1_19 d1_19 q1_19 q0_18 d0_18 wen0_18
+  weny0_term_18 weny1_term_18 wen1_18 d1_18 q1_18 q0_17 d0_17 vpw wen0_17
+  weny0_term_17 weny1_term_17 wen1_17 d1_17 q1_17 q0_16 d0_16 wen0_16
+  weny0_term_16 weny1_term_16 wen1_16 d1_16 q1_16 q0_15 d0_15 wen0_15
+  weny0_term_15 weny1_term_15 wen1_15 d1_15 q1_15 q0_14 d0_14 wen0_14
+  weny0_term_14 weny1_term_14 wen1_14 d1_14 q1_14 q0_13 d0_13 wen0_13
+  weny0_term_13 weny1_term_13 wen1_13 d1_13 q1_13 q0_12 d0_12 wen0_12
+  weny0_term_12 weny1_term_12 wen1_12 d1_12 q1_12 q0_11 d0_11 wen0_11
+  weny0_term_11 weny1_term_11 wen1_11 d1_11 q1_11 q0_10 d0_10 wen0_10
+  weny0_term_10 weny1_term_10 wen1_10 d1_10 q1_10 q0_9 d0_9 wen0_9
+  weny0_term_9 weny1_term_9 wen1_9 d1_9 q1_9 q0_8 d0_8 wen0_8 weny0_term_8
+  weny1_term_8 wen1_8 d1_8 q1_8 q0_7 d0_7 wen0_7 weny0_term_7 weny1_term_7
+  wen1_7 d1_7 q1_7 q0_6 d0_6 wen0_6 weny0_term_6 weny1_term_6 wen1_6 d1_6
+  q1_6 q0_5 d0_5 wen0_5 weny0_term_5 weny1_term_5 wen1_5 d1_5 q1_5 q0_4 d0_4
+  wen0_4 weny0_term_4 weny1_term_4 wen1_4 d1_4 q1_4 q0_3 d0_3 wen0_3
+  weny0_term_3 weny1_term_3 wen1_3 d1_3 q1_3 q0_2 d0_2 wen0_2 weny0_term_2
+  weny1_term_2 wen1_2 d1_2 q1_2 q0_1 d0_1 wen0_1 weny0_term_1 weny1_term_1
+  wen1_1 d1_1 q1_1 q0_0 d0_0 wen0_0 weny0_term_0 weny1_term_0 wen1_0 d1_0
+  vddp q1_0 yw3 yw2 nyr3 nyr2 wtdft log0 dwl_mainbreak wablm0 wa_en blprech
+  nact_cc yw1 yw0 nyr1 nyr0 rdmux nsae saprech log0_sa iwclk0 iwclk1 dwl_main
+  log0 rf64x128iocdm_l
.ends rf64x128io_row_l
****
.subckt rf64x128ckm2_std_nbl_ast blprech_l blprech_r cen_p2 gtp iwclk0 iwclk1
+  la_p2[0] la_p2[1] nact_cc nla_p2[0] nla_p2[1] nra_p2[0] nra_p2[1] nra_p2[2]
+  nra_p2[3] nra_p2[4] nra_p2[5] nsae_l nsae_r nyr0 nyr1 nyr2 nyr3 ra_p2[0]
+  ra_p2[1] ra_p2[2] ra_p2[3] ra_p2[4] ra_p2[5] rdmux saprech wtdft yw0_l
+  yw0_r yw1_l yw1_r yw2_l yw2_r yw3_l yw3_r actp dbl dbl_nbl_wa dbl_nbl_wa_el
+  dbl_nbl_wa_turn dwl dwl_turn log0 log0_sa log1 nactc nretnvt penso_term
+  pso0_term pso1_term rawl rawlm0 rawlm1 ret1n vddc vddce vddp vddp_nor vddpe
+  vnwc vnwp vpw vss vsse wa_en_left wa_en_right wabl wablm0 wablm0_left
+  wablm0_p2 wablm0_p2_prog wablm0_right wablm1 a0 a1 a2 a3 a4 a5 a6 a7 a8 a9
+  a10 cen clk ema[0] ema[1] ema[2] emas emaw[0] emaw[1] gwen nret nwr_thru
+  rdt
** rf64x128ckm2_std_nbl_ast: 767 flat devices **
mi255.mxna1 na9 a9 vss vpw nch_mac W=0.4U L=0.03U NF=1
mi255.mxpa1 na9 a9 vddpe vnwp pch_mac W=0.6U L=0.03U NF=1
mi256.mxna1 na8 a8 vss vpw nch_mac W=0.4U L=0.03U NF=1
mi256.mxpa1 na8 a8 vddpe vnwp pch_mac W=0.6U L=0.03U NF=1
mi257.mxna1 na7 a7 vss vpw nch_mac W=0.4U L=0.03U NF=1
mi257.mxpa1 na7 a7 vddpe vnwp pch_mac W=0.6U L=0.03U NF=1
mi258.mxna1 na5 a5 vss vpw nch_mac W=0.4U L=0.03U NF=1
mi258.mxpa1 na5 a5 vddpe vnwp pch_mac W=0.6U L=0.03U NF=1
mi259.mxna1 na3 a3 vss vpw nch_mac W=0.4U L=0.03U NF=1
mi259.mxpa1 na3 a3 vddpe vnwp pch_mac W=0.6U L=0.03U NF=1
mi260.mxna1 na1 a1 vss vpw nch_mac W=0.4U L=0.03U NF=1
mi260.mxpa1 na1 a1 vddpe vnwp pch_mac W=0.6U L=0.03U NF=1
mi261.mxna1 cedft cen vss vpw nch_mac W=0.4U L=0.03U NF=1
mi261.mxpa1 cedft cen vddpe vnwp pch_mac W=0.6U L=0.03U NF=1
mi262.mxna1 ngwen gwen vss vpw nch_mac W=0.4U L=0.03U NF=1
mi262.mxpa1 ngwen gwen vddpe vnwp pch_mac W=0.6U L=0.03U NF=1
mi263.mxna1 na0 a0 vss vpw nch_mac W=0.4U L=0.03U NF=1
mi263.mxpa1 na0 a0 vddpe vnwp pch_mac W=0.6U L=0.03U NF=1
mi264.mxna1 na2 a2 vss vpw nch_mac W=0.4U L=0.03U NF=1
mi264.mxpa1 na2 a2 vddpe vnwp pch_mac W=0.6U L=0.03U NF=1
mi265.mxna1 na4 a4 vss vpw nch_mac W=0.4U L=0.03U NF=1
mi265.mxpa1 na4 a4 vddpe vnwp pch_mac W=0.6U L=0.03U NF=1
mi266.mxna1 na6 a6 vss vpw nch_mac W=0.4U L=0.03U NF=1
mi266.mxpa1 na6 a6 vddpe vnwp pch_mac W=0.6U L=0.03U NF=1
mi58.mxna1 na10 a10 vss vpw nch_mac W=0.4U L=0.03U NF=1
mi58.mxpa1 na10 a10 vddpe vnwp pch_mac W=0.6U L=0.03U NF=1
mick.i0.mxna1 ick.nblpreclk gtp ick.i0.n1 vpw nch_mac W=2U L=0.03U NF=1
mick.i0.mxna2 ick.i0.n1 ick.nrdt_rd vss vpw nch_mac W=2U L=0.03U NF=1
mick.i0.mxpa1 ick.nblpreclk gtp vddpe vnwp pch_mac W=0.6U L=0.03U NF=1
mick.i0.mxpa2 ick.nblpreclk ick.nrdt_rd vddpe vnwp pch_mac W=0.6U L=0.03U NF=1
mick.i105_0.mxna1 ra_p2[0] ick.na_p2[4] vss vpw nch_mac W=0.4U L=0.035U NF=1
mick.i105_0.mxpa1 ra_p2[0] ick.na_p2[4] vddpe vnwp pch_mac W=0.45U L=0.035U
+  NF=1
mick.i105_1.mxna1 ra_p2[1] ick.na_p2[5] vss vpw nch_mac W=0.4U L=0.035U NF=1
mick.i105_1.mxpa1 ra_p2[1] ick.na_p2[5] vddpe vnwp pch_mac W=0.45U L=0.035U
+  NF=1
mick.i105_2.mxna1 ra_p2[2] ick.na_p2[6] vss vpw nch_mac W=0.4U L=0.035U NF=1
mick.i105_2.mxpa1 ra_p2[2] ick.na_p2[6] vddpe vnwp pch_mac W=0.45U L=0.035U
+  NF=1
mick.i105_3.mxna1 ra_p2[3] ick.na_p2[7] vss vpw nch_mac W=0.4U L=0.035U NF=1
mick.i105_3.mxpa1 ra_p2[3] ick.na_p2[7] vddpe vnwp pch_mac W=0.45U L=0.035U
+  NF=1
mick.i105_4.mxna1 ra_p2[4] ick.na_p2[8] vss vpw nch_mac W=0.4U L=0.035U NF=1
mick.i105_4.mxpa1 ra_p2[4] ick.na_p2[8] vddpe vnwp pch_mac W=0.45U L=0.035U
+  NF=1
mick.i105_5.mxna1 ra_p2[5] ick.na_p2[9] vss vpw nch_mac W=0.4U L=0.035U NF=1
mick.i105_5.mxpa1 ra_p2[5] ick.na_p2[9] vddpe vnwp pch_mac W=0.45U L=0.035U
+  NF=1
mick.i115_0.mxna1 nra_p2[0] ick.a_p2[4] vss vpw nch_mac W=0.4U L=0.035U NF=1
mick.i115_0.mxpa1 nra_p2[0] ick.a_p2[4] vddpe vnwp pch_mac W=0.45U L=0.035U
+  NF=1
mick.i115_1.mxna1 nra_p2[1] ick.a_p2[5] vss vpw nch_mac W=0.4U L=0.035U NF=1
mick.i115_1.mxpa1 nra_p2[1] ick.a_p2[5] vddpe vnwp pch_mac W=0.45U L=0.035U
+  NF=1
mick.i115_2.mxna1 nra_p2[2] ick.a_p2[6] vss vpw nch_mac W=0.4U L=0.035U NF=1
mick.i115_2.mxpa1 nra_p2[2] ick.a_p2[6] vddpe vnwp pch_mac W=0.45U L=0.035U
+  NF=1
mick.i115_3.mxna1 nra_p2[3] ick.a_p2[7] vss vpw nch_mac W=0.4U L=0.035U NF=1
mick.i115_3.mxpa1 nra_p2[3] ick.a_p2[7] vddpe vnwp pch_mac W=0.45U L=0.035U
+  NF=1
mick.i115_4.mxna1 nra_p2[4] ick.a_p2[8] vss vpw nch_mac W=0.4U L=0.035U NF=1
mick.i115_4.mxpa1 nra_p2[4] ick.a_p2[8] vddpe vnwp pch_mac W=0.45U L=0.035U
+  NF=1
mick.i115_5.mxna1 nra_p2[5] ick.a_p2[9] vss vpw nch_mac W=0.4U L=0.035U NF=1
mick.i115_5.mxpa1 nra_p2[5] ick.a_p2[9] vddpe vnwp pch_mac W=0.45U L=0.035U
+  NF=1
mick.i177.mxna1 ick.ndft_p2 ick.dft_p2 vss vpw nch_mac W=0.3U L=0.03U NF=1
mick.i177.mxpa1 ick.ndft_p2 ick.dft_p2 vddpe vnwp pch_mac W=0.4U L=0.03U NF=1
mick.i207.mxna1 rdmux ick.rda_p1 vss vpw nch_mac W=2.6U L=0.03U NF=4
mick.i207.mxpa1 rdmux ick.rda_p1 vddpe vnwp pch_mac W=4U L=0.03U NF=4
mick.i208.mxna1 saprech ick.insaprech vss vpw nch_mac W=4.575U L=0.035U NF=3
mick.i208.mxpa1 saprech ick.insaprech vddpe vnwp pch_mac W=3.6U L=0.035U NF=3
mick.i232.mxna1 ick.nrdt_rd ick.dft_p2 vss vpw nch_mac W=0.3U L=0.03U NF=1
mick.i232.mxnb1 ick.nrdt_rd ick.gwen_p2 ick.i232.n1 vpw nch_mac W=0.3U L=0.03U
+  NF=1
mick.i232.mxnb2 ick.i232.n1 ick.rdt_p2 vss vpw nch_mac W=0.3U L=0.03U NF=1
mick.i232.mxpa1 ick.nrdt_rd ick.dft_p2 ick.i232.p1 vnwp pch_mac W=0.3U L=0.03U
+  NF=1
mick.i232.mxpb1 ick.i232.p1 ick.gwen_p2 vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick.i232.mxpb2 ick.i232.p1 ick.rdt_p2 vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick.i234.mxna1 ick.iwen1 ick.gwen_p2 vss vpw nch_mac W=0.2U L=0.03U NF=1
mick.i234.mxna2 ick.iwen1 ick.na_p2[2] vss vpw nch_mac W=0.2U L=0.03U NF=1
mick.i234.mxpa1 ick.iwen1 ick.gwen_p2 ick.i234.p1 vnwp pch_mac W=0.4U L=0.03U
+  NF=1
mick.i234.mxpa2 ick.i234.p1 ick.na_p2[2] vddpe vnwp pch_mac W=0.4U L=0.03U
+  NF=1
mick.i239.mxna1 ick.rda_p1 ick.nrda_p1 vss vpw nch_mac W=0.8U L=0.03U NF=2
mick.i239.mxpa1 ick.rda_p1 ick.nrda_p1 vddpe vnwp pch_mac W=1.2U L=0.03U NF=2
mick.i243.mxna1 la_p2[1] ick.na_p2[10] vss vpw nch_mac W=0.26U L=0.03U NF=1
mick.i243.mxna2 la_p2[1] ick.dft_p2 vss vpw nch_mac W=0.26U L=0.03U NF=1
mick.i243.mxpa1 la_p2[1] ick.na_p2[10] ick.i243.p1 vnwp pch_mac W=0.51U
+  L=0.03U NF=1
mick.i243.mxpa2 ick.i243.p1 ick.dft_p2 vddpe vnwp pch_mac W=0.51U L=0.03U NF=1
mick.i244.mxna1 la_p2[0] ick.na_p2[3] vss vpw nch_mac W=0.26U L=0.03U NF=1
mick.i244.mxna2 la_p2[0] ick.dft_p2 vss vpw nch_mac W=0.26U L=0.03U NF=1
mick.i244.mxpa1 la_p2[0] ick.na_p2[3] ick.i244.p1 vnwp pch_mac W=0.51U L=0.03U
+  NF=1
mick.i244.mxpa2 ick.i244.p1 ick.dft_p2 vddpe vnwp pch_mac W=0.51U L=0.03U NF=1
mick.i245.mxna1 nla_p2[0] ick.a_p2[3] vss vpw nch_mac W=0.26U L=0.03U NF=1
mick.i245.mxna2 nla_p2[0] ick.dft_p2 vss vpw nch_mac W=0.26U L=0.03U NF=1
mick.i245.mxpa1 nla_p2[0] ick.a_p2[3] ick.i245.p1 vnwp pch_mac W=0.51U L=0.03U
+  NF=1
mick.i245.mxpa2 ick.i245.p1 ick.dft_p2 vddpe vnwp pch_mac W=0.51U L=0.03U NF=1
mick.i248.i48.mxnoe ick.ncen_p2 ick.nclk cedft vpw nch_mac W=0.5U L=0.03U NF=1
mick.i248.i48.mxpoen ick.ncen_p2 ick.bclk cedft vnwp pch_mac W=0.5U L=0.03U
+  NF=1
mick.i248.i50.mxna1 cen_p2 ick.ncen_p2 vss vpw nch_mac W=0.6U L=0.03U NF=2
mick.i248.i50.mxpa1 cen_p2 ick.ncen_p2 vddpe vnwp pch_mac W=0.8U L=0.03U NF=2
mick.i248.i55.mxna1 ick.i248.i55.n1 cen_p2 vss vpw nch_mac W=0.1U L=0.03U NF=1
mick.i248.i55.mxnoe ick.ncen_p2 ick.bclk ick.i248.i55.n1 vpw nch_mac W=0.1U
+  L=0.03U NF=1
mick.i248.i55.mxpa1 ick.i248.i55.p1 cen_p2 vddpe vnwp pch_mac W=0.1U L=0.03U
+  NF=1
mick.i248.i55.mxpoen ick.ncen_p2 ick.nclk ick.i248.i55.p1 vnwp pch_mac W=0.1U
+  L=0.03U NF=1
mick.i249.i0.mxna1 ick.i249.nwtdft ick.i249.igtp ick.i249.i0.n1 vpw nch_mac
+  W=0.2U L=0.04U NF=1
mick.i249.i0.mxna2 ick.i249.i0.n1 ick.i249.iwtdft vss vpw nch_mac W=0.2U
+  L=0.04U NF=1
mick.i249.i0.mxpa1 ick.i249.nwtdft ick.i249.igtp vddpe vnwp pch_mac W=0.2U
+  L=0.04U NF=1
mick.i249.i0.mxpa2 ick.i249.nwtdft ick.i249.iwtdft vddpe vnwp pch_mac W=0.2U
+  L=0.04U NF=1
mick.i249.i65.mxna1 ick.i249.net041 ick.ndft_p2 ick.i249.i65.n1 vpw nch_mac
+  W=0.2U L=0.035U NF=1
mick.i249.i65.mxnb1 ick.i249.i65.n1 ick.gwen_p2 vss vpw nch_mac W=0.2U
+  L=0.035U NF=1
mick.i249.i65.mxnb2 ick.i249.i65.n1 nwr_thru vss vpw nch_mac W=0.2U L=0.035U
+  NF=1
mick.i249.i65.mxpa1 ick.i249.net041 ick.ndft_p2 vddpe vnwp pch_mac W=0.2U
+  L=0.035U NF=1
mick.i249.i65.mxpb1 ick.i249.net041 ick.gwen_p2 ick.i249.i65.p1 vnwp pch_mac
+  W=0.2U L=0.035U NF=1
mick.i249.i65.mxpb2 ick.i249.i65.p1 nwr_thru vddpe vnwp pch_mac W=0.2U
+  L=0.035U NF=1
mick.i249.i89.mxna1 ick.i249.net031 ick.i249.nwtdft vss vpw nch_mac W=0.2U
+  L=0.04U NF=1
mick.i249.i89.mxpa1 ick.i249.net031 ick.i249.nwtdft vddpe vnwp pch_mac W=0.2U
+  L=0.04U NF=1
mick.i249.i90.mxna1 ick.i249.net025 ick.i249.net031 vss vpw nch_mac W=0.42U
+  L=0.04U NF=1
mick.i249.i90.mxpa1 ick.i249.net025 ick.i249.net031 vddpe vnwp pch_mac W=0.42U
+  L=0.04U NF=1
mick.i249.mxn0 ick.i249.net012 gtp vss vpw nch_mac W=0.12U L=0.035U NF=1
mick.i249.mxn1 ick.i249.igtp ick.i249.net012 ick.i249.net018 vpw nch_mac
+  W=0.12U L=0.035U NF=1
mick.i249.mxn10 ick.i249.iwtdft ick.i249.net011 ick.i249.net030 vpw nch_mac
+  W=0.12U L=0.035U NF=1
mick.i249.mxn12 ick.i249.net011 ick.i249.net041 ick.i249.net028 vpw nch_mac
+  W=0.12U L=0.035U NF=1
mick.i249.mxn13 ick.i249.net028 ick.i249.net041 vss vpw nch_mac W=0.12U
+  L=0.035U NF=1
mick.i249.mxn15 wtdft ick.i249.net025 vss vpw nch_mac W=1.8U L=0.035U NF=3
mick.i249.mxn2 ick.i249.net018 ick.i249.net012 vss vpw nch_mac W=0.12U
+  L=0.035U NF=1
mick.i249.mxn3 ick.i249.net030 ick.i249.net011 vss vpw nch_mac W=0.12U
+  L=0.035U NF=1
mick.i249.mxp0 ick.i249.net012 gtp ick.i249.net019 vnwp pch_mac W=0.12U
+  L=0.035U NF=1
mick.i249.mxp1 ick.i249.igtp ick.i249.net012 vddpe vnwp pch_mac W=0.12U
+  L=0.035U NF=1
mick.i249.mxp12 ick.i249.net011 ick.i249.net041 ick.i249.net032 vnwp pch_mac
+  W=0.12U L=0.035U NF=1
mick.i249.mxp13 ick.i249.net032 ick.i249.net041 vddpe vnwp pch_mac W=0.12U
+  L=0.035U NF=1
mick.i249.mxp15 wtdft ick.i249.net025 vddpe vnwp pch_mac W=6U L=0.035U NF=3
mick.i249.mxp2 ick.i249.net019 gtp vddpe vnwp pch_mac W=0.12U L=0.035U NF=1
mick.i249.mxp6 ick.i249.iwtdft ick.i249.net011 ick.i249.net037 vnwp pch_mac
+  W=0.12U L=0.035U NF=1
mick.i249.mxp9 ick.i249.net037 ick.i249.net011 vddpe vnwp pch_mac W=0.12U
+  L=0.035U NF=1
mick.i4.mxna1 ick.niclk gtp vss vpw nch_mac W=0.3U L=0.03U NF=1
mick.i4.mxpa1 ick.niclk gtp vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick.i63.mxna1 ick.iwen0 ick.ndft_p2 ick.i63.n1 vpw nch_mac W=0.4U L=0.03U
+  NF=1
mick.i63.mxnb1 ick.i63.n1 ick.gwen_p2 vss vpw nch_mac W=0.4U L=0.03U NF=1
mick.i63.mxnb2 ick.i63.n1 ick.a_p2[2] vss vpw nch_mac W=0.4U L=0.03U NF=1
mick.i63.mxpa1 ick.iwen0 ick.ndft_p2 vddpe vnwp pch_mac W=0.6U L=0.03U NF=1
mick.i63.mxpb1 ick.iwen0 ick.gwen_p2 ick.i63.p1 vnwp pch_mac W=0.6U L=0.03U
+  NF=1
mick.i63.mxpb2 ick.i63.p1 ick.a_p2[2] vddpe vnwp pch_mac W=0.6U L=0.03U NF=1
mick.i72.mxna1 ick.isaprech gtp ick.i72.n2 vpw nch_mac W=1.42U L=0.035U NF=1
mick.i72.mxna2 ick.i72.n2 ick.gwen_p2 ick.i72.n1 vpw nch_mac W=1.42U L=0.035U
+  NF=1
mick.i72.mxna3 ick.i72.n1 ick.ndft_p2 vss vpw nch_mac W=1.42U L=0.035U NF=1
mick.i72.mxpa1 ick.isaprech gtp vddpe vnwp pch_mac W=0.3U L=0.035U NF=1
mick.i72.mxpa2 ick.isaprech ick.gwen_p2 vddpe vnwp pch_mac W=0.3U L=0.035U
+  NF=1
mick.i72.mxpa3 ick.isaprech ick.ndft_p2 vddpe vnwp pch_mac W=0.3U L=0.035U
+  NF=1
mick.i95.mxna1 nla_p2[1] ick.a_p2[10] vss vpw nch_mac W=0.26U L=0.03U NF=1
mick.i95.mxna2 nla_p2[1] ick.dft_p2 vss vpw nch_mac W=0.26U L=0.03U NF=1
mick.i95.mxpa1 nla_p2[1] ick.a_p2[10] ick.i95.p1 vnwp pch_mac W=0.51U L=0.03U
+  NF=1
mick.i95.mxpa2 ick.i95.p1 ick.dft_p2 vddpe vnwp pch_mac W=0.51U L=0.03U NF=1
mick.mxn0 ick.insaprech ick.isaprech ick.n1 vpw nch_mac W=1U L=0.035U NF=1
mick.mxn1 ick.bclk ick.niclk vss vpw nch_mac W=0.6U L=0.03U NF=2
mick.mxn15 ick.nclk gtp vss vpw nch_mac W=0.8U L=0.03U NF=1
mick.mxn2 ick.n1 ick.nsetsa vss vpw nch_mac W=1U L=0.035U NF=1
mick.mxp0 ick.insaprech ick.isaprech vddpe vnwp pch_mac W=1.9U L=0.035U NF=1
mick.mxp1 ick.insaprech ick.nsetsa vddpe vnwp pch_mac W=0.4U L=0.035U NF=1
mick.mxp15 ick.nclk gtp vddpe vnwp pch_mac W=0.8U L=0.03U NF=1
mick.mxp2 ick.bclk ick.niclk vddpe vnwp pch_mac W=1.6U L=0.03U NF=2
mick._a2p2_lat.i50.mxna1 ick.nrda_p1 ick.irda_p1 vss vpw nch_mac W=0.2U
+  L=0.03U NF=1
mick._a2p2_lat.i50.mxpa1 ick.nrda_p1 ick.irda_p1 vddpe vnwp pch_mac W=0.3U
+  L=0.03U NF=1
mick._a2p2_lat.i55.mxna1 ick._a2p2_lat.i55.n1 ick.nrda_p1 vss vpw nch_mac
+  W=0.1U L=0.03U NF=1
mick._a2p2_lat.i55.mxnoe ick.irda_p1 ick.nclk ick._a2p2_lat.i55.n1 vpw nch_mac
+  W=0.1U L=0.03U NF=1
mick._a2p2_lat.i55.mxpa1 ick._a2p2_lat.i55.p1 ick.nrda_p1 vddpe vnwp pch_mac
+  W=0.1U L=0.03U NF=1
mick._a2p2_lat.i55.mxpoen ick.irda_p1 gtp ick._a2p2_lat.i55.p1 vnwp pch_mac
+  W=0.1U L=0.03U NF=1
mick._a2p2_lat.i57.mxna1 ick._a2p2_lat.nsel ick.gwen_p2 vss vpw nch_mac W=0.1U
+  L=0.03U NF=1
mick._a2p2_lat.i57.mxpa1 ick._a2p2_lat.nsel ick.gwen_p2 vddpe vnwp pch_mac
+  W=0.15U L=0.03U NF=1
mick._a2p2_lat.i65.mxnoe ick.irda_p1 gtp ick._a2p2_lat.nd vpw nch_mac W=0.2U
+  L=0.03U NF=1
mick._a2p2_lat.i65.mxpoen ick.irda_p1 ick.nclk ick._a2p2_lat.nd vnwp pch_mac
+  W=0.2U L=0.03U NF=1
mick._a2p2_lat.mxn1 ick._a2p2_lat.nd ick.a_p2[2] ick._a2p2_lat.n2 vpw nch_mac
+  W=0.2U L=0.03U NF=1
mick._a2p2_lat.mxn2 ick._a2p2_lat.nd ick.nrda_p1 ick._a2p2_lat.n1 vpw nch_mac
+  W=0.2U L=0.03U NF=1
mick._a2p2_lat.mxn5 ick._a2p2_lat.n1 ick._a2p2_lat.nsel vss vpw nch_mac W=0.2U
+  L=0.03U NF=1
mick._a2p2_lat.mxn6 ick._a2p2_lat.n2 ick.gwen_p2 vss vpw nch_mac W=0.2U
+  L=0.03U NF=1
mick._a2p2_lat.mxp1 ick._a2p2_lat.nd ick.nrda_p1 ick._a2p2_lat.p1 vnwp pch_mac
+  W=0.3U L=0.03U NF=1
mick._a2p2_lat.mxp3 ick._a2p2_lat.nd ick.a_p2[2] ick._a2p2_lat.p2 vnwp pch_mac
+  W=0.3U L=0.03U NF=1
mick._a2p2_lat.mxp4 ick._a2p2_lat.p1 ick.gwen_p2 vddpe vnwp pch_mac W=0.3U
+  L=0.03U NF=1
mick._a2p2_lat.mxp5 ick._a2p2_lat.p2 ick._a2p2_lat.nsel vddpe vnwp pch_mac
+  W=0.3U L=0.03U NF=1
mick._addr_lat_0.i48.mxnoe ick.na_p2[0] ick.nclk na0 vpw nch_mac W=0.5U
+  L=0.03U NF=1
mick._addr_lat_0.i48.mxpoen ick.na_p2[0] ick.bclk na0 vnwp pch_mac W=0.5U
+  L=0.03U NF=1
mick._addr_lat_0.i50.mxna1 ick.a_p2[0] ick.na_p2[0] vss vpw nch_mac W=0.2U
+  L=0.03U NF=1
mick._addr_lat_0.i50.mxpa1 ick.a_p2[0] ick.na_p2[0] vddpe vnwp pch_mac W=0.3U
+  L=0.03U NF=1
mick._addr_lat_0.i55.mxna1 ick._addr_lat_0.i55.n1 ick.a_p2[0] vss vpw nch_mac
+  W=0.1U L=0.03U NF=1
mick._addr_lat_0.i55.mxnoe ick.na_p2[0] ick.bclk ick._addr_lat_0.i55.n1 vpw
+  nch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_0.i55.mxpa1 ick._addr_lat_0.i55.p1 ick.a_p2[0] vddpe vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_0.i55.mxpoen ick.na_p2[0] ick.nclk ick._addr_lat_0.i55.p1 vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_1.i48.mxnoe ick.na_p2[1] ick.nclk na1 vpw nch_mac W=0.5U
+  L=0.03U NF=1
mick._addr_lat_1.i48.mxpoen ick.na_p2[1] ick.bclk na1 vnwp pch_mac W=0.5U
+  L=0.03U NF=1
mick._addr_lat_1.i50.mxna1 ick.a_p2[1] ick.na_p2[1] vss vpw nch_mac W=0.2U
+  L=0.03U NF=1
mick._addr_lat_1.i50.mxpa1 ick.a_p2[1] ick.na_p2[1] vddpe vnwp pch_mac W=0.3U
+  L=0.03U NF=1
mick._addr_lat_1.i55.mxna1 ick._addr_lat_1.i55.n1 ick.a_p2[1] vss vpw nch_mac
+  W=0.1U L=0.03U NF=1
mick._addr_lat_1.i55.mxnoe ick.na_p2[1] ick.bclk ick._addr_lat_1.i55.n1 vpw
+  nch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_1.i55.mxpa1 ick._addr_lat_1.i55.p1 ick.a_p2[1] vddpe vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_1.i55.mxpoen ick.na_p2[1] ick.nclk ick._addr_lat_1.i55.p1 vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_10.i48.mxnoe ick.na_p2[10] ick.nclk na10 vpw nch_mac W=0.5U
+  L=0.03U NF=1
mick._addr_lat_10.i48.mxpoen ick.na_p2[10] ick.bclk na10 vnwp pch_mac W=0.5U
+  L=0.03U NF=1
mick._addr_lat_10.i50.mxna1 ick.a_p2[10] ick.na_p2[10] vss vpw nch_mac W=0.2U
+  L=0.03U NF=1
mick._addr_lat_10.i50.mxpa1 ick.a_p2[10] ick.na_p2[10] vddpe vnwp pch_mac
+  W=0.3U L=0.03U NF=1
mick._addr_lat_10.i55.mxna1 ick._addr_lat_10.i55.n1 ick.a_p2[10] vss vpw
+  nch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_10.i55.mxnoe ick.na_p2[10] ick.bclk ick._addr_lat_10.i55.n1 vpw
+  nch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_10.i55.mxpa1 ick._addr_lat_10.i55.p1 ick.a_p2[10] vddpe vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_10.i55.mxpoen ick.na_p2[10] ick.nclk ick._addr_lat_10.i55.p1
+  vnwp pch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_2.i48.mxnoe ick.na_p2[2] ick.nclk na2 vpw nch_mac W=0.5U
+  L=0.03U NF=1
mick._addr_lat_2.i48.mxpoen ick.na_p2[2] ick.bclk na2 vnwp pch_mac W=0.5U
+  L=0.03U NF=1
mick._addr_lat_2.i50.mxna1 ick.a_p2[2] ick.na_p2[2] vss vpw nch_mac W=0.2U
+  L=0.03U NF=1
mick._addr_lat_2.i50.mxpa1 ick.a_p2[2] ick.na_p2[2] vddpe vnwp pch_mac W=0.3U
+  L=0.03U NF=1
mick._addr_lat_2.i55.mxna1 ick._addr_lat_2.i55.n1 ick.a_p2[2] vss vpw nch_mac
+  W=0.1U L=0.03U NF=1
mick._addr_lat_2.i55.mxnoe ick.na_p2[2] ick.bclk ick._addr_lat_2.i55.n1 vpw
+  nch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_2.i55.mxpa1 ick._addr_lat_2.i55.p1 ick.a_p2[2] vddpe vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_2.i55.mxpoen ick.na_p2[2] ick.nclk ick._addr_lat_2.i55.p1 vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_3.i48.mxnoe ick.na_p2[3] ick.nclk na3 vpw nch_mac W=0.5U
+  L=0.03U NF=1
mick._addr_lat_3.i48.mxpoen ick.na_p2[3] ick.bclk na3 vnwp pch_mac W=0.5U
+  L=0.03U NF=1
mick._addr_lat_3.i50.mxna1 ick.a_p2[3] ick.na_p2[3] vss vpw nch_mac W=0.2U
+  L=0.03U NF=1
mick._addr_lat_3.i50.mxpa1 ick.a_p2[3] ick.na_p2[3] vddpe vnwp pch_mac W=0.3U
+  L=0.03U NF=1
mick._addr_lat_3.i55.mxna1 ick._addr_lat_3.i55.n1 ick.a_p2[3] vss vpw nch_mac
+  W=0.1U L=0.03U NF=1
mick._addr_lat_3.i55.mxnoe ick.na_p2[3] ick.bclk ick._addr_lat_3.i55.n1 vpw
+  nch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_3.i55.mxpa1 ick._addr_lat_3.i55.p1 ick.a_p2[3] vddpe vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_3.i55.mxpoen ick.na_p2[3] ick.nclk ick._addr_lat_3.i55.p1 vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_4.i48.mxnoe ick.na_p2[4] ick.nclk na4 vpw nch_mac W=0.5U
+  L=0.03U NF=1
mick._addr_lat_4.i48.mxpoen ick.na_p2[4] ick.bclk na4 vnwp pch_mac W=0.5U
+  L=0.03U NF=1
mick._addr_lat_4.i50.mxna1 ick.a_p2[4] ick.na_p2[4] vss vpw nch_mac W=0.2U
+  L=0.03U NF=1
mick._addr_lat_4.i50.mxpa1 ick.a_p2[4] ick.na_p2[4] vddpe vnwp pch_mac W=0.3U
+  L=0.03U NF=1
mick._addr_lat_4.i55.mxna1 ick._addr_lat_4.i55.n1 ick.a_p2[4] vss vpw nch_mac
+  W=0.1U L=0.03U NF=1
mick._addr_lat_4.i55.mxnoe ick.na_p2[4] ick.bclk ick._addr_lat_4.i55.n1 vpw
+  nch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_4.i55.mxpa1 ick._addr_lat_4.i55.p1 ick.a_p2[4] vddpe vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_4.i55.mxpoen ick.na_p2[4] ick.nclk ick._addr_lat_4.i55.p1 vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_5.i48.mxnoe ick.na_p2[5] ick.nclk na5 vpw nch_mac W=0.5U
+  L=0.03U NF=1
mick._addr_lat_5.i48.mxpoen ick.na_p2[5] ick.bclk na5 vnwp pch_mac W=0.5U
+  L=0.03U NF=1
mick._addr_lat_5.i50.mxna1 ick.a_p2[5] ick.na_p2[5] vss vpw nch_mac W=0.2U
+  L=0.03U NF=1
mick._addr_lat_5.i50.mxpa1 ick.a_p2[5] ick.na_p2[5] vddpe vnwp pch_mac W=0.3U
+  L=0.03U NF=1
mick._addr_lat_5.i55.mxna1 ick._addr_lat_5.i55.n1 ick.a_p2[5] vss vpw nch_mac
+  W=0.1U L=0.03U NF=1
mick._addr_lat_5.i55.mxnoe ick.na_p2[5] ick.bclk ick._addr_lat_5.i55.n1 vpw
+  nch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_5.i55.mxpa1 ick._addr_lat_5.i55.p1 ick.a_p2[5] vddpe vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_5.i55.mxpoen ick.na_p2[5] ick.nclk ick._addr_lat_5.i55.p1 vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_6.i48.mxnoe ick.na_p2[6] ick.nclk na6 vpw nch_mac W=0.5U
+  L=0.03U NF=1
mick._addr_lat_6.i48.mxpoen ick.na_p2[6] ick.bclk na6 vnwp pch_mac W=0.5U
+  L=0.03U NF=1
mick._addr_lat_6.i50.mxna1 ick.a_p2[6] ick.na_p2[6] vss vpw nch_mac W=0.2U
+  L=0.03U NF=1
mick._addr_lat_6.i50.mxpa1 ick.a_p2[6] ick.na_p2[6] vddpe vnwp pch_mac W=0.3U
+  L=0.03U NF=1
mick._addr_lat_6.i55.mxna1 ick._addr_lat_6.i55.n1 ick.a_p2[6] vss vpw nch_mac
+  W=0.1U L=0.03U NF=1
mick._addr_lat_6.i55.mxnoe ick.na_p2[6] ick.bclk ick._addr_lat_6.i55.n1 vpw
+  nch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_6.i55.mxpa1 ick._addr_lat_6.i55.p1 ick.a_p2[6] vddpe vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_6.i55.mxpoen ick.na_p2[6] ick.nclk ick._addr_lat_6.i55.p1 vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_7.i48.mxnoe ick.na_p2[7] ick.nclk na7 vpw nch_mac W=0.5U
+  L=0.03U NF=1
mick._addr_lat_7.i48.mxpoen ick.na_p2[7] ick.bclk na7 vnwp pch_mac W=0.5U
+  L=0.03U NF=1
mick._addr_lat_7.i50.mxna1 ick.a_p2[7] ick.na_p2[7] vss vpw nch_mac W=0.2U
+  L=0.03U NF=1
mick._addr_lat_7.i50.mxpa1 ick.a_p2[7] ick.na_p2[7] vddpe vnwp pch_mac W=0.3U
+  L=0.03U NF=1
mick._addr_lat_7.i55.mxna1 ick._addr_lat_7.i55.n1 ick.a_p2[7] vss vpw nch_mac
+  W=0.1U L=0.03U NF=1
mick._addr_lat_7.i55.mxnoe ick.na_p2[7] ick.bclk ick._addr_lat_7.i55.n1 vpw
+  nch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_7.i55.mxpa1 ick._addr_lat_7.i55.p1 ick.a_p2[7] vddpe vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_7.i55.mxpoen ick.na_p2[7] ick.nclk ick._addr_lat_7.i55.p1 vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_8.i48.mxnoe ick.na_p2[8] ick.nclk na8 vpw nch_mac W=0.5U
+  L=0.03U NF=1
mick._addr_lat_8.i48.mxpoen ick.na_p2[8] ick.bclk na8 vnwp pch_mac W=0.5U
+  L=0.03U NF=1
mick._addr_lat_8.i50.mxna1 ick.a_p2[8] ick.na_p2[8] vss vpw nch_mac W=0.2U
+  L=0.03U NF=1
mick._addr_lat_8.i50.mxpa1 ick.a_p2[8] ick.na_p2[8] vddpe vnwp pch_mac W=0.3U
+  L=0.03U NF=1
mick._addr_lat_8.i55.mxna1 ick._addr_lat_8.i55.n1 ick.a_p2[8] vss vpw nch_mac
+  W=0.1U L=0.03U NF=1
mick._addr_lat_8.i55.mxnoe ick.na_p2[8] ick.bclk ick._addr_lat_8.i55.n1 vpw
+  nch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_8.i55.mxpa1 ick._addr_lat_8.i55.p1 ick.a_p2[8] vddpe vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_8.i55.mxpoen ick.na_p2[8] ick.nclk ick._addr_lat_8.i55.p1 vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_9.i48.mxnoe ick.na_p2[9] ick.nclk na9 vpw nch_mac W=0.5U
+  L=0.03U NF=1
mick._addr_lat_9.i48.mxpoen ick.na_p2[9] ick.bclk na9 vnwp pch_mac W=0.5U
+  L=0.03U NF=1
mick._addr_lat_9.i50.mxna1 ick.a_p2[9] ick.na_p2[9] vss vpw nch_mac W=0.2U
+  L=0.03U NF=1
mick._addr_lat_9.i50.mxpa1 ick.a_p2[9] ick.na_p2[9] vddpe vnwp pch_mac W=0.3U
+  L=0.03U NF=1
mick._addr_lat_9.i55.mxna1 ick._addr_lat_9.i55.n1 ick.a_p2[9] vss vpw nch_mac
+  W=0.1U L=0.03U NF=1
mick._addr_lat_9.i55.mxnoe ick.na_p2[9] ick.bclk ick._addr_lat_9.i55.n1 vpw
+  nch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_9.i55.mxpa1 ick._addr_lat_9.i55.p1 ick.a_p2[9] vddpe vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._addr_lat_9.i55.mxpoen ick.na_p2[9] ick.nclk ick._addr_lat_9.i55.p1 vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._assist.i127.mxna1 ick._assist.ndbl_turn dbl_nbl_wa_turn vss vpw nch_mac
+  W=0.22U L=0.035U NF=1
mick._assist.i127.mxpa1 ick._assist.ndbl_turn dbl_nbl_wa_turn vddpe vnwp
+  pch_mac W=0.3U L=0.035U NF=1
mick._assist.i128.mxna1 ick._assist.dummy_flip ick._assist.ndbl_turn vss vpw
+  nch_mac W=0.22U L=0.035U NF=1
mick._assist.i128.mxpa1 ick._assist.dummy_flip ick._assist.ndbl_turn vddpe
+  vnwp pch_mac W=0.3U L=0.035U NF=1
mick._assist.i129.mxna1 ick._assist.net035 ick._assist.dummy_flip vss vpw
+  nch_mac W=0.22U L=0.035U NF=1
mick._assist.i129.mxpa1 ick._assist.net035 ick._assist.dummy_flip vddpe vnwp
+  pch_mac W=0.3U L=0.035U NF=1
mick._assist.i137.mxna1 ick._assist.nwablm[0] wablm0 vss vpw nch_mac W=0.22U
+  L=0.035U NF=1
mick._assist.i137.mxpa1 ick._assist.nwablm[0] wablm0 vddpe vnwp pch_mac W=0.3U
+  L=0.035U NF=1
mick._assist.i138.i47.mxna1 ick._assist.i138.nd ick._assist.nwablm[0] vss vpw
+  nch_mac W=0.24U L=0.035U NF=1
mick._assist.i138.i47.mxpa1 ick._assist.i138.nd ick._assist.nwablm[0] vddpe
+  vnwp pch_mac W=0.48U L=0.035U NF=1
mick._assist.i138.i48.mxnoe wablm0_p2 ick.nclk ick._assist.i138.nd vpw nch_mac
+  W=0.24U L=0.035U NF=1
mick._assist.i138.i48.mxpoen wablm0_p2 ick.bclk ick._assist.i138.nd vnwp
+  pch_mac W=0.24U L=0.035U NF=1
mick._assist.i138.i50.mxna1 ick._assist.nwablm0_p2 wablm0_p2 vss vpw nch_mac
+  W=0.28U L=0.035U NF=1
mick._assist.i138.i50.mxpa1 ick._assist.nwablm0_p2 wablm0_p2 vddpe vnwp
+  pch_mac W=0.4U L=0.035U NF=1
mick._assist.i138.i55.mxna1 ick._assist.i138.i55.n1 ick._assist.nwablm0_p2 vss
+  vpw nch_mac W=0.1U L=0.035U NF=1
mick._assist.i138.i55.mxnoe wablm0_p2 ick.bclk ick._assist.i138.i55.n1 vpw
+  nch_mac W=0.1U L=0.035U NF=1
mick._assist.i138.i55.mxpa1 ick._assist.i138.i55.p1 ick._assist.nwablm0_p2
+  vddpe vnwp pch_mac W=0.1U L=0.035U NF=1
mick._assist.i138.i55.mxpoen wablm0_p2 ick.nclk ick._assist.i138.i55.p1 vnwp
+  pch_mac W=0.1U L=0.035U NF=1
mick._assist.i139.mxna1 ick._assist.nwablm[1] wablm1 vss vpw nch_mac W=0.22U
+  L=0.035U NF=1
mick._assist.i139.mxpa1 ick._assist.nwablm[1] wablm1 vddpe vnwp pch_mac W=0.3U
+  L=0.035U NF=1
mick._assist.i14.mxna1 wa_en_left ick._assist.net020 vss vpw nch_mac W=2.4U
+  L=0.035U NF=6
mick._assist.i14.mxpa1 wa_en_left ick._assist.net020 vddpe vnwp pch_mac W=2.4U
+  L=0.035U NF=6
mick._assist.i140.i47.mxna1 ick._assist.i140.nd ick._assist.nwablm[1] vss vpw
+  nch_mac W=0.24U L=0.035U NF=1
mick._assist.i140.i47.mxpa1 ick._assist.i140.nd ick._assist.nwablm[1] vddpe
+  vnwp pch_mac W=0.48U L=0.035U NF=1
mick._assist.i140.i48.mxnoe ick._assist.wablm1_p2 ick.nclk ick._assist.i140.nd
+  vpw nch_mac W=0.24U L=0.035U NF=1
mick._assist.i140.i48.mxpoen ick._assist.wablm1_p2 ick.bclk
+  ick._assist.i140.nd vnwp pch_mac W=0.24U L=0.035U NF=1
mick._assist.i140.i50.mxna1 ick._assist.nwablm1_p2 ick._assist.wablm1_p2 vss
+  vpw nch_mac W=0.28U L=0.035U NF=1
mick._assist.i140.i50.mxpa1 ick._assist.nwablm1_p2 ick._assist.wablm1_p2 vddpe
+  vnwp pch_mac W=0.4U L=0.035U NF=1
mick._assist.i140.i55.mxna1 ick._assist.i140.i55.n1 ick._assist.nwablm1_p2 vss
+  vpw nch_mac W=0.1U L=0.035U NF=1
mick._assist.i140.i55.mxnoe ick._assist.wablm1_p2 ick.bclk
+  ick._assist.i140.i55.n1 vpw nch_mac W=0.1U L=0.035U NF=1
mick._assist.i140.i55.mxpa1 ick._assist.i140.i55.p1 ick._assist.nwablm1_p2
+  vddpe vnwp pch_mac W=0.1U L=0.035U NF=1
mick._assist.i140.i55.mxpoen ick._assist.wablm1_p2 ick.nclk
+  ick._assist.i140.i55.p1 vnwp pch_mac W=0.1U L=0.035U NF=1
mick._assist.i142.mxna1 ick._assist.nwablm0_out wablm0_p2_prog vss vpw nch_mac
+  W=0.22U L=0.035U NF=1
mick._assist.i142.mxpa1 ick._assist.nwablm0_out wablm0_p2_prog vddpe vnwp
+  pch_mac W=0.3U L=0.035U NF=1
mick._assist.i143.mxna1 wablm0_left ick._assist.nwablm0_out vss vpw nch_mac
+  W=1U L=0.035U NF=1
mick._assist.i143.mxpa1 wablm0_left ick._assist.nwablm0_out vddpe vnwp pch_mac
+  W=1U L=0.035U NF=1
mick._assist.i144.mxna1 wablm0_right ick._assist.nwablm0_out vss vpw nch_mac
+  W=1U L=0.035U NF=1
mick._assist.i144.mxpa1 wablm0_right ick._assist.nwablm0_out vddpe vnwp
+  pch_mac W=1U L=0.035U NF=1
mick._assist.i149.mxna1 wa_en_right ick._assist.net020 vss vpw nch_mac W=2.4U
+  L=0.035U NF=6
mick._assist.i149.mxpa1 wa_en_right ick._assist.net020 vddpe vnwp pch_mac
+  W=2.4U L=0.035U NF=6
mick._assist.i150.mxna1 ick._assist.dummy_flip3 ick._assist.net035 vss vpw
+  nch_mac W=0.18U L=0.03U NF=1
mick._assist.i150.mxna2 ick._assist.dummy_flip3 ick._assist.nwablm1_p2 vss vpw
+  nch_mac W=0.18U L=0.03U NF=1
mick._assist.i150.mxpa1 ick._assist.dummy_flip3 ick._assist.net035
+  ick._assist.i150.p1 vnwp pch_mac W=0.4U L=0.03U NF=1
mick._assist.i150.mxpa2 ick._assist.i150.p1 ick._assist.nwablm1_p2 vddpe vnwp
+  pch_mac W=0.4U L=0.03U NF=1
mick._assist.i152.mxna1 ick._assist.net020 ick._assist.net022 vss vpw nch_mac
+  W=1.2U L=0.035U NF=2
mick._assist.i152.mxpa1 ick._assist.net020 ick._assist.net022 vddpe vnwp
+  pch_mac W=0.5U L=0.035U NF=2
mick._assist.i153.mxna1 ick._assist.net036 log0 vss vpw nch_mac W=0.22U
+  L=0.035U NF=1
mick._assist.i153.mxpa1 ick._assist.net036 log0 vddpe vnwp pch_mac W=0.3U
+  L=0.035U NF=1
mick._assist.i154.mxna1 ick._assist.net034 ick._assist.net036 vss vpw nch_mac
+  W=0.22U L=0.035U NF=1
mick._assist.i154.mxpa1 ick._assist.net034 ick._assist.net036 vddpe vnwp
+  pch_mac W=0.3U L=0.035U NF=1
mick._assist.i155.mxna1 ick._assist.net040 ick._assist.net034 vss vpw nch_mac
+  W=0.22U L=0.035U NF=1
mick._assist.i155.mxpa1 ick._assist.net040 ick._assist.net034 vddpe vnwp
+  pch_mac W=0.3U L=0.035U NF=1
mick._assist.i166.mxna1 ick._assist.wa_en_local ick.gwen_p2 vss vpw nch_mac
+  W=0.4U L=0.035U NF=1
mick._assist.i166.mxna2 ick._assist.wa_en_local ick.dft_p2 vss vpw nch_mac
+  W=0.4U L=0.035U NF=1
mick._assist.i166.mxna3 ick._assist.wa_en_local ick._assist.nwabl_lat vss vpw
+  nch_mac W=0.4U L=0.035U NF=1
mick._assist.i166.mxpa1 ick._assist.wa_en_local ick.gwen_p2
+  ick._assist.i166.p2 vnwp pch_mac W=0.4U L=0.035U NF=1
mick._assist.i166.mxpa2 ick._assist.i166.p2 ick.dft_p2 ick._assist.i166.p1
+  vnwp pch_mac W=0.4U L=0.035U NF=1
mick._assist.i166.mxpa3 ick._assist.i166.p1 ick._assist.nwabl_lat vddpe vnwp
+  pch_mac W=0.4U L=0.035U NF=1
mick._assist.i74.mxna1 ick._assist.nwabl wabl vss vpw nch_mac W=0.22U L=0.035U
+  NF=1
mick._assist.i74.mxpa1 ick._assist.nwabl wabl vddpe vnwp pch_mac W=0.3U
+  L=0.035U NF=1
mick._assist.i92.mxna1 ick.float ick._assist.net040 vss vpw nch_mac W=0.6U
+  L=0.035U NF=2
mick._assist.i92.mxpa1 ick.float ick._assist.net040 vddpe vnwp pch_mac W=1.35U
+  L=0.035U NF=2
mick._assist.mxn3 ick._assist.net032 ick._assist.wa_en_local vss vpw nch_mac
+  W=1U L=0.035U NF=1
mick._assist.mxn4 dbl_nbl_wa gtp ick._assist.net032 vpw nch_mac W=0.5U
+  L=0.035U NF=1
mick._assist.mxn5 ick._assist.net045 ick._assist.wa_en_local vss vpw nch_mac
+  W=0.5U L=0.035U NF=1
mick._assist.mxn6 dbl_nbl_wa_el gtp ick._assist.net045 vpw nch_mac W=0.2U
+  L=0.035U NF=1
mick._assist.mxn7 ick._assist.net022 dbl_nbl_wa_turn vss vpw nch_mac W=3U
+  L=0.03U NF=1
mick._assist.mxn8 ick._assist.net022 ick._assist.dummy_flip3 vss vpw nch_mac
+  W=0.4U L=0.03U NF=1
mick._assist.mxp1 dbl_nbl_wa ick._assist.wa_en_local vddpe vnwp pch_mac W=1U
+  L=0.035U NF=1
mick._assist.mxp2 dbl_nbl_wa gtp vddpe vnwp pch_mac W=3U L=0.035U NF=1
mick._assist.mxp3 ick._assist.net056 ick._assist.dummy_flip3 vddpe vnwp
+  pch_mac W=1U L=0.03U NF=1
mick._assist.mxp4 ick._assist.net022 dbl_nbl_wa_turn ick._assist.net056 vnwp
+  pch_mac W=1U L=0.03U NF=1
mick._assist._xwabl_lat.i47.mxna1 ick._assist._xwabl_lat.nd ick._assist.nwabl
+  vss vpw nch_mac W=0.24U L=0.035U NF=1
mick._assist._xwabl_lat.i47.mxpa1 ick._assist._xwabl_lat.nd ick._assist.nwabl
+  vddpe vnwp pch_mac W=0.48U L=0.035U NF=1
mick._assist._xwabl_lat.i48.mxnoe ick._assist.wabl_lat ick.nclk
+  ick._assist._xwabl_lat.nd vpw nch_mac W=0.24U L=0.035U NF=1
mick._assist._xwabl_lat.i48.mxpoen ick._assist.wabl_lat ick.bclk
+  ick._assist._xwabl_lat.nd vnwp pch_mac W=0.24U L=0.035U NF=1
mick._assist._xwabl_lat.i50.mxna1 ick._assist.nwabl_lat ick._assist.wabl_lat
+  vss vpw nch_mac W=0.28U L=0.035U NF=1
mick._assist._xwabl_lat.i50.mxpa1 ick._assist.nwabl_lat ick._assist.wabl_lat
+  vddpe vnwp pch_mac W=0.4U L=0.035U NF=1
mick._assist._xwabl_lat.i55.mxna1 ick._assist._xwabl_lat.i55.n1
+  ick._assist.nwabl_lat vss vpw nch_mac W=0.1U L=0.035U NF=1
mick._assist._xwabl_lat.i55.mxnoe ick._assist.wabl_lat ick.bclk
+  ick._assist._xwabl_lat.i55.n1 vpw nch_mac W=0.1U L=0.035U NF=1
mick._assist._xwabl_lat.i55.mxpa1 ick._assist._xwabl_lat.i55.p1
+  ick._assist.nwabl_lat vddpe vnwp pch_mac W=0.1U L=0.035U NF=1
mick._assist._xwabl_lat.i55.mxpoen ick._assist.wabl_lat ick.nclk
+  ick._assist._xwabl_lat.i55.p1 vnwp pch_mac W=0.1U L=0.035U NF=1
mick._blprech.i29.mxna1 blprech_l ick._blprech.nblprech_l vss vpw nch_mac
+  W=4.5U L=0.03U NF=4
mick._blprech.i29.mxpa1 blprech_l ick._blprech.nblprech_l vddpe vnwp pch_mac
+  W=2.8U L=0.03U NF=4
mick._blprech.i36.mxna1 blprech_r ick._blprech.nblprech_r vss vpw nch_mac
+  W=4.5U L=0.03U NF=4
mick._blprech.i36.mxpa1 blprech_r ick._blprech.nblprech_r vddpe vnwp pch_mac
+  W=2.8U L=0.03U NF=4
mick._blprech.i52.mxna1 ick._blprech.dgtp ick._blprech.yr01 vss vpw nch_mac
+  W=0.3U L=0.03U NF=1
mick._blprech.i52.mxna2 ick._blprech.dgtp ick._blprech.yr23 vss vpw nch_mac
+  W=0.3U L=0.03U NF=1
mick._blprech.i52.mxpa1 ick._blprech.dgtp ick._blprech.yr01
+  ick._blprech.i52.p1 vnwp pch_mac W=0.8U L=0.03U NF=1
mick._blprech.i52.mxpa2 ick._blprech.i52.p1 ick._blprech.yr23 vddpe vnwp
+  pch_mac W=0.8U L=0.03U NF=1
mick._blprech.i65.mxna1 ick._blprech.i65.n1 ick._blprech.nret1 vss vpw nch_mac
+  W=0.1U L=0.03U NF=1
mick._blprech.i65.mxnoe ick._blprech.ret2 ick._blprech.nret1
+  ick._blprech.i65.n1 vpw nch_mac W=0.1U L=0.03U NF=1
mick._blprech.i65.mxpa1 ick._blprech.i65.p1 ick._blprech.nret1 vddpe vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._blprech.i65.mxpoen ick._blprech.ret2 ick._blprech.nret1
+  ick._blprech.i65.p1 vnwp pch_mac W=0.1U L=0.03U NF=1
mick._blprech.i75.mxna1 ick._blprech.i75.n1 ick._blprech.ret1 vss vpw nch_mac
+  W=0.1U L=0.03U NF=1
mick._blprech.i75.mxnoe ick._blprech.nret1 ick._blprech.ret1
+  ick._blprech.i75.n1 vpw nch_mac W=0.1U L=0.03U NF=1
mick._blprech.i75.mxpa1 ick._blprech.i75.p1 ick._blprech.ret1 vddpe vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._blprech.i75.mxpoen ick._blprech.nret1 ick._blprech.ret1
+  ick._blprech.i75.p1 vnwp pch_mac W=0.1U L=0.03U NF=1
mick._blprech.i76.mxna1 ick._blprech.i76.n1 nret vss vpw nch_mac W=0.1U
+  L=0.03U NF=1
mick._blprech.i76.mxnoe ick._blprech.ret1 nret ick._blprech.i76.n1 vpw nch_mac
+  W=0.1U L=0.03U NF=1
mick._blprech.i76.mxpa1 ick._blprech.i76.p1 nret vddpe vnwp pch_mac W=0.1U
+  L=0.03U NF=1
mick._blprech.i76.mxpoen ick._blprech.ret1 nret ick._blprech.i76.p1 vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._blprech.i79.mxna1 ick._blprech.i79.n1 ick._blprech.ret2 vss vpw nch_mac
+  W=0.2U L=0.03U NF=1
mick._blprech.i79.mxnoe ick._blprech.nret2 ick._blprech.ret2
+  ick._blprech.i79.n1 vpw nch_mac W=0.2U L=0.03U NF=1
mick._blprech.i79.mxpa1 ick._blprech.i79.p1 ick._blprech.ret2 vddpe vnwp
+  pch_mac W=0.3U L=0.03U NF=1
mick._blprech.i79.mxpoen ick._blprech.nret2 ick._blprech.ret2
+  ick._blprech.i79.p1 vnwp pch_mac W=0.3U L=0.03U NF=1
mick._blprech.i82.mxna1 ick._blprech.yr01 ick.nblpreclk ick._blprech.i82.n2
+  vpw nch_mac W=0.3U L=0.03U NF=1
mick._blprech.i82.mxna2 ick._blprech.i82.n2 nyr0 ick._blprech.i82.n1 vpw
+  nch_mac W=0.3U L=0.03U NF=1
mick._blprech.i82.mxna3 ick._blprech.i82.n1 nyr1 vss vpw nch_mac W=0.3U
+  L=0.03U NF=1
mick._blprech.i82.mxpa1 ick._blprech.yr01 ick.nblpreclk vddpe vnwp pch_mac
+  W=0.2U L=0.03U NF=1
mick._blprech.i82.mxpa2 ick._blprech.yr01 nyr0 vddpe vnwp pch_mac W=0.2U
+  L=0.03U NF=1
mick._blprech.i82.mxpa3 ick._blprech.yr01 nyr1 vddpe vnwp pch_mac W=0.2U
+  L=0.03U NF=1
mick._blprech.i83.mxna1 ick._blprech.yr23 nyr2 ick._blprech.i83.n1 vpw nch_mac
+  W=0.3U L=0.03U NF=1
mick._blprech.i83.mxna2 ick._blprech.i83.n1 nyr3 vss vpw nch_mac W=0.3U
+  L=0.03U NF=1
mick._blprech.i83.mxpa1 ick._blprech.yr23 nyr2 vddpe vnwp pch_mac W=0.2U
+  L=0.03U NF=1
mick._blprech.i83.mxpa2 ick._blprech.yr23 nyr3 vddpe vnwp pch_mac W=0.2U
+  L=0.03U NF=1
mick._blprech.mxn10 ick._blprech.net56 ick._blprech.nret2 vss vpw nch_mac
+  W=0.7U L=0.03U NF=1
mick._blprech.mxn11 ick._blprech.net54 ick._blprech.dgtp ick._blprech.net55
+  vpw nch_mac W=0.7U L=0.03U NF=1
mick._blprech.mxn12 ick._blprech.net57 ick._blprech.dgtp ick._blprech.net56
+  vpw nch_mac W=0.7U L=0.03U NF=1
mick._blprech.mxn13 ick._blprech.nblprech_l ick.nblpreclk ick._blprech.net54
+  vpw nch_mac W=0.7U L=0.03U NF=1
mick._blprech.mxn14 ick._blprech.nblprech_l ick.nblpreclk ick._blprech.net57
+  vpw nch_mac W=0.7U L=0.03U NF=1
mick._blprech.mxn3 ick._blprech.net60 nret vss vpw nch_mac W=0.7U L=0.03U NF=1
mick._blprech.mxn4 ick._blprech.net61 ick._blprech.dgtp ick._blprech.net60 vpw
+  nch_mac W=0.7U L=0.03U NF=1
mick._blprech.mxn5 ick._blprech.nblprech_r ick.nblpreclk ick._blprech.net61
+  vpw nch_mac W=0.7U L=0.03U NF=1
mick._blprech.mxn6 ick._blprech.nblprech_r ick.nblpreclk ick._blprech.net59
+  vpw nch_mac W=0.7U L=0.03U NF=1
mick._blprech.mxn7 ick._blprech.net59 ick._blprech.dgtp ick._blprech.net58 vpw
+  nch_mac W=0.7U L=0.03U NF=1
mick._blprech.mxn8 ick._blprech.net58 nret vss vpw nch_mac W=0.7U L=0.03U NF=1
mick._blprech.mxn9 ick._blprech.net55 ick._blprech.nret2 vss vpw nch_mac
+  W=0.7U L=0.03U NF=1
mick._blprech.mxp1 ick._blprech.nblprech_r nret vddpe vnwp pch_mac W=0.9U
+  L=0.03U NF=2
mick._blprech.mxp2 ick._blprech.nblprech_r ick._blprech.dgtp vddpe vnwp
+  pch_mac W=0.9U L=0.03U NF=2
mick._blprech.mxp3 ick._blprech.nblprech_r ick.nblpreclk vddpe vnwp pch_mac
+  W=0.9U L=0.03U NF=2
mick._blprech.mxp4 ick._blprech.nblprech_l ick.nblpreclk vddpe vnwp pch_mac
+  W=0.9U L=0.03U NF=2
mick._blprech.mxp5 ick._blprech.nblprech_l ick._blprech.dgtp vddpe vnwp
+  pch_mac W=0.9U L=0.03U NF=2
mick._blprech.mxp6 ick._blprech.nblprech_l ick._blprech.nret2 vddpe vnwp
+  pch_mac W=0.9U L=0.03U NF=2
mick._ckgen.iema.i220.mxna1 ick._ckgen.iema.gwen_sa ick._ckgen.iema.gwe_sa vss
+  vpw nch_mac W=0.4U L=0.03U NF=2
mick._ckgen.iema.i220.mxpa1 ick._ckgen.iema.gwen_sa ick._ckgen.iema.gwe_sa
+  vddpe vnwp pch_mac W=0.6U L=0.03U NF=2
mick._ckgen.iema.i249.mxna1 ick.nsetsa ick.gtpsa_split ick._ckgen.iema.i249.n1
+  vpw nch_mac W=2U L=0.03U NF=2
mick._ckgen.iema.i249.mxna2 ick._ckgen.iema.i249.n1 ick._ckgen.iema.gwen_sa
+  vss vpw nch_mac W=2U L=0.03U NF=2
mick._ckgen.iema.i249.mxpa1 ick.nsetsa ick.gtpsa_split vddpe vnwp pch_mac W=1U
+  L=0.03U NF=2
mick._ckgen.iema.i249.mxpa2 ick.nsetsa ick._ckgen.iema.gwen_sa vddpe vnwp
+  pch_mac W=1U L=0.03U NF=2
mick._ckgen.iema.i51.mxna1 ick._ckgen.iema.nwdly ick._ckgen.iema.iwdly vss vpw
+  nch_mac W=0.12U L=0.03U NF=1
mick._ckgen.iema.i51.mxpa1 ick._ckgen.iema.nwdly ick._ckgen.iema.iwdly vddpe
+  vnwp pch_mac W=0.2U L=0.03U NF=1
mick._ckgen.iema.i52.mxna1 ick._ckgen.iema.wdly ick._ckgen.iema.nwdly vss vpw
+  nch_mac W=0.2U L=0.03U NF=1
mick._ckgen.iema.i52.mxpa1 ick._ckgen.iema.wdly ick._ckgen.iema.nwdly vddpe
+  vnwp pch_mac W=0.12U L=0.03U NF=1
mick._ckgen.iema.i55.mxna1 ick._ckgen.iema.i55.n1 ick._ckgen.iema.gwen_sa vss
+  vpw nch_mac W=0.1U L=0.03U NF=1
mick._ckgen.iema.i55.mxnoe ick._ckgen.iema.gwe_sa ick.gtpsa_split
+  ick._ckgen.iema.i55.n1 vpw nch_mac W=0.1U L=0.03U NF=1
mick._ckgen.iema.i55.mxpa1 ick._ckgen.iema.i55.p1 ick._ckgen.iema.gwen_sa
+  vddpe vnwp pch_mac W=0.1U L=0.03U NF=1
mick._ckgen.iema.i55.mxpoen ick._ckgen.iema.gwe_sa ick._ckgen.iema.ngtp_sa
+  ick._ckgen.iema.i55.p1 vnwp pch_mac W=0.1U L=0.03U NF=1
mick._ckgen.iema.i56.mxna1 ick._ckgen.reset ick._ckgen.iema.net37
+  ick._ckgen.iema.i56.n1 vpw nch_mac W=0.8U L=0.03U NF=1
mick._ckgen.iema.i56.mxnb1 ick._ckgen.iema.i56.n1 ick._ckgen.iema.wdly vss vpw
+  nch_mac W=0.8U L=0.03U NF=1
mick._ckgen.iema.i56.mxnb2 ick._ckgen.iema.i56.n1 ick._ckgen.iema.gwen_sa vss
+  vpw nch_mac W=0.8U L=0.03U NF=1
mick._ckgen.iema.i56.mxpa1 ick._ckgen.reset ick._ckgen.iema.net37 vddpe vnwp
+  pch_mac W=0.6U L=0.03U NF=1
mick._ckgen.iema.i56.mxpb1 ick._ckgen.reset ick._ckgen.iema.wdly
+  ick._ckgen.iema.i56.p1 vnwp pch_mac W=0.4U L=0.03U NF=1
mick._ckgen.iema.i56.mxpb2 ick._ckgen.iema.i56.p1 ick._ckgen.iema.gwen_sa
+  vddpe vnwp pch_mac W=0.4U L=0.03U NF=1
mick._ckgen.iema.i58.mxna1 ick._ckgen.iema.ngtp_sa ick.gtpsa_split vss vpw
+  nch_mac W=0.1U L=0.03U NF=1
mick._ckgen.iema.i58.mxpa1 ick._ckgen.iema.ngtp_sa ick.gtpsa_split vddpe vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._ckgen.iema.i61.mxna1 ick._ckgen.iema.net37 ick._ckgen.iema.net34 vss vpw
+  nch_mac W=0.2U L=0.03U NF=1
mick._ckgen.iema.i61.mxpa1 ick._ckgen.iema.net37 ick._ckgen.iema.net34 vddpe
+  vnwp pch_mac W=0.2U L=0.03U NF=1
mick._ckgen.iema.i63.mxna1 ick._ckgen.iema.gwe_dft ick.gwen_p2
+  ick._ckgen.iema.i63.n1 vpw nch_mac W=0.4U L=0.03U NF=1
mick._ckgen.iema.i63.mxna2 ick._ckgen.iema.i63.n1 ick.ndft_p2 vss vpw nch_mac
+  W=0.4U L=0.03U NF=1
mick._ckgen.iema.i63.mxpa1 ick._ckgen.iema.gwe_dft ick.gwen_p2 vddpe vnwp
+  pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.i63.mxpa2 ick._ckgen.iema.gwe_dft ick.ndft_p2 vddpe vnwp
+  pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.i65.mxnoe ick._ckgen.iema.gwe_sa ick._ckgen.iema.ngtp_sa
+  ick._ckgen.iema.gwe_dft vpw nch_mac W=0.2U L=0.03U NF=1
mick._ckgen.iema.i65.mxpoen ick._ckgen.iema.gwe_sa ick.gtpsa_split
+  ick._ckgen.iema.gwe_dft vnwp pch_mac W=0.2U L=0.03U NF=1
mick._ckgen.iema.i66.mxna1 ick._ckgen.iema.net34 dwl ick._ckgen.iema.i66.n1
+  vpw nch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.i66.mxna2 ick._ckgen.iema.i66.n1 ick.gtpsa_split vss vpw
+  nch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.i66.mxpa1 ick._ckgen.iema.net34 dwl vddpe vnwp pch_mac W=0.2U
+  L=0.03U NF=1
mick._ckgen.iema.i66.mxpa2 ick._ckgen.iema.net34 ick.gtpsa_split vddpe vnwp
+  pch_mac W=0.2U L=0.03U NF=1
mick._ckgen.iema.i68.mxna1 ick._ckgen.iema.ck_in dbl vss vpw nch_mac W=0.6U
+  L=0.03U NF=2
mick._ckgen.iema.i68.mxpa1 ick._ckgen.iema.ck_in dbl vddpe vnwp pch_mac W=1.2U
+  L=0.03U NF=2
mick._ckgen.iema.irmux._rdly0.mxn3 ick._ckgen.iema.irmux._rdly0.ndin
+  ick._ckgen.iema.irmux.ckmx1o ick._ckgen.iema.irmux._rdly0.n1 vpw nch_mac
+  W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rdly0.mxn4 ick._ckgen.iema.irmux.ckdly0
+  ick._ckgen.iema.irmux._rdly0.ndin vss vpw nch_mac W=0.2U L=0.03U NF=1
mick._ckgen.iema.irmux._rdly0.mxn9 ick._ckgen.iema.irmux._rdly0.n1
+  ick._ckgen.iema.irmux.ckmx1o vss vpw nch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rdly0.mxp0 ick._ckgen.iema.irmux._rdly0.ndin
+  ick._ckgen.iema.irmux.ckmx1o vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rdly0.mxp2 ick._ckgen.iema.irmux._rdly0.p1
+  ick._ckgen.iema.irmux._rdly0.ndin vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rdly0.mxp4 ick._ckgen.iema.irmux.ckdly0
+  ick._ckgen.iema.irmux._rdly0.ndin ick._ckgen.iema.irmux._rdly0.p1 vnwp
+  pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rdly1.mxn3 ick._ckgen.iema.irmux._rdly1.ndin
+  ick._ckgen.iema.irmux.ckdly2 ick._ckgen.iema.irmux._rdly1.n1 vpw nch_mac
+  W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rdly1.mxn4 ick._ckgen.iema.irmux.ckdly1
+  ick._ckgen.iema.irmux._rdly1.ndin vss vpw nch_mac W=0.2U L=0.03U NF=1
mick._ckgen.iema.irmux._rdly1.mxn9 ick._ckgen.iema.irmux._rdly1.n1
+  ick._ckgen.iema.irmux.ckdly2 vss vpw nch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rdly1.mxp0 ick._ckgen.iema.irmux._rdly1.ndin
+  ick._ckgen.iema.irmux.ckdly2 vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rdly1.mxp2 ick._ckgen.iema.irmux._rdly1.p1
+  ick._ckgen.iema.irmux._rdly1.ndin vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rdly1.mxp4 ick._ckgen.iema.irmux.ckdly1
+  ick._ckgen.iema.irmux._rdly1.ndin ick._ckgen.iema.irmux._rdly1.p1 vnwp
+  pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rdly2.mxn3 ick._ckgen.iema.irmux._rdly2.ndin
+  ick._ckgen.iema.ck_in ick._ckgen.iema.irmux._rdly2.n1 vpw nch_mac W=0.3U
+  L=0.03U NF=1
mick._ckgen.iema.irmux._rdly2.mxn4 ick._ckgen.iema.irmux.ckdly2
+  ick._ckgen.iema.irmux._rdly2.ndin vss vpw nch_mac W=0.2U L=0.03U NF=1
mick._ckgen.iema.irmux._rdly2.mxn9 ick._ckgen.iema.irmux._rdly2.n1
+  ick._ckgen.iema.ck_in vss vpw nch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rdly2.mxp0 ick._ckgen.iema.irmux._rdly2.ndin
+  ick._ckgen.iema.ck_in vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rdly2.mxp2 ick._ckgen.iema.irmux._rdly2.p1
+  ick._ckgen.iema.irmux._rdly2.ndin vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rdly2.mxp4 ick._ckgen.iema.irmux.ckdly2
+  ick._ckgen.iema.irmux._rdly2.ndin ick._ckgen.iema.irmux._rdly2.p1 vnwp
+  pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx0.i19.mxna1 ick._ckgen.iema.irmux._rmx0.nck_out
+  ick._ckgen.iema.irmux.ckmx1o ick._ckgen.iema.irmux._rmx0.i19.n1 vpw nch_mac
+  W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx0.i19.mxnb1 ick._ckgen.iema.irmux._rmx0.i19.n1
+  ick._ckgen.iema.irmux.ckdly0 vss vpw nch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx0.i19.mxnb2 ick._ckgen.iema.irmux._rmx0.i19.n1
+  ick._ckgen.iema.irmux._rmx0.sel_in vss vpw nch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx0.i19.mxpa1 ick._ckgen.iema.irmux._rmx0.nck_out
+  ick._ckgen.iema.irmux.ckmx1o vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx0.i19.mxpb1 ick._ckgen.iema.irmux._rmx0.nck_out
+  ick._ckgen.iema.irmux.ckdly0 ick._ckgen.iema.irmux._rmx0.i19.p1 vnwp
+  pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx0.i19.mxpb2 ick._ckgen.iema.irmux._rmx0.i19.p1
+  ick._ckgen.iema.irmux._rmx0.sel_in vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx0.i2.mxna1 ick._ckgen.iema.irmux._rmx0.sel_in
+  ema[0] vss vpw nch_mac W=0.1U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx0.i2.mxpa1 ick._ckgen.iema.irmux._rmx0.sel_in
+  ema[0] vddpe vnwp pch_mac W=0.1U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx0.i20.mxna1 ick._ckgen.iema.irmux.ckdly_in
+  ick._ckgen.iema.irmux._rmx0.nck_out vss vpw nch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx0.i20.mxpa1 ick._ckgen.iema.irmux.ckdly_in
+  ick._ckgen.iema.irmux._rmx0.nck_out vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx00.i2.mxna1 ick._ckgen.iema.irmux._rmx00.sel_in
+  ema[2] vss vpw nch_mac W=0.1U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx00.i2.mxpa1 ick._ckgen.iema.irmux._rmx00.sel_in
+  ema[2] vddpe vnwp pch_mac W=0.1U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx00.i24.mxna1 ick._ckgen.iema.irmux._rmx00.nck_out
+  ick._ckgen.iema.ck_in ick._ckgen.iema.irmux._rmx00.i24.n2 vpw nch_mac
+  W=0.9U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx00.i24.mxnb1 ick._ckgen.iema.irmux._rmx00.i24.n2
+  gtp ick._ckgen.iema.irmux._rmx00.i24.n1 vpw nch_mac W=0.9U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx00.i24.mxnc1 ick._ckgen.iema.irmux._rmx00.i24.n1
+  ick._ckgen.iema.irmux.ckdly_in vss vpw nch_mac W=0.9U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx00.i24.mxnc2 ick._ckgen.iema.irmux._rmx00.i24.n1
+  ick._ckgen.iema.irmux._rmx00.sel_in vss vpw nch_mac W=0.9U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx00.i24.mxpa1 ick._ckgen.iema.irmux._rmx00.nck_out
+  ick._ckgen.iema.ck_in vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx00.i24.mxpb1 ick._ckgen.iema.irmux._rmx00.nck_out
+  gtp vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx00.i24.mxpc1 ick._ckgen.iema.irmux._rmx00.nck_out
+  ick._ckgen.iema.irmux.ckdly_in ick._ckgen.iema.irmux._rmx00.i24.p1 vnwp
+  pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx00.i24.mxpc2 ick._ckgen.iema.irmux._rmx00.i24.p1
+  ick._ckgen.iema.irmux._rmx00.sel_in vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx00.i25.mxna1 ick.ck_emas
+  ick._ckgen.iema.irmux._rmx00.nck_out vss vpw nch_mac W=0.3U L=0.035U NF=1
mick._ckgen.iema.irmux._rmx00.i25.mxpa1 ick.ck_emas
+  ick._ckgen.iema.irmux._rmx00.nck_out vddpe vnwp pch_mac W=0.4U L=0.035U
+  NF=1
mick._ckgen.iema.irmux._rmx00.mxn4 ick._ckgen.iema.irmux._rmx00.net26
+  ick.ngtpemas vss vpw nch_mac W=0.8U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx00.mxn5 ick.gtpsa_split
+  ick._ckgen.iema.irmux._rmx00.nck_out ick._ckgen.iema.irmux._rmx00.net26 vpw
+  nch_mac W=0.8U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx00.mxn6 ick.gtpsa_split
+  ick._ckgen.iema.irmux._rmx00.nck_out ick._ckgen.iema.irmux._rmx00.net25 vpw
+  nch_mac W=0.8U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx00.mxn7 ick._ckgen.iema.irmux._rmx00.net25
+  ick.ngtpemas vss vpw nch_mac W=0.8U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx00.mxp2 ick.gtpsa_split ick.ngtpemas vddpe vnwp
+  pch_mac W=1.4U L=0.03U NF=2
mick._ckgen.iema.irmux._rmx00.mxp3 ick.gtpsa_split
+  ick._ckgen.iema.irmux._rmx00.nck_out vddpe vnwp pch_mac W=1.4U L=0.03U NF=2
mick._ckgen.iema.irmux._rmx1.i19.mxna1 ick._ckgen.iema.irmux._rmx1.nck_out
+  ick._ckgen.iema.ck_in ick._ckgen.iema.irmux._rmx1.i19.n1 vpw nch_mac W=0.3U
+  L=0.03U NF=1
mick._ckgen.iema.irmux._rmx1.i19.mxnb1 ick._ckgen.iema.irmux._rmx1.i19.n1
+  ick._ckgen.iema.irmux.ckdly1 vss vpw nch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx1.i19.mxnb2 ick._ckgen.iema.irmux._rmx1.i19.n1
+  ick._ckgen.iema.irmux._rmx1.sel_in vss vpw nch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx1.i19.mxpa1 ick._ckgen.iema.irmux._rmx1.nck_out
+  ick._ckgen.iema.ck_in vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx1.i19.mxpb1 ick._ckgen.iema.irmux._rmx1.nck_out
+  ick._ckgen.iema.irmux.ckdly1 ick._ckgen.iema.irmux._rmx1.i19.p1 vnwp
+  pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx1.i19.mxpb2 ick._ckgen.iema.irmux._rmx1.i19.p1
+  ick._ckgen.iema.irmux._rmx1.sel_in vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx1.i2.mxna1 ick._ckgen.iema.irmux._rmx1.sel_in
+  ema[1] vss vpw nch_mac W=0.1U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx1.i2.mxpa1 ick._ckgen.iema.irmux._rmx1.sel_in
+  ema[1] vddpe vnwp pch_mac W=0.1U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx1.i20.mxna1 ick._ckgen.iema.irmux.ckmx1o
+  ick._ckgen.iema.irmux._rmx1.nck_out vss vpw nch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema.irmux._rmx1.i20.mxpa1 ick._ckgen.iema.irmux.ckmx1o
+  ick._ckgen.iema.irmux._rmx1.nck_out vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema._wdly0.mxn3 ick._ckgen.iema._wdly0.ndin
+  ick._ckgen.iema.wclk00 vss vpw nch_mac W=0.12U L=0.03U NF=1
mick._ckgen.iema._wdly0.mxn4 ick._ckgen.iema.wclk01
+  ick._ckgen.iema._wdly0.ndin vss vpw nch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema._wdly0.mxp0 ick._ckgen.iema._wdly0.ndin
+  ick._ckgen.iema.wclk00 vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema._wdly0.mxp4 ick._ckgen.iema.wclk01
+  ick._ckgen.iema._wdly0.ndin vddpe vnwp pch_mac W=0.12U L=0.03U NF=1
mick._ckgen.iema._wdly1.mxn3 ick._ckgen.iema._wdly1.ndin
+  ick._ckgen.iema.dwclk10 ick._ckgen.iema._wdly1.n1 vpw nch_mac W=0.3U
+  L=0.03U NF=1
mick._ckgen.iema._wdly1.mxn4 ick._ckgen.iema.wclk11
+  ick._ckgen.iema._wdly1.ndin vss vpw nch_mac W=0.2U L=0.03U NF=1
mick._ckgen.iema._wdly1.mxn9 ick._ckgen.iema._wdly1.n1 ick._ckgen.iema.dwclk10
+  vss vpw nch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema._wdly1.mxp0 ick._ckgen.iema._wdly1.ndin
+  ick._ckgen.iema.dwclk10 vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema._wdly1.mxp2 ick._ckgen.iema._wdly1.p1
+  ick._ckgen.iema._wdly1.ndin vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema._wdly1.mxp4 ick._ckgen.iema.wclk11
+  ick._ckgen.iema._wdly1.ndin ick._ckgen.iema._wdly1.p1 vnwp pch_mac W=0.3U
+  L=0.03U NF=1
mick._ckgen.iema._wdly2.mxn3 ick._ckgen.iema._wdly2.ndin ick.gtpsa_split
+  ick._ckgen.iema._wdly2.n1 vpw nch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema._wdly2.mxn4 ick._ckgen.iema.dwclk10
+  ick._ckgen.iema._wdly2.ndin vss vpw nch_mac W=0.2U L=0.03U NF=1
mick._ckgen.iema._wdly2.mxn9 ick._ckgen.iema._wdly2.n1 ick.gtpsa_split vss vpw
+  nch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema._wdly2.mxp0 ick._ckgen.iema._wdly2.ndin ick.gtpsa_split vddpe
+  vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema._wdly2.mxp2 ick._ckgen.iema._wdly2.p1
+  ick._ckgen.iema._wdly2.ndin vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema._wdly2.mxp4 ick._ckgen.iema.dwclk10
+  ick._ckgen.iema._wdly2.ndin ick._ckgen.iema._wdly2.p1 vnwp pch_mac W=0.3U
+  L=0.03U NF=1
mick._ckgen.iema._wmx0.i19.mxna1 ick._ckgen.iema._wmx0.nck_out
+  ick._ckgen.iema.wclk00 ick._ckgen.iema._wmx0.i19.n1 vpw nch_mac W=0.42U
+  L=0.03U NF=1
mick._ckgen.iema._wmx0.i19.mxnb1 ick._ckgen.iema._wmx0.i19.n1
+  ick._ckgen.iema.wclk01 vss vpw nch_mac W=0.42U L=0.03U NF=1
mick._ckgen.iema._wmx0.i19.mxnb2 ick._ckgen.iema._wmx0.i19.n1
+  ick._ckgen.iema._wmx0.sel_in vss vpw nch_mac W=0.42U L=0.03U NF=1
mick._ckgen.iema._wmx0.i19.mxpa1 ick._ckgen.iema._wmx0.nck_out
+  ick._ckgen.iema.wclk00 vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema._wmx0.i19.mxpb1 ick._ckgen.iema._wmx0.nck_out
+  ick._ckgen.iema.wclk01 ick._ckgen.iema._wmx0.i19.p1 vnwp pch_mac W=0.3U
+  L=0.03U NF=1
mick._ckgen.iema._wmx0.i19.mxpb2 ick._ckgen.iema._wmx0.i19.p1
+  ick._ckgen.iema._wmx0.sel_in vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema._wmx0.i2.mxna1 ick._ckgen.iema._wmx0.sel_in emaw[0] vss vpw
+  nch_mac W=0.1U L=0.03U NF=1
mick._ckgen.iema._wmx0.i2.mxpa1 ick._ckgen.iema._wmx0.sel_in emaw[0] vddpe
+  vnwp pch_mac W=0.1U L=0.03U NF=1
mick._ckgen.iema._wmx0.i20.mxna1 ick._ckgen.iema.iwdly
+  ick._ckgen.iema._wmx0.nck_out vss vpw nch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema._wmx0.i20.mxpa1 ick._ckgen.iema.iwdly
+  ick._ckgen.iema._wmx0.nck_out vddpe vnwp pch_mac W=0.42U L=0.03U NF=1
mick._ckgen.iema._wmx1.i19.mxna1 ick._ckgen.iema._wmx1.nck_out ick.gtpsa_split
+  ick._ckgen.iema._wmx1.i19.n1 vpw nch_mac W=0.42U L=0.03U NF=1
mick._ckgen.iema._wmx1.i19.mxnb1 ick._ckgen.iema._wmx1.i19.n1
+  ick._ckgen.iema.wclk11 vss vpw nch_mac W=0.42U L=0.03U NF=1
mick._ckgen.iema._wmx1.i19.mxnb2 ick._ckgen.iema._wmx1.i19.n1
+  ick._ckgen.iema._wmx1.sel_in vss vpw nch_mac W=0.42U L=0.03U NF=1
mick._ckgen.iema._wmx1.i19.mxpa1 ick._ckgen.iema._wmx1.nck_out ick.gtpsa_split
+  vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema._wmx1.i19.mxpb1 ick._ckgen.iema._wmx1.nck_out
+  ick._ckgen.iema.wclk11 ick._ckgen.iema._wmx1.i19.p1 vnwp pch_mac W=0.3U
+  L=0.03U NF=1
mick._ckgen.iema._wmx1.i19.mxpb2 ick._ckgen.iema._wmx1.i19.p1
+  ick._ckgen.iema._wmx1.sel_in vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema._wmx1.i2.mxna1 ick._ckgen.iema._wmx1.sel_in emaw[1] vss vpw
+  nch_mac W=0.1U L=0.03U NF=1
mick._ckgen.iema._wmx1.i2.mxpa1 ick._ckgen.iema._wmx1.sel_in emaw[1] vddpe
+  vnwp pch_mac W=0.1U L=0.03U NF=1
mick._ckgen.iema._wmx1.i20.mxna1 ick._ckgen.iema.wclk00
+  ick._ckgen.iema._wmx1.nck_out vss vpw nch_mac W=0.3U L=0.03U NF=1
mick._ckgen.iema._wmx1.i20.mxpa1 ick._ckgen.iema.wclk00
+  ick._ckgen.iema._wmx1.nck_out vddpe vnwp pch_mac W=0.42U L=0.03U NF=1
mick._ckgen.mxn1 dwl ick._ckgen.ngtp vsse vpw nch_mac W=1.6U L=0.03U NF=4
mick._ckgen.mxp1 dwl ick._ckgen.ngtp vddpe vnwp pch_mac W=4U L=0.03U NF=4
mick._ckgen._memgtp.i26.mxna1 ick._ckgen._memgtp.ctr ick._ckgen._memgtp.nctr
+  vss vpw nch_mac W=0.52U L=0.03U NF=2
mick._ckgen._memgtp.i26.mxpa1 ick._ckgen._memgtp.ctr ick._ckgen._memgtp.nctr
+  vddpe vnwp pch_mac W=1.3U L=0.03U NF=2
mick._ckgen._memgtp.i27.mxna1 ick._ckgen._memgtp.bclk ick._ckgen._memgtp.nclk
+  vss vpw nch_mac W=0.12U L=0.03U NF=1
mick._ckgen._memgtp.i27.mxpa1 ick._ckgen._memgtp.bclk ick._ckgen._memgtp.nclk
+  vddpe vnwp pch_mac W=0.15U L=0.03U NF=1
mick._ckgen._memgtp.i28.mxnoe ick._ckgen._memgtp.ncedft_lat
+  ick._ckgen._memgtp.nclk cedft vpw nch_mac W=0.3U L=0.03U NF=1
mick._ckgen._memgtp.i28.mxpoen ick._ckgen._memgtp.ncedft_lat
+  ick._ckgen._memgtp.bclk cedft vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen._memgtp.i29.mxna1 ick._ckgen._memgtp.i29.n1
+  ick._ckgen._memgtp.nctr vss vpw nch_mac W=0.12U L=0.03U NF=1
mick._ckgen._memgtp.i29.mxnoe ick._ckgen._memgtp.ncedft_lat
+  ick._ckgen._memgtp.bclk ick._ckgen._memgtp.i29.n1 vpw nch_mac W=0.12U
+  L=0.03U NF=1
mick._ckgen._memgtp.i29.mxpa1 ick._ckgen._memgtp.i29.p1
+  ick._ckgen._memgtp.nctr vddpe vnwp pch_mac W=0.12U L=0.03U NF=1
mick._ckgen._memgtp.i29.mxpoen ick._ckgen._memgtp.ncedft_lat
+  ick._ckgen._memgtp.nclk ick._ckgen._memgtp.i29.p1 vnwp pch_mac W=0.12U
+  L=0.03U NF=1
mick._ckgen._memgtp.i6.mxna1 gtp ick._ckgen.ngtp vss vpw nch_mac W=4U L=0.03U
+  NF=8
mick._ckgen._memgtp.i6.mxpa1 gtp ick._ckgen.ngtp vddpe vnwp pch_mac W=8U
+  L=0.03U NF=8
mick._ckgen._memgtp.i68.mxna1 ick._ckgen._memgtp.feed ick._ckgen.ngtp vss vpw
+  nch_mac W=0.2U L=0.03U NF=1
mick._ckgen._memgtp.i68.mxpa1 ick._ckgen._memgtp.feed ick._ckgen.ngtp vddpe
+  vnwp pch_mac W=0.7U L=0.03U NF=1
mick._ckgen._memgtp.i7.mxna1 ick._ckgen._memgtp.nclk clk vss vpw nch_mac W=3U
+  L=0.03U NF=4
mick._ckgen._memgtp.i7.mxpa1 ick._ckgen._memgtp.nclk clk vddpe vnwp pch_mac
+  W=3U L=0.03U NF=4
mick._ckgen._memgtp.i74.mxna1 ick._ckgen._memgtp.nfeed ick._ckgen._memgtp.feed
+  vss vpw nch_mac W=0.2U L=0.03U NF=1
mick._ckgen._memgtp.i74.mxpa1 ick._ckgen._memgtp.nfeed ick._ckgen._memgtp.feed
+  vddpe vnwp pch_mac W=0.3U L=0.03U NF=1
mick._ckgen._memgtp.i83.mxna1 ick._ckgen._memgtp.nctr
+  ick._ckgen._memgtp.ncedft_lat ick._ckgen._memgtp.i83.n2 vpw nch_mac W=0.65U
+  L=0.03U NF=1
mick._ckgen._memgtp.i83.mxna2 ick._ckgen._memgtp.i83.n2 nret
+  ick._ckgen._memgtp.i83.n1 vpw nch_mac W=0.65U L=0.03U NF=1
mick._ckgen._memgtp.i83.mxna3 ick._ckgen._memgtp.i83.n1
+  ick._ckgen._memgtp.nfeed vss vpw nch_mac W=0.65U L=0.03U NF=1
mick._ckgen._memgtp.i83.mxpa1 ick._ckgen._memgtp.nctr
+  ick._ckgen._memgtp.ncedft_lat vddpe vnwp pch_mac W=0.4U L=0.03U NF=1
mick._ckgen._memgtp.i83.mxpa2 ick._ckgen._memgtp.nctr nret vddpe vnwp pch_mac
+  W=0.4U L=0.03U NF=1
mick._ckgen._memgtp.i83.mxpa3 ick._ckgen._memgtp.nctr ick._ckgen._memgtp.nfeed
+  vddpe vnwp pch_mac W=0.4U L=0.03U NF=1
mick._ckgen._memgtp.mxn0 ick._ckgen._memgtp.nclk ick._ckgen._memgtp.ctr
+  ick._ckgen.ngtp vpw nch_mac W=3U L=0.03U NF=4
mick._ckgen._memgtp.mxn2 ick._ckgen._memgtp.net031 nret vss vpw nch_mac W=0.5U
+  L=0.03U NF=1
mick._ckgen._memgtp.mxn7 ick._ckgen._memgtp.net0150 ick._ckgen._memgtp.feed
+  ick._ckgen._memgtp.net031 vpw nch_mac W=0.26U L=0.03U NF=1
mick._ckgen._memgtp.mxn8 ick._ckgen.ngtp ick._ckgen.reset
+  ick._ckgen._memgtp.net0150 vpw nch_mac W=0.26U L=0.03U NF=1
mick._ckgen._memgtp.mxp1 ick._ckgen.ngtp ick._ckgen.reset vddpe vnwp pch_mac
+  W=3U L=0.03U NF=4
mick._ckgen._memgtp.mxp2 ick._ckgen._memgtp.net127 ick._ckgen._memgtp.ctr
+  vddpe vnwp pch_mac W=0.48U L=0.03U NF=1
mick._ckgen._memgtp.mxp3 ick._ckgen._memgtp.net127 clk vddpe vnwp pch_mac
+  W=0.48U L=0.03U NF=1
mick._ckgen._memgtp.mxp5 ick._ckgen.ngtp ick._ckgen._memgtp.feed
+  ick._ckgen._memgtp.net127 vnwp pch_mac W=0.48U L=0.03U NF=1
mick._ckgen._memgtp.mxpclamp ick._ckgen.ngtp nret vddpe vnwp pch_mac W=0.3U
+  L=0.03U NF=1
mick._dftrambyp_lat.i47.mxna1 ick._dftrambyp_lat.nd log0 vss vpw nch_mac
+  W=0.5U L=0.03U NF=1
mick._dftrambyp_lat.i47.mxpa1 ick._dftrambyp_lat.nd log0 vddpe vnwp pch_mac
+  W=0.62U L=0.03U NF=2
mick._dftrambyp_lat.i48.mxnoe ick.indft_p2 ick.nclk ick._dftrambyp_lat.nd vpw
+  nch_mac W=0.5U L=0.03U NF=1
mick._dftrambyp_lat.i48.mxpoen ick.indft_p2 ick.bclk ick._dftrambyp_lat.nd
+  vnwp pch_mac W=0.5U L=0.03U NF=1
mick._dftrambyp_lat.i50.mxna1 ick.dft_p2 ick.indft_p2 vss vpw nch_mac W=0.2U
+  L=0.03U NF=1
mick._dftrambyp_lat.i50.mxpa1 ick.dft_p2 ick.indft_p2 vddpe vnwp pch_mac
+  W=0.3U L=0.03U NF=1
mick._dftrambyp_lat.i55.mxna1 ick._dftrambyp_lat.i55.n1 ick.dft_p2 vss vpw
+  nch_mac W=0.1U L=0.03U NF=1
mick._dftrambyp_lat.i55.mxnoe ick.indft_p2 ick.bclk ick._dftrambyp_lat.i55.n1
+  vpw nch_mac W=0.1U L=0.03U NF=1
mick._dftrambyp_lat.i55.mxpa1 ick._dftrambyp_lat.i55.p1 ick.dft_p2 vddpe vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._dftrambyp_lat.i55.mxpoen ick.indft_p2 ick.nclk ick._dftrambyp_lat.i55.p1
+  vnwp pch_mac W=0.1U L=0.03U NF=1
mick._gwen_lat.i48.mxnoe ick.igwe_p2 ick.nclk ngwen vpw nch_mac W=0.5U L=0.03U
+  NF=1
mick._gwen_lat.i48.mxpoen ick.igwe_p2 ick.bclk ngwen vnwp pch_mac W=0.5U
+  L=0.03U NF=1
mick._gwen_lat.i50.mxna1 ick.gwen_p2 ick.igwe_p2 vss vpw nch_mac W=0.6U
+  L=0.03U NF=2
mick._gwen_lat.i50.mxpa1 ick.gwen_p2 ick.igwe_p2 vddpe vnwp pch_mac W=0.8U
+  L=0.03U NF=2
mick._gwen_lat.i55.mxna1 ick._gwen_lat.i55.n1 ick.gwen_p2 vss vpw nch_mac
+  W=0.1U L=0.03U NF=1
mick._gwen_lat.i55.mxnoe ick.igwe_p2 ick.bclk ick._gwen_lat.i55.n1 vpw nch_mac
+  W=0.1U L=0.03U NF=1
mick._gwen_lat.i55.mxpa1 ick._gwen_lat.i55.p1 ick.gwen_p2 vddpe vnwp pch_mac
+  W=0.1U L=0.03U NF=1
mick._gwen_lat.i55.mxpoen ick.igwe_p2 ick.nclk ick._gwen_lat.i55.p1 vnwp
+  pch_mac W=0.1U L=0.03U NF=1
mick._rdt_lat.i47.mxna1 ick._rdt_lat.nd rdt vss vpw nch_mac W=0.5U L=0.03U
+  NF=1
mick._rdt_lat.i47.mxpa1 ick._rdt_lat.nd rdt vddpe vnwp pch_mac W=0.82U L=0.03U
+  NF=2
mick._rdt_lat.i48.mxnoe ick.nrdt_p2 ick.nclk ick._rdt_lat.nd vpw nch_mac
+  W=0.5U L=0.03U NF=1
mick._rdt_lat.i48.mxpoen ick.nrdt_p2 ick.bclk ick._rdt_lat.nd vnwp pch_mac
+  W=0.5U L=0.03U NF=1
mick._rdt_lat.i50.mxna1 ick.rdt_p2 ick.nrdt_p2 vss vpw nch_mac W=0.2U L=0.03U
+  NF=1
mick._rdt_lat.i50.mxpa1 ick.rdt_p2 ick.nrdt_p2 vddpe vnwp pch_mac W=0.3U
+  L=0.03U NF=1
mick._rdt_lat.i55.mxna1 ick._rdt_lat.i55.n1 ick.rdt_p2 vss vpw nch_mac W=0.1U
+  L=0.03U NF=1
mick._rdt_lat.i55.mxnoe ick.nrdt_p2 ick.bclk ick._rdt_lat.i55.n1 vpw nch_mac
+  W=0.1U L=0.03U NF=1
mick._rdt_lat.i55.mxpa1 ick._rdt_lat.i55.p1 ick.rdt_p2 vddpe vnwp pch_mac
+  W=0.1U L=0.03U NF=1
mick._rdt_lat.i55.mxpoen ick.nrdt_p2 ick.nclk ick._rdt_lat.i55.p1 vnwp pch_mac
+  W=0.1U L=0.03U NF=1
mick._sense.delay.mxn3 ick._sense.gtpdly ick._sense.delay.ndin
+  ick._sense.delay.n1 vpw nch_mac W=0.3U L=0.03U NF=1
mick._sense.delay.mxn4 ick._sense.delay.ndin ick._sense.igtpdly vss vpw
+  nch_mac W=0.2U L=0.03U NF=1
mick._sense.delay.mxn9 ick._sense.delay.n1 ick._sense.delay.ndin vss vpw
+  nch_mac W=0.3U L=0.03U NF=1
mick._sense.delay.mxp0 ick._sense.gtpdly ick._sense.delay.ndin vddpe vnwp
+  pch_mac W=0.3U L=0.03U NF=1
mick._sense.delay.mxp2 ick._sense.delay.p1 ick._sense.igtpdly vddpe vnwp
+  pch_mac W=0.3U L=0.03U NF=1
mick._sense.delay.mxp4 ick._sense.delay.ndin ick._sense.igtpdly
+  ick._sense.delay.p1 vnwp pch_mac W=0.3U L=0.03U NF=1
mick._sense.delay1.mxn3 ick._sense.igtpdly ick._sense.delay1.ndin
+  ick._sense.delay1.n1 vpw nch_mac W=0.3U L=0.03U NF=1
mick._sense.delay1.mxn4 ick._sense.delay1.ndin ick.ck_emas vss vpw nch_mac
+  W=0.2U L=0.03U NF=1
mick._sense.delay1.mxn9 ick._sense.delay1.n1 ick._sense.delay1.ndin vss vpw
+  nch_mac W=0.3U L=0.03U NF=1
mick._sense.delay1.mxp0 ick._sense.igtpdly ick._sense.delay1.ndin vddpe vnwp
+  pch_mac W=0.3U L=0.03U NF=1
mick._sense.delay1.mxp2 ick._sense.delay1.p1 ick.ck_emas vddpe vnwp pch_mac
+  W=0.3U L=0.03U NF=1
mick._sense.delay1.mxp4 ick._sense.delay1.ndin ick.ck_emas
+  ick._sense.delay1.p1 vnwp pch_mac W=0.3U L=0.03U NF=1
mick._sense.i2.mxna1 ick.ngtpemas ick.ck_emas vss vpw nch_mac W=0.4U L=0.035U
+  NF=1
mick._sense.i2.mxnb1 ick.ngtpemas ick._sense.gtpdly ick._sense.i2.n1 vpw
+  nch_mac W=0.4U L=0.035U NF=1
mick._sense.i2.mxnb2 ick._sense.i2.n1 emas vss vpw nch_mac W=0.4U L=0.035U
+  NF=1
mick._sense.i2.mxpa1 ick.ngtpemas ick.ck_emas ick._sense.i2.p1 vnwp pch_mac
+  W=1U L=0.035U NF=1
mick._sense.i2.mxpb1 ick._sense.i2.p1 ick._sense.gtpdly vddpe vnwp pch_mac
+  W=1U L=0.035U NF=1
mick._sense.i2.mxpb2 ick._sense.i2.p1 emas vddpe vnwp pch_mac W=1U L=0.035U
+  NF=1
mick._sense.i3.mxna1 ick._sense.isae ick.nsetsa vss vpw nch_mac W=1U L=0.035U
+  NF=4
mick._sense.i3.mxpa1 ick._sense.isae ick.nsetsa vddpe vnwp pch_mac W=2.5U
+  L=0.035U NF=4
mick._sense.i6.mxna1 nsae_l ick._sense.isae vss vpw nch_mac W=5U L=0.035U NF=5
mick._sense.i6.mxpa1 nsae_l ick._sense.isae vddpe vnwp pch_mac W=4.6U L=0.035U
+  NF=5
mick._sense.i60.mxna1 nsae_r ick._sense.isae vss vpw nch_mac W=5U L=0.035U
+  NF=5
mick._sense.i60.mxpa1 nsae_r ick._sense.isae vddpe vnwp pch_mac W=4.6U
+  L=0.035U NF=5
mick._write.i1.mxna1 ick._write.nwclk1 gtp ick._write.i1.n1 vpw nch_mac W=1.9U
+  L=0.03U NF=1
mick._write.i1.mxna2 ick._write.i1.n1 ick.iwen1 vss vpw nch_mac W=1.9U L=0.03U
+  NF=1
mick._write.i1.mxpa1 ick._write.nwclk1 gtp vddpe vnwp pch_mac W=1U L=0.03U
+  NF=1
mick._write.i1.mxpa2 ick._write.nwclk1 ick.iwen1 vddpe vnwp pch_mac W=1U
+  L=0.03U NF=1
mick._write.i14.mxna1 iwclk0 ick._write.nwclk0 vss vpw nch_mac W=3U L=0.03U
+  NF=4
mick._write.i14.mxpa1 iwclk0 ick._write.nwclk0 vddpe vnwp pch_mac W=9U L=0.03U
+  NF=4
mick._write.i53.mxna1 ick._write.nwclk0 gtp ick._write.i53.n1 vpw nch_mac
+  W=1.9U L=0.03U NF=1
mick._write.i53.mxna2 ick._write.i53.n1 ick.iwen0 vss vpw nch_mac W=1.9U
+  L=0.03U NF=1
mick._write.i53.mxpa1 ick._write.nwclk0 gtp vddpe vnwp pch_mac W=1U L=0.03U
+  NF=1
mick._write.i53.mxpa2 ick._write.nwclk0 ick.iwen0 vddpe vnwp pch_mac W=1U
+  L=0.03U NF=1
mick._write.i67.mxna1 iwclk1 ick._write.nwclk1 vss vpw nch_mac W=3U L=0.03U
+  NF=4
mick._write.i67.mxpa1 iwclk1 ick._write.nwclk1 vddpe vnwp pch_mac W=9U L=0.03U
+  NF=4
mick._ydec.i19_0.mxna1 ick._ydec.ysel[0] ick.a_p2[1] vss vpw nch_mac W=0.15U
+  L=0.03U NF=1
mick._ydec.i19_0.mxna2 ick._ydec.ysel[0] ick.a_p2[0] vss vpw nch_mac W=0.15U
+  L=0.03U NF=1
mick._ydec.i19_0.mxpa1 ick._ydec.ysel[0] ick.a_p2[1] ick._ydec.i19_0.p1 vnwp
+  pch_mac W=0.3U L=0.03U NF=1
mick._ydec.i19_0.mxpa2 ick._ydec.i19_0.p1 ick.a_p2[0] vddpe vnwp pch_mac
+  W=0.3U L=0.03U NF=1
mick._ydec.i19_1.mxna1 ick._ydec.ysel[1] ick.a_p2[1] vss vpw nch_mac W=0.15U
+  L=0.03U NF=1
mick._ydec.i19_1.mxna2 ick._ydec.ysel[1] ick.na_p2[0] vss vpw nch_mac W=0.15U
+  L=0.03U NF=1
mick._ydec.i19_1.mxpa1 ick._ydec.ysel[1] ick.a_p2[1] ick._ydec.i19_1.p1 vnwp
+  pch_mac W=0.3U L=0.03U NF=1
mick._ydec.i19_1.mxpa2 ick._ydec.i19_1.p1 ick.na_p2[0] vddpe vnwp pch_mac
+  W=0.3U L=0.03U NF=1
mick._ydec.i19_2.mxna1 ick._ydec.ysel[2] ick.a_p2[1] vss vpw nch_mac W=0.15U
+  L=0.03U NF=1
mick._ydec.i19_2.mxna2 ick._ydec.ysel[2] ick.a_p2[0] vss vpw nch_mac W=0.15U
+  L=0.03U NF=1
mick._ydec.i19_2.mxpa1 ick._ydec.ysel[2] ick.a_p2[1] ick._ydec.i19_2.p1 vnwp
+  pch_mac W=0.3U L=0.03U NF=1
mick._ydec.i19_2.mxpa2 ick._ydec.i19_2.p1 ick.a_p2[0] vddpe vnwp pch_mac
+  W=0.3U L=0.03U NF=1
mick._ydec.i19_3.mxna1 ick._ydec.ysel[3] ick.a_p2[1] vss vpw nch_mac W=0.15U
+  L=0.03U NF=1
mick._ydec.i19_3.mxna2 ick._ydec.ysel[3] ick.na_p2[0] vss vpw nch_mac W=0.15U
+  L=0.03U NF=1
mick._ydec.i19_3.mxpa1 ick._ydec.ysel[3] ick.a_p2[1] ick._ydec.i19_3.p1 vnwp
+  pch_mac W=0.3U L=0.03U NF=1
mick._ydec.i19_3.mxpa2 ick._ydec.i19_3.p1 ick.na_p2[0] vddpe vnwp pch_mac
+  W=0.3U L=0.03U NF=1
mick._ydec.i21.mxna1 ick._ydec.dftrdt ick.nrdt_rd vss vpw nch_mac W=0.3U
+  L=0.03U NF=1
mick._ydec.i21.mxpa1 ick._ydec.dftrdt ick.nrdt_rd vddpe vnwp pch_mac W=0.45U
+  L=0.03U NF=1
mick._ydec.i9.mxna1 ick._ydec.gwe ick.gwen_p2 vss vpw nch_mac W=0.3U L=0.03U
+  NF=1
mick._ydec.i9.mxpa1 ick._ydec.gwe ick.gwen_p2 vddpe vnwp pch_mac W=0.45U
+  L=0.03U NF=1
mick._ydec.mxn0 ick._ydec.rd ick._ydec.gwe vss vpw nch_mac W=0.3U L=0.03U NF=2
mick._ydec.mxn1 ick._ydec.wr ick.gwen_p2 vss vpw nch_mac W=0.3U L=0.03U NF=2
mick._ydec.mxn2 ick._ydec.rd ick._ydec.dftrdt vss vpw nch_mac W=0.3U L=0.03U
+  NF=2
mick._ydec.mxn3 ick._ydec.wr ick._ydec.dftrdt vss vpw nch_mac W=0.3U L=0.03U
+  NF=2
mick._ydec.mxp0 ick._ydec.net37 ick._ydec.dftrdt vddpe vnwp pch_mac W=0.6U
+  L=0.03U NF=1
mick._ydec.mxp1 ick._ydec.rd ick._ydec.gwe ick._ydec.net37 vnwp pch_mac W=0.6U
+  L=0.03U NF=1
mick._ydec.mxp2 ick._ydec.net35 ick._ydec.dftrdt vddpe vnwp pch_mac W=0.6U
+  L=0.03U NF=1
mick._ydec.mxp3 ick._ydec.rd ick._ydec.gwe ick._ydec.net35 vnwp pch_mac W=0.6U
+  L=0.03U NF=1
mick._ydec.mxp4 ick._ydec.wr ick.gwen_p2 ick._ydec.net34 vnwp pch_mac W=0.4U
+  L=0.03U NF=1
mick._ydec.mxp5 ick._ydec.wr ick.gwen_p2 ick._ydec.net36 vnwp pch_mac W=0.4U
+  L=0.03U NF=1
mick._ydec.mxp6 ick._ydec.net36 ick._ydec.dftrdt vddpe vnwp pch_mac W=0.4U
+  L=0.03U NF=1
mick._ydec.mxp7 ick._ydec.net34 ick._ydec.dftrdt vddpe vnwp pch_mac W=0.4U
+  L=0.03U NF=1
mick._ydec._rmux_0.i39.mxna1 nyr0 ick._ydec._rmux_0.iyp vss vpw nch_mac
+  W=3.44U L=0.03U NF=4
mick._ydec._rmux_0.i39.mxpa1 nyr0 ick._ydec._rmux_0.iyp vddpe vnwp pch_mac
+  W=5.52U L=0.03U NF=4
mick._ydec._rmux_0.i46.mxna1 ick._ydec._rmux_0.iyp ick._ydec._rmux_0.inyp vss
+  vpw nch_mac W=0.88U L=0.04U NF=4
mick._ydec._rmux_0.i46.mxpa1 ick._ydec._rmux_0.iyp ick._ydec._rmux_0.inyp
+  vddpe vnwp pch_mac W=1.8U L=0.04U NF=4
mick._ydec._rmux_0.mxn0 ick._ydec._rmux_0.inyp ick._ydec.ysel[0] ick._ydec.rn1
+  vpw nch_mac W=0.4U L=0.03U NF=1
mick._ydec._rmux_0.mxn1 ick._ydec._rmux_0.n2 ick._ydec.rd vss vpw nch_mac
+  W=0.4U L=0.03U NF=1
mick._ydec._rmux_0.mxn2 ick._ydec.rn1 gtp ick._ydec._rmux_0.n2 vpw nch_mac
+  W=0.4U L=0.03U NF=1
mick._ydec._rmux_0.mxp0 ick._ydec._rmux_0.inyp ick._ydec.ysel[0] vddpe vnwp
+  pch_mac W=0.3U L=0.03U NF=1
mick._ydec._rmux_0.mxp1 ick._ydec._rmux_0.inyp ick._ydec.rd vddpe vnwp pch_mac
+  W=0.3U L=0.03U NF=1
mick._ydec._rmux_0.mxp2 ick._ydec._rmux_0.inyp gtp vddpe vnwp pch_mac W=0.3U
+  L=0.03U NF=1
mick._ydec._rmux_1.i39.mxna1 nyr1 ick._ydec._rmux_1.iyp vss vpw nch_mac
+  W=3.44U L=0.03U NF=4
mick._ydec._rmux_1.i39.mxpa1 nyr1 ick._ydec._rmux_1.iyp vddpe vnwp pch_mac
+  W=5.52U L=0.03U NF=4
mick._ydec._rmux_1.i46.mxna1 ick._ydec._rmux_1.iyp ick._ydec._rmux_1.inyp vss
+  vpw nch_mac W=0.88U L=0.04U NF=4
mick._ydec._rmux_1.i46.mxpa1 ick._ydec._rmux_1.iyp ick._ydec._rmux_1.inyp
+  vddpe vnwp pch_mac W=1.8U L=0.04U NF=4
mick._ydec._rmux_1.mxn0 ick._ydec._rmux_1.inyp ick._ydec.ysel[1] ick._ydec.rn1
+  vpw nch_mac W=0.4U L=0.03U NF=1
mick._ydec._rmux_1.mxn1 ick._ydec._rmux_1.n2 ick._ydec.rd vss vpw nch_mac
+  W=0.4U L=0.03U NF=1
mick._ydec._rmux_1.mxn2 ick._ydec.rn1 gtp ick._ydec._rmux_1.n2 vpw nch_mac
+  W=0.4U L=0.03U NF=1
mick._ydec._rmux_1.mxp0 ick._ydec._rmux_1.inyp ick._ydec.ysel[1] vddpe vnwp
+  pch_mac W=0.3U L=0.03U NF=1
mick._ydec._rmux_1.mxp1 ick._ydec._rmux_1.inyp ick._ydec.rd vddpe vnwp pch_mac
+  W=0.3U L=0.03U NF=1
mick._ydec._rmux_1.mxp2 ick._ydec._rmux_1.inyp gtp vddpe vnwp pch_mac W=0.3U
+  L=0.03U NF=1
mick._ydec._rmux_2.i39.mxna1 nyr2 ick._ydec._rmux_2.iyp vss vpw nch_mac
+  W=3.44U L=0.03U NF=4
mick._ydec._rmux_2.i39.mxpa1 nyr2 ick._ydec._rmux_2.iyp vddpe vnwp pch_mac
+  W=5.52U L=0.03U NF=4
mick._ydec._rmux_2.i46.mxna1 ick._ydec._rmux_2.iyp ick._ydec._rmux_2.inyp vss
+  vpw nch_mac W=0.88U L=0.04U NF=4
mick._ydec._rmux_2.i46.mxpa1 ick._ydec._rmux_2.iyp ick._ydec._rmux_2.inyp
+  vddpe vnwp pch_mac W=1.8U L=0.04U NF=4
mick._ydec._rmux_2.mxn0 ick._ydec._rmux_2.inyp ick._ydec.ysel[2] ick._ydec.rn1
+  vpw nch_mac W=0.4U L=0.03U NF=1
mick._ydec._rmux_2.mxn1 ick._ydec._rmux_2.n2 ick._ydec.rd vss vpw nch_mac
+  W=0.4U L=0.03U NF=1
mick._ydec._rmux_2.mxn2 ick._ydec.rn1 gtp ick._ydec._rmux_2.n2 vpw nch_mac
+  W=0.4U L=0.03U NF=1
mick._ydec._rmux_2.mxp0 ick._ydec._rmux_2.inyp ick._ydec.ysel[2] vddpe vnwp
+  pch_mac W=0.3U L=0.03U NF=1
mick._ydec._rmux_2.mxp1 ick._ydec._rmux_2.inyp ick._ydec.rd vddpe vnwp pch_mac
+  W=0.3U L=0.03U NF=1
mick._ydec._rmux_2.mxp2 ick._ydec._rmux_2.inyp gtp vddpe vnwp pch_mac W=0.3U
+  L=0.03U NF=1
mick._ydec._rmux_3.i39.mxna1 nyr3 ick._ydec._rmux_3.iyp vss vpw nch_mac
+  W=3.44U L=0.03U NF=4
mick._ydec._rmux_3.i39.mxpa1 nyr3 ick._ydec._rmux_3.iyp vddpe vnwp pch_mac
+  W=5.52U L=0.03U NF=4
mick._ydec._rmux_3.i46.mxna1 ick._ydec._rmux_3.iyp ick._ydec._rmux_3.inyp vss
+  vpw nch_mac W=0.88U L=0.04U NF=4
mick._ydec._rmux_3.i46.mxpa1 ick._ydec._rmux_3.iyp ick._ydec._rmux_3.inyp
+  vddpe vnwp pch_mac W=1.8U L=0.04U NF=4
mick._ydec._rmux_3.mxn0 ick._ydec._rmux_3.inyp ick._ydec.ysel[3] ick._ydec.rn1
+  vpw nch_mac W=0.4U L=0.03U NF=1
mick._ydec._rmux_3.mxn1 ick._ydec._rmux_3.n2 ick._ydec.rd vss vpw nch_mac
+  W=0.4U L=0.03U NF=1
mick._ydec._rmux_3.mxn2 ick._ydec.rn1 gtp ick._ydec._rmux_3.n2 vpw nch_mac
+  W=0.4U L=0.03U NF=1
mick._ydec._rmux_3.mxp0 ick._ydec._rmux_3.inyp ick._ydec.ysel[3] vddpe vnwp
+  pch_mac W=0.3U L=0.03U NF=1
mick._ydec._rmux_3.mxp1 ick._ydec._rmux_3.inyp ick._ydec.rd vddpe vnwp pch_mac
+  W=0.3U L=0.03U NF=1
mick._ydec._rmux_3.mxp2 ick._ydec._rmux_3.inyp gtp vddpe vnwp pch_mac W=0.3U
+  L=0.03U NF=1
mick._ydec._wmux_0.i39.mxna1 yw0_l ick._ydec._wmux_0.nyp vss vpw nch_mac
+  W=1.11U L=0.03U NF=2
mick._ydec._wmux_0.i39.mxpa1 yw0_l ick._ydec._wmux_0.nyp vddpe vnwp pch_mac
+  W=3U L=0.03U NF=2
mick._ydec._wmux_0.i54.mxna1 ick._ydec._wmux_0.nyp ick._ydec._wmux_0.iyp vss
+  vpw nch_mac W=0.66U L=0.04U NF=2
mick._ydec._wmux_0.i54.mxpa1 ick._ydec._wmux_0.nyp ick._ydec._wmux_0.iyp vddpe
+  vnwp pch_mac W=0.9U L=0.04U NF=2
mick._ydec._wmux_0.i56.mxna1 ick._ydec._wmux_0.iyp ick._ydec._wmux_0.inyp
+  ick._ydec._wmux_0.i56.n1 vpw nch_mac W=0.21U L=0.04U NF=1
mick._ydec._wmux_0.i56.mxna2 ick._ydec._wmux_0.i56.n1 ick._ydec._wmux_0.iinyp
+  vss vpw nch_mac W=0.21U L=0.04U NF=1
mick._ydec._wmux_0.i56.mxpa1 ick._ydec._wmux_0.iyp ick._ydec._wmux_0.inyp
+  vddpe vnwp pch_mac W=0.2U L=0.04U NF=1
mick._ydec._wmux_0.i56.mxpa2 ick._ydec._wmux_0.iyp ick._ydec._wmux_0.iinyp
+  vddpe vnwp pch_mac W=0.2U L=0.04U NF=1
mick._ydec._wmux_0.i57.mxna1 ick._ydec._wmux_0.iiyp ick._ydec._wmux_0.inyp vss
+  vpw nch_mac W=0.12U L=0.04U NF=1
mick._ydec._wmux_0.i57.mxpa1 ick._ydec._wmux_0.iiyp ick._ydec._wmux_0.inyp
+  vddpe vnwp pch_mac W=0.12U L=0.04U NF=1
mick._ydec._wmux_0.i60.mxna1 yw0_r ick._ydec._wmux_0.nyp vss vpw nch_mac
+  W=1.11U L=0.03U NF=2
mick._ydec._wmux_0.i60.mxpa1 yw0_r ick._ydec._wmux_0.nyp vddpe vnwp pch_mac
+  W=3U L=0.03U NF=2
mick._ydec._wmux_0.i61.mxna1 ick._ydec._wmux_0.iinyp ick._ydec._wmux_0.iiyp
+  vss vpw nch_mac W=0.12U L=0.04U NF=1
mick._ydec._wmux_0.i61.mxpa1 ick._ydec._wmux_0.iinyp ick._ydec._wmux_0.iiyp
+  vddpe vnwp pch_mac W=0.12U L=0.04U NF=1
mick._ydec._wmux_0.mxn0 ick._ydec._wmux_0.inyp ick._ydec.ysel[0] ick._ydec.wn1
+  vpw nch_mac W=0.2U L=0.03U NF=1
mick._ydec._wmux_0.mxn1 ick._ydec._wmux_0.n2 ick._ydec.wr vss vpw nch_mac
+  W=0.2U L=0.03U NF=1
mick._ydec._wmux_0.mxn2 ick._ydec.wn1 gtp ick._ydec._wmux_0.n2 vpw nch_mac
+  W=0.2U L=0.03U NF=1
mick._ydec._wmux_0.mxp0 ick._ydec._wmux_0.inyp ick._ydec.ysel[0] vddpe vnwp
+  pch_mac W=0.2U L=0.03U NF=1
mick._ydec._wmux_0.mxp1 ick._ydec._wmux_0.inyp ick._ydec.wr vddpe vnwp pch_mac
+  W=0.2U L=0.03U NF=1
mick._ydec._wmux_0.mxp2 ick._ydec._wmux_0.inyp gtp vddpe vnwp pch_mac W=0.2U
+  L=0.03U NF=1
mick._ydec._wmux_1.i39.mxna1 yw1_l ick._ydec._wmux_1.nyp vss vpw nch_mac
+  W=1.11U L=0.03U NF=2
mick._ydec._wmux_1.i39.mxpa1 yw1_l ick._ydec._wmux_1.nyp vddpe vnwp pch_mac
+  W=3U L=0.03U NF=2
mick._ydec._wmux_1.i54.mxna1 ick._ydec._wmux_1.nyp ick._ydec._wmux_1.iyp vss
+  vpw nch_mac W=0.66U L=0.04U NF=2
mick._ydec._wmux_1.i54.mxpa1 ick._ydec._wmux_1.nyp ick._ydec._wmux_1.iyp vddpe
+  vnwp pch_mac W=0.9U L=0.04U NF=2
mick._ydec._wmux_1.i56.mxna1 ick._ydec._wmux_1.iyp ick._ydec._wmux_1.inyp
+  ick._ydec._wmux_1.i56.n1 vpw nch_mac W=0.21U L=0.04U NF=1
mick._ydec._wmux_1.i56.mxna2 ick._ydec._wmux_1.i56.n1 ick._ydec._wmux_1.iinyp
+  vss vpw nch_mac W=0.21U L=0.04U NF=1
mick._ydec._wmux_1.i56.mxpa1 ick._ydec._wmux_1.iyp ick._ydec._wmux_1.inyp
+  vddpe vnwp pch_mac W=0.2U L=0.04U NF=1
mick._ydec._wmux_1.i56.mxpa2 ick._ydec._wmux_1.iyp ick._ydec._wmux_1.iinyp
+  vddpe vnwp pch_mac W=0.2U L=0.04U NF=1
mick._ydec._wmux_1.i57.mxna1 ick._ydec._wmux_1.iiyp ick._ydec._wmux_1.inyp vss
+  vpw nch_mac W=0.12U L=0.04U NF=1
mick._ydec._wmux_1.i57.mxpa1 ick._ydec._wmux_1.iiyp ick._ydec._wmux_1.inyp
+  vddpe vnwp pch_mac W=0.12U L=0.04U NF=1
mick._ydec._wmux_1.i60.mxna1 yw1_r ick._ydec._wmux_1.nyp vss vpw nch_mac
+  W=1.11U L=0.03U NF=2
mick._ydec._wmux_1.i60.mxpa1 yw1_r ick._ydec._wmux_1.nyp vddpe vnwp pch_mac
+  W=3U L=0.03U NF=2
mick._ydec._wmux_1.i61.mxna1 ick._ydec._wmux_1.iinyp ick._ydec._wmux_1.iiyp
+  vss vpw nch_mac W=0.12U L=0.04U NF=1
mick._ydec._wmux_1.i61.mxpa1 ick._ydec._wmux_1.iinyp ick._ydec._wmux_1.iiyp
+  vddpe vnwp pch_mac W=0.12U L=0.04U NF=1
mick._ydec._wmux_1.mxn0 ick._ydec._wmux_1.inyp ick._ydec.ysel[1] ick._ydec.wn1
+  vpw nch_mac W=0.2U L=0.03U NF=1
mick._ydec._wmux_1.mxn1 ick._ydec._wmux_1.n2 ick._ydec.wr vss vpw nch_mac
+  W=0.2U L=0.03U NF=1
mick._ydec._wmux_1.mxn2 ick._ydec.wn1 gtp ick._ydec._wmux_1.n2 vpw nch_mac
+  W=0.2U L=0.03U NF=1
mick._ydec._wmux_1.mxp0 ick._ydec._wmux_1.inyp ick._ydec.ysel[1] vddpe vnwp
+  pch_mac W=0.2U L=0.03U NF=1
mick._ydec._wmux_1.mxp1 ick._ydec._wmux_1.inyp ick._ydec.wr vddpe vnwp pch_mac
+  W=0.2U L=0.03U NF=1
mick._ydec._wmux_1.mxp2 ick._ydec._wmux_1.inyp gtp vddpe vnwp pch_mac W=0.2U
+  L=0.03U NF=1
mick._ydec._wmux_2.i39.mxna1 yw3_l ick._ydec._wmux_2.nyp vss vpw nch_mac
+  W=1.11U L=0.03U NF=2
mick._ydec._wmux_2.i39.mxpa1 yw3_l ick._ydec._wmux_2.nyp vddpe vnwp pch_mac
+  W=3U L=0.03U NF=2
mick._ydec._wmux_2.i54.mxna1 ick._ydec._wmux_2.nyp ick._ydec._wmux_2.iyp vss
+  vpw nch_mac W=0.66U L=0.04U NF=2
mick._ydec._wmux_2.i54.mxpa1 ick._ydec._wmux_2.nyp ick._ydec._wmux_2.iyp vddpe
+  vnwp pch_mac W=0.9U L=0.04U NF=2
mick._ydec._wmux_2.i56.mxna1 ick._ydec._wmux_2.iyp ick._ydec._wmux_2.inyp
+  ick._ydec._wmux_2.i56.n1 vpw nch_mac W=0.21U L=0.04U NF=1
mick._ydec._wmux_2.i56.mxna2 ick._ydec._wmux_2.i56.n1 ick._ydec._wmux_2.iinyp
+  vss vpw nch_mac W=0.21U L=0.04U NF=1
mick._ydec._wmux_2.i56.mxpa1 ick._ydec._wmux_2.iyp ick._ydec._wmux_2.inyp
+  vddpe vnwp pch_mac W=0.2U L=0.04U NF=1
mick._ydec._wmux_2.i56.mxpa2 ick._ydec._wmux_2.iyp ick._ydec._wmux_2.iinyp
+  vddpe vnwp pch_mac W=0.2U L=0.04U NF=1
mick._ydec._wmux_2.i57.mxna1 ick._ydec._wmux_2.iiyp ick._ydec._wmux_2.inyp vss
+  vpw nch_mac W=0.12U L=0.04U NF=1
mick._ydec._wmux_2.i57.mxpa1 ick._ydec._wmux_2.iiyp ick._ydec._wmux_2.inyp
+  vddpe vnwp pch_mac W=0.12U L=0.04U NF=1
mick._ydec._wmux_2.i60.mxna1 yw3_r ick._ydec._wmux_2.nyp vss vpw nch_mac
+  W=1.11U L=0.03U NF=2
mick._ydec._wmux_2.i60.mxpa1 yw3_r ick._ydec._wmux_2.nyp vddpe vnwp pch_mac
+  W=3U L=0.03U NF=2
mick._ydec._wmux_2.i61.mxna1 ick._ydec._wmux_2.iinyp ick._ydec._wmux_2.iiyp
+  vss vpw nch_mac W=0.12U L=0.04U NF=1
mick._ydec._wmux_2.i61.mxpa1 ick._ydec._wmux_2.iinyp ick._ydec._wmux_2.iiyp
+  vddpe vnwp pch_mac W=0.12U L=0.04U NF=1
mick._ydec._wmux_2.mxn0 ick._ydec._wmux_2.inyp ick._ydec.ysel[3] ick._ydec.wn1
+  vpw nch_mac W=0.2U L=0.03U NF=1
mick._ydec._wmux_2.mxn1 ick._ydec._wmux_2.n2 ick._ydec.wr vss vpw nch_mac
+  W=0.2U L=0.03U NF=1
mick._ydec._wmux_2.mxn2 ick._ydec.wn1 gtp ick._ydec._wmux_2.n2 vpw nch_mac
+  W=0.2U L=0.03U NF=1
mick._ydec._wmux_2.mxp0 ick._ydec._wmux_2.inyp ick._ydec.ysel[3] vddpe vnwp
+  pch_mac W=0.2U L=0.03U NF=1
mick._ydec._wmux_2.mxp1 ick._ydec._wmux_2.inyp ick._ydec.wr vddpe vnwp pch_mac
+  W=0.2U L=0.03U NF=1
mick._ydec._wmux_2.mxp2 ick._ydec._wmux_2.inyp gtp vddpe vnwp pch_mac W=0.2U
+  L=0.03U NF=1
mick._ydec._wmux_3.i39.mxna1 yw2_l ick._ydec._wmux_3.nyp vss vpw nch_mac
+  W=1.11U L=0.03U NF=2
mick._ydec._wmux_3.i39.mxpa1 yw2_l ick._ydec._wmux_3.nyp vddpe vnwp pch_mac
+  W=3U L=0.03U NF=2
mick._ydec._wmux_3.i54.mxna1 ick._ydec._wmux_3.nyp ick._ydec._wmux_3.iyp vss
+  vpw nch_mac W=0.66U L=0.04U NF=2
mick._ydec._wmux_3.i54.mxpa1 ick._ydec._wmux_3.nyp ick._ydec._wmux_3.iyp vddpe
+  vnwp pch_mac W=0.9U L=0.04U NF=2
mick._ydec._wmux_3.i56.mxna1 ick._ydec._wmux_3.iyp ick._ydec._wmux_3.inyp
+  ick._ydec._wmux_3.i56.n1 vpw nch_mac W=0.21U L=0.04U NF=1
mick._ydec._wmux_3.i56.mxna2 ick._ydec._wmux_3.i56.n1 ick._ydec._wmux_3.iinyp
+  vss vpw nch_mac W=0.21U L=0.04U NF=1
mick._ydec._wmux_3.i56.mxpa1 ick._ydec._wmux_3.iyp ick._ydec._wmux_3.inyp
+  vddpe vnwp pch_mac W=0.2U L=0.04U NF=1
mick._ydec._wmux_3.i56.mxpa2 ick._ydec._wmux_3.iyp ick._ydec._wmux_3.iinyp
+  vddpe vnwp pch_mac W=0.2U L=0.04U NF=1
mick._ydec._wmux_3.i57.mxna1 ick._ydec._wmux_3.iiyp ick._ydec._wmux_3.inyp vss
+  vpw nch_mac W=0.12U L=0.04U NF=1
mick._ydec._wmux_3.i57.mxpa1 ick._ydec._wmux_3.iiyp ick._ydec._wmux_3.inyp
+  vddpe vnwp pch_mac W=0.12U L=0.04U NF=1
mick._ydec._wmux_3.i60.mxna1 yw2_r ick._ydec._wmux_3.nyp vss vpw nch_mac
+  W=1.11U L=0.03U NF=2
mick._ydec._wmux_3.i60.mxpa1 yw2_r ick._ydec._wmux_3.nyp vddpe vnwp pch_mac
+  W=3U L=0.03U NF=2
mick._ydec._wmux_3.i61.mxna1 ick._ydec._wmux_3.iinyp ick._ydec._wmux_3.iiyp
+  vss vpw nch_mac W=0.12U L=0.04U NF=1
mick._ydec._wmux_3.i61.mxpa1 ick._ydec._wmux_3.iinyp ick._ydec._wmux_3.iiyp
+  vddpe vnwp pch_mac W=0.12U L=0.04U NF=1
mick._ydec._wmux_3.mxn0 ick._ydec._wmux_3.inyp ick._ydec.ysel[2] ick._ydec.wn1
+  vpw nch_mac W=0.2U L=0.03U NF=1
mick._ydec._wmux_3.mxn1 ick._ydec._wmux_3.n2 ick._ydec.wr vss vpw nch_mac
+  W=0.2U L=0.03U NF=1
mick._ydec._wmux_3.mxn2 ick._ydec.wn1 gtp ick._ydec._wmux_3.n2 vpw nch_mac
+  W=0.2U L=0.03U NF=1
mick._ydec._wmux_3.mxp0 ick._ydec._wmux_3.inyp ick._ydec.ysel[2] vddpe vnwp
+  pch_mac W=0.2U L=0.03U NF=1
mick._ydec._wmux_3.mxp1 ick._ydec._wmux_3.inyp ick._ydec.wr vddpe vnwp pch_mac
+  W=0.2U L=0.03U NF=1
mick._ydec._wmux_3.mxp2 ick._ydec._wmux_3.inyp gtp vddpe vnwp pch_mac W=0.2U
+  L=0.03U NF=1
.ends rf64x128ckm2_std_nbl_ast
****
.subckt rf64x128ck_blk dbl_nbl_wa_turn dbl_nbl_wa nact_cc nretnvt nactc actp
+  vddp_nor log0_sa gtp nla_p2[1] nla_p2[0] la_p2[1] la_p2[0] nra_p2[5]
+  nra_p2[4] nra_p2[3] nra_p2[2] nra_p2[1] nra_p2[0] ra_p2[5] ra_p2[4]
+  ra_p2[3] ra_p2[2] ra_p2[1] ra_p2[0] cen_p2 nret ret1n ema[0] ema[1] ema[2]
+  vddc vddce vddpe dbl penso_term pso1_term pso0_term log1 wablm1 wablm0 wabl
+  rawlm1 rawlm0 rawl emas emaw[0] emaw[1] vpw rdt gwen cen clk a0 a1 a2 a3 a4
+  a5 a6 a7 a8 a9 a10 vddp blprech_r yw3_r yw2_r yw1_r yw0_r nsae_r iwclk0
+  iwclk1 dwl dwl_turn wablm0_right wa_en_right blprech_l yw3_l yw2_l yw1_l
+  yw0_l nyr3 nyr2 nyr1 nyr0 rdmux nsae_l saprech wtdft log0 wablm0_left
+  wa_en_left
** rf64x128ck_blk: 767 flat devices **
xck blprech_l blprech_r cen_p2 gtp iwclk0 iwclk1 la_p2[0] la_p2[1] nact_cc
+  nla_p2[0] nla_p2[1] nra_p2[0] nra_p2[1] nra_p2[2] nra_p2[3] nra_p2[4]
+  nra_p2[5] nsae_l nsae_r nyr0 nyr1 nyr2 nyr3 ra_p2[0] ra_p2[1] ra_p2[2]
+  ra_p2[3] ra_p2[4] ra_p2[5] rdmux saprech wtdft yw0_l yw0_r yw1_l yw1_r
+  yw2_l yw2_r yw3_l yw3_r actp dbl dbl_nbl_wa dbl_nbl_wa dbl_nbl_wa_turn dwl
+  dwl_turn log0 log0_sa log1 nactc nretnvt penso_term pso0_term pso1_term
+  rawl rawlm0 rawlm1 ret1n vddc vddce vddp vddp_nor vddpe vddce vddpe vpw vpw
+  vpw wa_en_left wa_en_right wabl wablm0 wablm0_left wablm0_p2 log0
+  wablm0_right wablm1 a0 a1 a2 a3 a4 a5 a6 a7 a8 a9 a10 cen clk ema[0] ema[1]
+  ema[2] emas emaw[0] emaw[1] gwen nret log1 rdt rf64x128ckm2_std_nbl_ast
.ends rf64x128ck_blk
****
.subckt rf64x128iocdm_r bl3_31 nbl3_31 nbl2_31 bl2_31 vddc_31 bl1_31 nbl1_31
+  nbl0_31 bl0_31 bl3_30 nbl3_30 nbl2_30 bl2_30 vddc_30 bl1_30 nbl1_30 nbl0_30
+  bl0_30 bl3_29 nbl3_29 nbl2_29 bl2_29 vddc_29 bl1_29 nbl1_29 nbl0_29 bl0_29
+  bl3_28 nbl3_28 nbl2_28 bl2_28 vddc_28 bl1_28 nbl1_28 nbl0_28 bl0_28 bl3_27
+  nbl3_27 nbl2_27 bl2_27 vddc_27 bl1_27 nbl1_27 nbl0_27 bl0_27 bl3_26 nbl3_26
+  nbl2_26 bl2_26 vddc_26 bl1_26 nbl1_26 nbl0_26 bl0_26 bl3_25 nbl3_25 nbl2_25
+  bl2_25 vddc_25 bl1_25 nbl1_25 nbl0_25 bl0_25 bl3_24 nbl3_24 nbl2_24 bl2_24
+  vddc_24 bl1_24 nbl1_24 nbl0_24 bl0_24 bl3_23 nbl3_23 nbl2_23 bl2_23 vddc_23
+  bl1_23 nbl1_23 nbl0_23 bl0_23 bl3_22 nbl3_22 nbl2_22 bl2_22 vddc_22 bl1_22
+  nbl1_22 nbl0_22 bl0_22 bl3_21 nbl3_21 nbl2_21 bl2_21 vddc_21 bl1_21 nbl1_21
+  nbl0_21 bl0_21 bl3_20 nbl3_20 nbl2_20 bl2_20 vddc_20 bl1_20 nbl1_20 nbl0_20
+  bl0_20 bl3_19 nbl3_19 nbl2_19 bl2_19 vddc_19 bl1_19 nbl1_19 nbl0_19 bl0_19
+  bl3_18 nbl3_18 nbl2_18 bl2_18 vddc_18 bl1_18 nbl1_18 nbl0_18 bl0_18 bl3_17
+  nbl3_17 nbl2_17 bl2_17 vddc_17 bl1_17 nbl1_17 nbl0_17 bl0_17 bl3_16 nbl3_16
+  nbl2_16 bl2_16 vddc_16 bl1_16 nbl1_16 nbl0_16 bl0_16 bl3_15 nbl3_15 nbl2_15
+  bl2_15 vddc_15 bl1_15 nbl1_15 nbl0_15 bl0_15 bl3_14 nbl3_14 nbl2_14 bl2_14
+  vddc_14 bl1_14 nbl1_14 nbl0_14 bl0_14 bl3_13 nbl3_13 nbl2_13 bl2_13 vddc_13
+  bl1_13 nbl1_13 nbl0_13 bl0_13 bl3_12 nbl3_12 nbl2_12 bl2_12 vddc_12 bl1_12
+  nbl1_12 nbl0_12 bl0_12 bl3_11 nbl3_11 nbl2_11 bl2_11 vddc_11 bl1_11 nbl1_11
+  nbl0_11 bl0_11 bl3_10 nbl3_10 nbl2_10 bl2_10 vddc_10 bl1_10 nbl1_10 nbl0_10
+  bl0_10 bl3_9 nbl3_9 nbl2_9 bl2_9 vddc_9 bl1_9 nbl1_9 nbl0_9 bl0_9 bl3_8
+  nbl3_8 nbl2_8 bl2_8 vddc_8 bl1_8 nbl1_8 nbl0_8 bl0_8 bl3_7 nbl3_7 nbl2_7
+  bl2_7 vddc_7 bl1_7 nbl1_7 nbl0_7 bl0_7 bl3_6 nbl3_6 nbl2_6 bl2_6 vddc_6
+  bl1_6 nbl1_6 nbl0_6 bl0_6 bl3_5 nbl3_5 nbl2_5 bl2_5 vddc_5 vddce bl1_5
+  nbl1_5 nbl0_5 bl0_5 bl3_4 nbl3_4 nbl2_4 bl2_4 vddc_4 bl1_4 nbl1_4 nbl0_4
+  bl0_4 bl3_3 nbl3_3 nbl2_3 bl2_3 vddc_3 bl1_3 nbl1_3 nbl0_3 bl0_3 bl3_2
+  nbl3_2 nbl2_2 bl2_2 vddc_2 bl1_2 nbl1_2 nbl0_2 bl0_2 bl3_1 nbl3_1 nbl2_1
+  bl2_1 vddc_1 bl1_1 nbl1_1 nbl0_1 bl0_1 bl3_0 nbl3_0 nbl2_0 bl2_0 vddc_0
+  bl1_0 nbl1_0 nbl0_0 bl0_0 q1_31 d1_31 wen1_31 weny1_term_31 weny0_term_31
+  wen0_31 d0_31 q0_31 q1_30 d1_30 wen1_30 weny1_term_30 weny0_term_30 wen0_30
+  d0_30 q0_30 q1_29 d1_29 wen1_29 weny1_term_29 weny0_term_29 wen0_29 d0_29
+  q0_29 q1_28 d1_28 wen1_28 weny1_term_28 weny0_term_28 wen0_28 d0_28 q0_28
+  q1_27 d1_27 wen1_27 weny1_term_27 weny0_term_27 wen0_27 d0_27 vddp q0_27
+  q1_26 d1_26 wen1_26 weny1_term_26 weny0_term_26 wen0_26 d0_26 q0_26 q1_25
+  d1_25 wen1_25 weny1_term_25 weny0_term_25 wen0_25 d0_25 q0_25 q1_24 d1_24
+  wen1_24 weny1_term_24 weny0_term_24 wen0_24 d0_24 q0_24 q1_23 d1_23 wen1_23
+  weny1_term_23 weny0_term_23 wen0_23 d0_23 vpw q0_23 q1_22 d1_22 wen1_22
+  weny1_term_22 weny0_term_22 wen0_22 d0_22 q0_22 q1_21 d1_21 wen1_21
+  weny1_term_21 weny0_term_21 wen0_21 d0_21 q0_21 q1_20 d1_20 wen1_20
+  weny1_term_20 weny0_term_20 wen0_20 d0_20 q0_20 q1_19 d1_19 wen1_19
+  weny1_term_19 weny0_term_19 wen0_19 d0_19 q0_19 q1_18 d1_18 wen1_18
+  weny1_term_18 weny0_term_18 wen0_18 d0_18 q0_18 q1_17 d1_17 wen1_17
+  weny1_term_17 weny0_term_17 wen0_17 d0_17 q0_17 q1_16 d1_16 wen1_16
+  weny1_term_16 weny0_term_16 wen0_16 d0_16 q0_16 q1_15 d1_15 wen1_15
+  weny1_term_15 weny0_term_15 wen0_15 d0_15 q0_15 q1_14 d1_14 wen1_14
+  weny1_term_14 weny0_term_14 wen0_14 d0_14 q0_14 q1_13 d1_13 wen1_13
+  weny1_term_13 weny0_term_13 wen0_13 d0_13 q0_13 q1_12 d1_12 wen1_12
+  weny1_term_12 weny0_term_12 wen0_12 d0_12 q0_12 q1_11 d1_11 wen1_11
+  weny1_term_11 weny0_term_11 wen0_11 d0_11 q0_11 q1_10 d1_10 wen1_10
+  weny1_term_10 weny0_term_10 wen0_10 d0_10 q0_10 q1_9 d1_9 wen1_9
+  weny1_term_9 weny0_term_9 wen0_9 d0_9 q0_9 q1_8 d1_8 wen1_8 weny1_term_8
+  weny0_term_8 wen0_8 d0_8 q0_8 q1_7 d1_7 wen1_7 weny1_term_7 weny0_term_7
+  wen0_7 d0_7 q0_7 q1_6 d1_6 wen1_6 weny1_term_6 weny0_term_6 wen0_6 d0_6
+  q0_6 q1_5 d1_5 wen1_5 weny1_term_5 weny0_term_5 wen0_5 d0_5 q0_5 q1_4 d1_4
+  wen1_4 weny1_term_4 weny0_term_4 wen0_4 d0_4 q0_4 q1_3 d1_3 wen1_3
+  weny1_term_3 weny0_term_3 wen0_3 d0_3 q0_3 q1_2 d1_2 wen1_2 weny1_term_2
+  weny0_term_2 wen0_2 d0_2 q0_2 q1_1 d1_1 wen1_1 weny1_term_1 weny0_term_1
+  wen0_1 d0_1 q0_1 q1_0 d1_0 wen1_0 weny1_term_0 weny0_term_0 wen0_0 d0_0
+  q0_0 blprech nact_cc yw1 yw0 nyr1 nyr0 rdmux nsae saprech log0_sa iwclk0
+  iwclk1 dwl_main dwl_turn yw3 yw2 nyr3 nyr2 wtdft log0 dwl_mainbreak wablm0
+  wa_en
** rf64x128iocdm_r: 9152 flat devices **
xr_io_1 q0_1 q1_1 bl0_1 bl1_1 bl2_1 bl3_1 blprech cap_ctrl0_94 cap_ctrl1_96
+  cap_ctrl0_94 cap_ctrl1_96 d0_1 d1_1 dwl_mainbreak dwl_mainbreak
+  dwl_mainbreak dwl_mainbreak iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_1
+  nbl1_1 nbl2_1 nbl3_1 nsae nyr0 nyr1 nyr2 nyr3 rdmux saprech vddc_1 vddce
+  vddp vddp vddp vpw vpw vpw wa_en wablm0 wen0_1 wen1_1 weny0_term_1
+  weny1_term_1 wtdft yw0 yw1 yw2 yw3 rf64x128colm2x2_std_nbl_ast
xr_io_10 q0_10 q1_10 bl0_10 bl1_10 bl2_10 bl3_10 blprech cap_ctrl0_6
+  cap_ctrl1_8 cap_ctrl0_6 cap_ctrl1_8 d0_10 d1_10 dwl_mainbreak dwl_mainbreak
+  dwl_mainbreak dwl_mainbreak iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_10
+  nbl1_10 nbl2_10 nbl3_10 nsae nyr0 nyr1 nyr2 nyr3 rdmux saprech vddc_10
+  vddce vddp vddp vddp vpw vpw vpw wa_en wablm0 wen0_10 wen1_10 weny0_term_10
+  weny1_term_10 wtdft yw0 yw1 yw2 yw3 rf64x128colm2x2_std_nbl_ast
xr_io_11 q0_11 q1_11 bl0_11 bl1_11 bl2_11 bl3_11 blprech cap_ctrl0_10
+  cap_ctrl1_12 cap_ctrl0_10 cap_ctrl1_12 d0_11 d1_11 dwl_mainbreak
+  dwl_mainbreak dwl_mainbreak dwl_mainbreak iwclk0 iwclk1 log0 log0_sa
+  nact_cc nbl0_11 nbl1_11 nbl2_11 nbl3_11 nsae nyr0 nyr1 nyr2 nyr3 rdmux
+  saprech vddc_11 vddce vddp vddp vddp vpw vpw vpw wa_en wablm0 wen0_11
+  wen1_11 weny0_term_11 weny1_term_11 wtdft yw0 yw1 yw2 yw3
+  rf64x128colm2x2_std_nbl_ast
xr_io_12 q0_12 q1_12 bl0_12 bl1_12 bl2_12 bl3_12 blprech cap_ctrl0_18
+  cap_ctrl1_20 cap_ctrl0_18 cap_ctrl1_20 d0_12 d1_12 dwl_mainbreak
+  dwl_mainbreak dwl_mainbreak dwl_mainbreak iwclk0 iwclk1 log0 log0_sa
+  nact_cc nbl0_12 nbl1_12 nbl2_12 nbl3_12 nsae nyr0 nyr1 nyr2 nyr3 rdmux
+  saprech vddc_12 vddce vddp vddp vddp vpw vpw vpw wa_en wablm0 wen0_12
+  wen1_12 weny0_term_12 weny1_term_12 wtdft yw0 yw1 yw2 yw3
+  rf64x128colm2x2_std_nbl_ast
xr_io_13 q0_13 q1_13 bl0_13 bl1_13 bl2_13 bl3_13 blprech cap_ctrl0_22
+  cap_ctrl1_24 cap_ctrl0_22 cap_ctrl1_24 d0_13 d1_13 dwl_mainbreak
+  dwl_mainbreak dwl_mainbreak dwl_mainbreak iwclk0 iwclk1 log0 log0_sa
+  nact_cc nbl0_13 nbl1_13 nbl2_13 nbl3_13 nsae nyr0 nyr1 nyr2 nyr3 rdmux
+  saprech vddc_13 vddce vddp vddp vddp vpw vpw vpw wa_en wablm0 wen0_13
+  wen1_13 weny0_term_13 weny1_term_13 wtdft yw0 yw1 yw2 yw3
+  rf64x128colm2x2_std_nbl_ast
xr_io_14 q0_14 q1_14 bl0_14 bl1_14 bl2_14 bl3_14 blprech cap_ctrl0_26
+  cap_ctrl1_28 cap_ctrl0_26 cap_ctrl1_28 d0_14 d1_14 dwl_mainbreak
+  dwl_mainbreak dwl_mainbreak dwl_mainbreak iwclk0 iwclk1 log0 log0_sa
+  nact_cc nbl0_14 nbl1_14 nbl2_14 nbl3_14 nsae nyr0 nyr1 nyr2 nyr3 rdmux
+  saprech vddc_14 vddce vddp vddp vddp vpw vpw vpw wa_en wablm0 wen0_14
+  wen1_14 weny0_term_14 weny1_term_14 wtdft yw0 yw1 yw2 yw3
+  rf64x128colm2x2_std_nbl_ast
xr_io_15 q0_15 q1_15 bl0_15 bl1_15 bl2_15 bl3_15 blprech cap_ctrl0_30
+  cap_ctrl1_32 cap_ctrl0_30 cap_ctrl1_32 d0_15 d1_15 dwl_main dwl_mainbreak
+  dwl_turn dwl_mainbreak iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_15 nbl1_15
+  nbl2_15 nbl3_15 nsae nyr0 nyr1 nyr2 nyr3 rdmux saprech vddc_15 vddce vddp
+  vddp vddp vpw vpw vpw wa_en wablm0 wen0_15 wen1_15 weny0_term_15
+  weny1_term_15 wtdft yw0 yw1 yw2 yw3 rf64x128colm2x2_std_nbl_ast
xr_io_16 q0_16 q1_16 bl0_16 bl1_16 bl2_16 bl3_16 blprech cap_ctrl0_34
+  cap_ctrl1_36 cap_ctrl0_34 cap_ctrl1_36 d0_16 d1_16 dwl_main dwl_main
+  dwl_turn dwl_turn iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_16 nbl1_16
+  nbl2_16 nbl3_16 nsae nyr0 nyr1 nyr2 nyr3 rdmux saprech vddc_16 vddce vddp
+  vddp vddp vpw vpw vpw wa_en wablm0 wen0_16 wen1_16 weny0_term_16
+  weny1_term_16 wtdft yw0 yw1 yw2 yw3 rf64x128colm2x2_std_nbl_ast
xr_io_17 q0_17 q1_17 bl0_17 bl1_17 bl2_17 bl3_17 blprech cap_ctrl0_38
+  cap_ctrl1_40 cap_ctrl0_38 cap_ctrl1_40 d0_17 d1_17 dwl_main dwl_main
+  dwl_turn dwl_turn iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_17 nbl1_17
+  nbl2_17 nbl3_17 nsae nyr0 nyr1 nyr2 nyr3 rdmux saprech vddc_17 vddce vddp
+  vddp vddp vpw vpw vpw wa_en wablm0 wen0_17 wen1_17 weny0_term_17
+  weny1_term_17 wtdft yw0 yw1 yw2 yw3 rf64x128colm2x2_std_nbl_ast
xr_io_18 q0_18 q1_18 bl0_18 bl1_18 bl2_18 bl3_18 blprech cap_ctrl0_42
+  cap_ctrl1_44 cap_ctrl0_42 cap_ctrl1_44 d0_18 d1_18 dwl_main dwl_main
+  dwl_turn dwl_turn iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_18 nbl1_18
+  nbl2_18 nbl3_18 nsae nyr0 nyr1 nyr2 nyr3 rdmux saprech vddc_18 vddce vddp
+  vddp vddp vpw vpw vpw wa_en wablm0 wen0_18 wen1_18 weny0_term_18
+  weny1_term_18 wtdft yw0 yw1 yw2 yw3 rf64x128colm2x2_std_nbl_ast
xr_io_19 q0_19 q1_19 bl0_19 bl1_19 bl2_19 bl3_19 blprech cap_ctrl0_46
+  cap_ctrl1_48 cap_ctrl0_46 cap_ctrl1_48 d0_19 d1_19 dwl_main dwl_main
+  dwl_turn dwl_turn iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_19 nbl1_19
+  nbl2_19 nbl3_19 nsae nyr0 nyr1 nyr2 nyr3 rdmux saprech vddc_19 vddce vddp
+  vddp vddp vpw vpw vpw wa_en wablm0 wen0_19 wen1_19 weny0_term_19
+  weny1_term_19 wtdft yw0 yw1 yw2 yw3 rf64x128colm2x2_std_nbl_ast
xr_io_2 q0_2 q1_2 bl0_2 bl1_2 bl2_2 bl3_2 blprech cap_ctrl0_98 cap_ctrl1_100
+  cap_ctrl0_98 cap_ctrl1_100 d0_2 d1_2 dwl_mainbreak dwl_mainbreak
+  dwl_mainbreak dwl_mainbreak iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_2
+  nbl1_2 nbl2_2 nbl3_2 nsae nyr0 nyr1 nyr2 nyr3 rdmux saprech vddc_2 vddce
+  vddp vddp vddp vpw vpw vpw wa_en wablm0 wen0_2 wen1_2 weny0_term_2
+  weny1_term_2 wtdft yw0 yw1 yw2 yw3 rf64x128colm2x2_std_nbl_ast
xr_io_20 q0_20 q1_20 bl0_20 bl1_20 bl2_20 bl3_20 blprech cap_ctrl0_50
+  cap_ctrl1_52 cap_ctrl0_50 cap_ctrl1_52 d0_20 d1_20 dwl_main dwl_main
+  dwl_turn dwl_turn iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_20 nbl1_20
+  nbl2_20 nbl3_20 nsae nyr0 nyr1 nyr2 nyr3 rdmux saprech vddc_20 vddce vddp
+  vddp vddp vpw vpw vpw wa_en wablm0 wen0_20 wen1_20 weny0_term_20
+  weny1_term_20 wtdft yw0 yw1 yw2 yw3 rf64x128colm2x2_std_nbl_ast
xr_io_21 q0_21 q1_21 bl0_21 bl1_21 bl2_21 bl3_21 blprech cap_ctrl0_54
+  cap_ctrl1_56 cap_ctrl0_54 cap_ctrl1_56 d0_21 d1_21 dwl_main dwl_main
+  dwl_turn dwl_turn iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_21 nbl1_21
+  nbl2_21 nbl3_21 nsae nyr0 nyr1 nyr2 nyr3 rdmux saprech vddc_21 vddce vddp
+  vddp vddp vpw vpw vpw wa_en wablm0 wen0_21 wen1_21 weny0_term_21
+  weny1_term_21 wtdft yw0 yw1 yw2 yw3 rf64x128colm2x2_std_nbl_ast
xr_io_22 q0_22 q1_22 bl0_22 bl1_22 bl2_22 bl3_22 blprech cap_ctrl0_58
+  cap_ctrl1_60 cap_ctrl0_58 cap_ctrl1_60 d0_22 d1_22 dwl_main dwl_main
+  dwl_turn dwl_turn iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_22 nbl1_22
+  nbl2_22 nbl3_22 nsae nyr0 nyr1 nyr2 nyr3 rdmux saprech vddc_22 vddce vddp
+  vddp vddp vpw vpw vpw wa_en wablm0 wen0_22 wen1_22 weny0_term_22
+  weny1_term_22 wtdft yw0 yw1 yw2 yw3 rf64x128colm2x2_std_nbl_ast
xr_io_23 q0_23 q1_23 bl0_23 bl1_23 bl2_23 bl3_23 blprech cap_ctrl0_62
+  cap_ctrl1_64 cap_ctrl0_62 cap_ctrl1_64 d0_23 d1_23 dwl_main dwl_main
+  dwl_turn dwl_turn iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_23 nbl1_23
+  nbl2_23 nbl3_23 nsae nyr0 nyr1 nyr2 nyr3 rdmux saprech vddc_23 vddce vddp
+  vddp vddp vpw vpw vpw wa_en wablm0 wen0_23 wen1_23 weny0_term_23
+  weny1_term_23 wtdft yw0 yw1 yw2 yw3 rf64x128colm2x2_std_nbl_ast
xr_io_24 q0_24 q1_24 bl0_24 bl1_24 bl2_24 bl3_24 blprech cap_ctrl0_66
+  cap_ctrl1_68 cap_ctrl0_66 cap_ctrl1_68 d0_24 d1_24 dwl_main dwl_main
+  dwl_turn dwl_turn iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_24 nbl1_24
+  nbl2_24 nbl3_24 nsae nyr0 nyr1 nyr2 nyr3 rdmux saprech vddc_24 vddce vddp
+  vddp vddp vpw vpw vpw wa_en wablm0 wen0_24 wen1_24 weny0_term_24
+  weny1_term_24 wtdft yw0 yw1 yw2 yw3 rf64x128colm2x2_std_nbl_ast
xr_io_25 q0_25 q1_25 bl0_25 bl1_25 bl2_25 bl3_25 blprech cap_ctrl0_70
+  cap_ctrl1_72 cap_ctrl0_70 cap_ctrl1_72 d0_25 d1_25 dwl_main dwl_main
+  dwl_turn dwl_turn iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_25 nbl1_25
+  nbl2_25 nbl3_25 nsae nyr0 nyr1 nyr2 nyr3 rdmux saprech vddc_25 vddce vddp
+  vddp vddp vpw vpw vpw wa_en wablm0 wen0_25 wen1_25 weny0_term_25
+  weny1_term_25 wtdft yw0 yw1 yw2 yw3 rf64x128colm2x2_std_nbl_ast
xr_io_26 q0_26 q1_26 bl0_26 bl1_26 bl2_26 bl3_26 blprech cap_ctrl0_74
+  cap_ctrl1_76 cap_ctrl0_74 cap_ctrl1_76 d0_26 d1_26 dwl_main dwl_main
+  dwl_turn dwl_turn iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_26 nbl1_26
+  nbl2_26 nbl3_26 nsae nyr0 nyr1 nyr2 nyr3 rdmux saprech vddc_26 vddce vddp
+  vddp vddp vpw vpw vpw wa_en wablm0 wen0_26 wen1_26 weny0_term_26
+  weny1_term_26 wtdft yw0 yw1 yw2 yw3 rf64x128colm2x2_std_nbl_ast
xr_io_27 q0_27 q1_27 bl0_27 bl1_27 bl2_27 bl3_27 blprech cap_ctrl0_78
+  cap_ctrl1_80 cap_ctrl0_78 cap_ctrl1_80 d0_27 d1_27 dwl_main dwl_main
+  dwl_turn dwl_turn iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_27 nbl1_27
+  nbl2_27 nbl3_27 nsae nyr0 nyr1 nyr2 nyr3 rdmux saprech vddc_27 vddce vddp
+  vddp vddp vpw vpw vpw wa_en wablm0 wen0_27 wen1_27 weny0_term_27
+  weny1_term_27 wtdft yw0 yw1 yw2 yw3 rf64x128colm2x2_std_nbl_ast
xr_io_28 q0_28 q1_28 bl0_28 bl1_28 bl2_28 bl3_28 blprech cap_ctrl0_82
+  cap_ctrl1_84 cap_ctrl0_82 cap_ctrl1_84 d0_28 d1_28 dwl_main dwl_main
+  dwl_turn dwl_turn iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_28 nbl1_28
+  nbl2_28 nbl3_28 nsae nyr0 nyr1 nyr2 nyr3 rdmux saprech vddc_28 vddce vddp
+  vddp vddp vpw vpw vpw wa_en wablm0 wen0_28 wen1_28 weny0_term_28
+  weny1_term_28 wtdft yw0 yw1 yw2 yw3 rf64x128colm2x2_std_nbl_ast
xr_io_29 q0_29 q1_29 bl0_29 bl1_29 bl2_29 bl3_29 blprech cap_ctrl0_86
+  cap_ctrl1_88 cap_ctrl0_86 cap_ctrl1_88 d0_29 d1_29 dwl_main dwl_main
+  dwl_turn dwl_turn iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_29 nbl1_29
+  nbl2_29 nbl3_29 nsae nyr0 nyr1 nyr2 nyr3 rdmux saprech vddc_29 vddce vddp
+  vddp vddp vpw vpw vpw wa_en wablm0 wen0_29 wen1_29 weny0_term_29
+  weny1_term_29 wtdft yw0 yw1 yw2 yw3 rf64x128colm2x2_std_nbl_ast
xr_io_3 q0_3 q1_3 bl0_3 bl1_3 bl2_3 bl3_3 blprech cap_ctrl0_106 cap_ctrl1_108
+  cap_ctrl0_106 cap_ctrl1_108 d0_3 d1_3 dwl_mainbreak dwl_mainbreak
+  dwl_mainbreak dwl_mainbreak iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_3
+  nbl1_3 nbl2_3 nbl3_3 nsae nyr0 nyr1 nyr2 nyr3 rdmux saprech vddc_3 vddce
+  vddp vddp vddp vpw vpw vpw wa_en wablm0 wen0_3 wen1_3 weny0_term_3
+  weny1_term_3 wtdft yw0 yw1 yw2 yw3 rf64x128colm2x2_std_nbl_ast
xr_io_30 q0_30 q1_30 bl0_30 bl1_30 bl2_30 bl3_30 blprech cap_ctrl0_14
+  cap_ctrl1_16 cap_ctrl0_14 cap_ctrl1_16 d0_30 d1_30 dwl_main dwl_main
+  dwl_turn dwl_turn iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_30 nbl1_30
+  nbl2_30 nbl3_30 nsae nyr0 nyr1 nyr2 nyr3 rdmux saprech vddc_30 vddce vddp
+  vddp vddp vpw vpw vpw wa_en wablm0 wen0_30 wen1_30 weny0_term_30
+  weny1_term_30 wtdft yw0 yw1 yw2 yw3 rf64x128colm2x2_std_nbl_ast
xr_io_4 q0_4 q1_4 bl0_4 bl1_4 bl2_4 bl3_4 blprech cap_ctrl0_110 cap_ctrl1_112
+  cap_ctrl0_110 cap_ctrl1_112 d0_4 d1_4 dwl_mainbreak dwl_mainbreak
+  dwl_mainbreak dwl_mainbreak iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_4
+  nbl1_4 nbl2_4 nbl3_4 nsae nyr0 nyr1 nyr2 nyr3 rdmux saprech vddc_4 vddce
+  vddp vddp vddp vpw vpw vpw wa_en wablm0 wen0_4 wen1_4 weny0_term_4
+  weny1_term_4 wtdft yw0 yw1 yw2 yw3 rf64x128colm2x2_std_nbl_ast
xr_io_5 q0_5 q1_5 bl0_5 bl1_5 bl2_5 bl3_5 blprech cap_ctrl0_114 cap_ctrl1_116
+  cap_ctrl0_114 cap_ctrl1_116 d0_5 d1_5 dwl_mainbreak dwl_mainbreak
+  dwl_mainbreak dwl_mainbreak iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_5
+  nbl1_5 nbl2_5 nbl3_5 nsae nyr0 nyr1 nyr2 nyr3 rdmux saprech vddc_5 vddce
+  vddp vddp vddp vpw vpw vpw wa_en wablm0 wen0_5 wen1_5 weny0_term_5
+  weny1_term_5 wtdft yw0 yw1 yw2 yw3 rf64x128colm2x2_std_nbl_ast
xr_io_6 q0_6 q1_6 bl0_6 bl1_6 bl2_6 bl3_6 blprech cap_ctrl0_118 cap_ctrl1_120
+  cap_ctrl0_118 cap_ctrl1_120 d0_6 d1_6 dwl_mainbreak dwl_mainbreak
+  dwl_mainbreak dwl_mainbreak iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_6
+  nbl1_6 nbl2_6 nbl3_6 nsae nyr0 nyr1 nyr2 nyr3 rdmux saprech vddc_6 vddce
+  vddp vddp vddp vpw vpw vpw wa_en wablm0 wen0_6 wen1_6 weny0_term_6
+  weny1_term_6 wtdft yw0 yw1 yw2 yw3 rf64x128colm2x2_std_nbl_ast
xr_io_7 q0_7 q1_7 bl0_7 bl1_7 bl2_7 bl3_7 blprech cap_ctrl0_122 cap_ctrl1_124
+  cap_ctrl0_122 cap_ctrl1_124 d0_7 d1_7 dwl_mainbreak dwl_mainbreak
+  dwl_mainbreak dwl_mainbreak iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_7
+  nbl1_7 nbl2_7 nbl3_7 nsae nyr0 nyr1 nyr2 nyr3 rdmux saprech vddc_7 vddce
+  vddp vddp vddp vpw vpw vpw wa_en wablm0 wen0_7 wen1_7 weny0_term_7
+  weny1_term_7 wtdft yw0 yw1 yw2 yw3 rf64x128colm2x2_std_nbl_ast
xr_io_8 q0_8 q1_8 bl0_8 bl1_8 bl2_8 bl3_8 blprech cap_ctrl0 cap_ctrl1
+  cap_ctrl0 cap_ctrl1 d0_8 d1_8 dwl_mainbreak dwl_mainbreak dwl_mainbreak
+  dwl_mainbreak iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_8 nbl1_8 nbl2_8
+  nbl3_8 nsae nyr0 nyr1 nyr2 nyr3 rdmux saprech vddc_8 vddce vddp vddp vddp
+  vpw vpw vpw wa_en wablm0 wen0_8 wen1_8 weny0_term_8 weny1_term_8 wtdft yw0
+  yw1 yw2 yw3 rf64x128colm2x2_std_nbl_ast
xr_io_9 q0_9 q1_9 bl0_9 bl1_9 bl2_9 bl3_9 blprech cap_ctrl0_2 cap_ctrl1_4
+  cap_ctrl0_2 cap_ctrl1_4 d0_9 d1_9 dwl_mainbreak dwl_mainbreak dwl_mainbreak
+  dwl_mainbreak iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_9 nbl1_9 nbl2_9
+  nbl3_9 nsae nyr0 nyr1 nyr2 nyr3 rdmux saprech vddc_9 vddce vddp vddp vddp
+  vpw vpw vpw wa_en wablm0 wen0_9 wen1_9 weny0_term_9 weny1_term_9 wtdft yw0
+  yw1 yw2 yw3 rf64x128colm2x2_std_nbl_ast
xr_io_l q0_0 q1_0 bl0_0 bl1_0 bl2_0 bl3_0 blprech cap_ctrl0_90 cap_ctrl1_92
+  cap_ctrl0_90 cap_ctrl1_92 d0_0 d1_0 dwl_mainbreak dwl_mainbreak
+  dwl_mainbreak dwl_mainbreak iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_0
+  nbl1_0 nbl2_0 nbl3_0 nsae nyr0 nyr1 nyr2 nyr3 rdmux saprech vddc_0 vddce
+  vddp vddp vddp vpw vpw vpw wa_en wablm0 wen0_0 wen1_0 weny0_term_0
+  weny1_term_0 wtdft yw0 yw1 yw2 yw3 rf64x128colm2x2_std_nbl_ast
xr_io_r q0_31 q1_31 bl0_31 bl1_31 bl2_31 bl3_31 blprech cap_ctrl0_102
+  cap_ctrl1_104 cap_ctrl0_102 cap_ctrl1_104 d0_31 d1_31 dwl_main dwl_main
+  dwl_turn dwl_turn iwclk0 iwclk1 log0 log0_sa nact_cc nbl0_31 nbl1_31
+  nbl2_31 nbl3_31 nsae nyr0 nyr1 nyr2 nyr3 rdmux saprech vddc_31 vddce vddp
+  vddp vddp vpw vpw vpw wa_en wablm0 wen0_31 wen1_31 weny0_term_31
+  weny1_term_31 wtdft yw0 yw1 yw2 yw3 rf64x128colm2x2_std_nbl_ast
.ends rf64x128iocdm_r
****
.subckt rf64x128io_row_r bl3_31 nbl3_31 nbl2_31 bl2_31 vddc_31 bl1_31 nbl1_31
+  nbl0_31 bl0_31 bl3_30 nbl3_30 nbl2_30 bl2_30 vddc_30 bl1_30 nbl1_30 nbl0_30
+  bl0_30 bl3_29 nbl3_29 nbl2_29 bl2_29 vddc_29 bl1_29 nbl1_29 nbl0_29 bl0_29
+  bl3_28 nbl3_28 nbl2_28 bl2_28 vddc_28 bl1_28 nbl1_28 nbl0_28 bl0_28 bl3_27
+  nbl3_27 nbl2_27 bl2_27 vddc_27 bl1_27 nbl1_27 nbl0_27 bl0_27 bl3_26 nbl3_26
+  nbl2_26 bl2_26 vddc_26 bl1_26 nbl1_26 nbl0_26 bl0_26 bl3_25 nbl3_25 nbl2_25
+  bl2_25 vddc_25 bl1_25 nbl1_25 nbl0_25 bl0_25 bl3_24 nbl3_24 nbl2_24 bl2_24
+  vddc_24 bl1_24 nbl1_24 nbl0_24 bl0_24 bl3_23 nbl3_23 nbl2_23 bl2_23 vddc_23
+  bl1_23 nbl1_23 nbl0_23 bl0_23 bl3_22 nbl3_22 nbl2_22 bl2_22 vddc_22 bl1_22
+  nbl1_22 nbl0_22 bl0_22 bl3_21 nbl3_21 nbl2_21 bl2_21 vddc_21 bl1_21 nbl1_21
+  nbl0_21 bl0_21 bl3_20 nbl3_20 nbl2_20 bl2_20 vddc_20 bl1_20 nbl1_20 nbl0_20
+  bl0_20 bl3_19 nbl3_19 nbl2_19 bl2_19 vddc_19 bl1_19 nbl1_19 nbl0_19 bl0_19
+  bl3_18 nbl3_18 nbl2_18 bl2_18 vddc_18 bl1_18 nbl1_18 nbl0_18 bl0_18 bl3_17
+  nbl3_17 nbl2_17 bl2_17 vddc_17 bl1_17 nbl1_17 nbl0_17 bl0_17 bl3_16 nbl3_16
+  nbl2_16 bl2_16 vddc_16 bl1_16 nbl1_16 nbl0_16 bl0_16 bl3_15 nbl3_15 nbl2_15
+  bl2_15 vddc_15 bl1_15 nbl1_15 nbl0_15 bl0_15 bl3_14 nbl3_14 nbl2_14 bl2_14
+  vddc_14 bl1_14 nbl1_14 nbl0_14 bl0_14 bl3_13 nbl3_13 nbl2_13 bl2_13 vddc_13
+  bl1_13 nbl1_13 nbl0_13 bl0_13 bl3_12 nbl3_12 nbl2_12 bl2_12 vddc_12 bl1_12
+  nbl1_12 nbl0_12 bl0_12 bl3_11 nbl3_11 nbl2_11 bl2_11 vddc_11 bl1_11 nbl1_11
+  nbl0_11 bl0_11 bl3_10 nbl3_10 nbl2_10 bl2_10 vddc_10 vddce bl1_10 nbl1_10
+  nbl0_10 bl0_10 bl3_9 nbl3_9 nbl2_9 bl2_9 vddc_9 bl1_9 nbl1_9 nbl0_9 bl0_9
+  bl3_8 nbl3_8 nbl2_8 bl2_8 vddc_8 bl1_8 nbl1_8 nbl0_8 bl0_8 bl3_7 nbl3_7
+  nbl2_7 bl2_7 vddc_7 bl1_7 nbl1_7 nbl0_7 bl0_7 bl3_6 nbl3_6 nbl2_6 bl2_6
+  vddc_6 bl1_6 nbl1_6 nbl0_6 bl0_6 bl3_5 nbl3_5 nbl2_5 bl2_5 vddc_5 bl1_5
+  nbl1_5 nbl0_5 bl0_5 bl3_4 nbl3_4 nbl2_4 bl2_4 vddc_4 bl1_4 nbl1_4 nbl0_4
+  bl0_4 bl3_3 nbl3_3 nbl2_3 bl2_3 vddc_3 bl1_3 nbl1_3 nbl0_3 bl0_3 bl3_2
+  nbl3_2 nbl2_2 bl2_2 vddc_2 bl1_2 nbl1_2 nbl0_2 bl0_2 bl3_1 nbl3_1 nbl2_1
+  bl2_1 vddc_1 bl1_1 nbl1_1 nbl0_1 bl0_1 bl3_0 nbl3_0 nbl2_0 bl2_0 vddc_0
+  bl1_0 nbl1_0 nbl0_0 bl0_0 q1_31 d1_31 wen1_31 weny1_term_31 weny0_term_31
+  wen0_31 d0_31 q0_31 q1_30 d1_30 wen1_30 weny1_term_30 weny0_term_30 wen0_30
+  d0_30 q0_30 q1_29 d1_29 wen1_29 weny1_term_29 weny0_term_29 wen0_29 d0_29
+  q0_29 q1_28 d1_28 wen1_28 weny1_term_28 weny0_term_28 wen0_28 d0_28 q0_28
+  q1_27 d1_27 wen1_27 weny1_term_27 weny0_term_27 wen0_27 d0_27 q0_27 q1_26
+  d1_26 wen1_26 weny1_term_26 weny0_term_26 wen0_26 d0_26 q0_26 q1_25 d1_25
+  wen1_25 weny1_term_25 weny0_term_25 wen0_25 d0_25 q0_25 q1_24 d1_24 wen1_24
+  weny1_term_24 weny0_term_24 wen0_24 d0_24 q0_24 q1_23 d1_23 wen1_23
+  weny1_term_23 weny0_term_23 wen0_23 d0_23 q0_23 q1_22 d1_22 wen1_22
+  weny1_term_22 weny0_term_22 wen0_22 d0_22 q0_22 q1_21 d1_21 wen1_21
+  weny1_term_21 weny0_term_21 wen0_21 d0_21 q0_21 q1_20 d1_20 wen1_20
+  weny1_term_20 weny0_term_20 wen0_20 d0_20 q0_20 q1_19 d1_19 wen1_19
+  weny1_term_19 weny0_term_19 wen0_19 d0_19 q0_19 q1_18 d1_18 wen1_18
+  weny1_term_18 weny0_term_18 wen0_18 d0_18 q0_18 q1_17 d1_17 wen1_17
+  weny1_term_17 weny0_term_17 wen0_17 d0_17 vpw q0_17 q1_16 d1_16 wen1_16
+  weny1_term_16 weny0_term_16 wen0_16 d0_16 q0_16 q1_15 d1_15 wen1_15
+  weny1_term_15 weny0_term_15 wen0_15 d0_15 q0_15 q1_14 d1_14 wen1_14
+  weny1_term_14 weny0_term_14 wen0_14 d0_14 vddpe q0_14 q1_13 d1_13 wen1_13
+  weny1_term_13 weny0_term_13 wen0_13 d0_13 q0_13 q1_12 d1_12 wen1_12
+  weny1_term_12 weny0_term_12 wen0_12 d0_12 q0_12 q1_11 d1_11 wen1_11
+  weny1_term_11 weny0_term_11 wen0_11 d0_11 q0_11 q1_10 d1_10 wen1_10
+  weny1_term_10 weny0_term_10 wen0_10 d0_10 q0_10 q1_9 d1_9 wen1_9
+  weny1_term_9 weny0_term_9 wen0_9 d0_9 q0_9 q1_8 d1_8 wen1_8 weny1_term_8
+  weny0_term_8 wen0_8 d0_8 q0_8 q1_7 d1_7 wen1_7 weny1_term_7 weny0_term_7
+  wen0_7 d0_7 q0_7 q1_6 d1_6 wen1_6 weny1_term_6 weny0_term_6 wen0_6 d0_6
+  q0_6 q1_5 d1_5 wen1_5 weny1_term_5 weny0_term_5 wen0_5 d0_5 q0_5 q1_4 d1_4
+  wen1_4 weny1_term_4 weny0_term_4 wen0_4 d0_4 q0_4 q1_3 d1_3 wen1_3
+  weny1_term_3 weny0_term_3 wen0_3 d0_3 q0_3 q1_2 d1_2 wen1_2 weny1_term_2
+  weny0_term_2 wen0_2 d0_2 q0_2 q1_1 d1_1 wen1_1 weny1_term_1 weny0_term_1
+  wen0_1 d0_1 q0_1 q1_0 d1_0 wen1_0 weny1_term_0 weny0_term_0 wen0_0 d0_0
+  q0_0 blprech nact_cc yw3 yw2 yw1 yw0 nyr3 nyr2 nyr1 nyr0 rdmux nsae saprech
+  wtdft log0_sa log0 iwclk0 iwclk1 dwl_mainbreak wablm0 wa_en
** rf64x128io_row_r: 9152 flat devices **
xio_cdm_row_r bl3_31 nbl3_31 nbl2_31 bl2_31 vddc_31 bl1_31 nbl1_31 nbl0_31
+  bl0_31 bl3_30 nbl3_30 nbl2_30 bl2_30 vddc_30 bl1_30 nbl1_30 nbl0_30 bl0_30
+  bl3_29 nbl3_29 nbl2_29 bl2_29 vddc_29 bl1_29 nbl1_29 nbl0_29 bl0_29 bl3_28
+  nbl3_28 nbl2_28 bl2_28 vddc_28 bl1_28 nbl1_28 nbl0_28 bl0_28 bl3_27 nbl3_27
+  nbl2_27 bl2_27 vddc_27 bl1_27 nbl1_27 nbl0_27 bl0_27 bl3_26 nbl3_26 nbl2_26
+  bl2_26 vddc_26 bl1_26 nbl1_26 nbl0_26 bl0_26 bl3_25 nbl3_25 nbl2_25 bl2_25
+  vddc_25 bl1_25 nbl1_25 nbl0_25 bl0_25 bl3_24 nbl3_24 nbl2_24 bl2_24 vddc_24
+  bl1_24 nbl1_24 nbl0_24 bl0_24 bl3_23 nbl3_23 nbl2_23 bl2_23 vddc_23 bl1_23
+  nbl1_23 nbl0_23 bl0_23 bl3_22 nbl3_22 nbl2_22 bl2_22 vddc_22 bl1_22 nbl1_22
+  nbl0_22 bl0_22 bl3_21 nbl3_21 nbl2_21 bl2_21 vddc_21 bl1_21 nbl1_21 nbl0_21
+  bl0_21 bl3_20 nbl3_20 nbl2_20 bl2_20 vddc_20 bl1_20 nbl1_20 nbl0_20 bl0_20
+  bl3_19 nbl3_19 nbl2_19 bl2_19 vddc_19 bl1_19 nbl1_19 nbl0_19 bl0_19 bl3_18
+  nbl3_18 nbl2_18 bl2_18 vddc_18 bl1_18 nbl1_18 nbl0_18 bl0_18 bl3_17 nbl3_17
+  nbl2_17 bl2_17 vddc_17 bl1_17 nbl1_17 nbl0_17 bl0_17 bl3_16 nbl3_16 nbl2_16
+  bl2_16 vddc_16 bl1_16 nbl1_16 nbl0_16 bl0_16 bl3_15 nbl3_15 nbl2_15 bl2_15
+  vddc_15 bl1_15 nbl1_15 nbl0_15 bl0_15 bl3_14 nbl3_14 nbl2_14 bl2_14 vddc_14
+  bl1_14 nbl1_14 nbl0_14 bl0_14 bl3_13 nbl3_13 nbl2_13 bl2_13 vddc_13 bl1_13
+  nbl1_13 nbl0_13 bl0_13 bl3_12 nbl3_12 nbl2_12 bl2_12 vddc_12 bl1_12 nbl1_12
+  nbl0_12 bl0_12 bl3_11 nbl3_11 nbl2_11 bl2_11 vddc_11 bl1_11 nbl1_11 nbl0_11
+  bl0_11 bl3_10 nbl3_10 nbl2_10 bl2_10 vddc_10 bl1_10 nbl1_10 nbl0_10 bl0_10
+  bl3_9 nbl3_9 nbl2_9 bl2_9 vddc_9 bl1_9 nbl1_9 nbl0_9 bl0_9 bl3_8 nbl3_8
+  nbl2_8 bl2_8 vddc_8 bl1_8 nbl1_8 nbl0_8 bl0_8 bl3_7 nbl3_7 nbl2_7 bl2_7
+  vddc_7 bl1_7 nbl1_7 nbl0_7 bl0_7 bl3_6 nbl3_6 nbl2_6 bl2_6 vddc_6 bl1_6
+  nbl1_6 nbl0_6 bl0_6 bl3_5 nbl3_5 nbl2_5 bl2_5 vddc_5 vddce bl1_5 nbl1_5
+  nbl0_5 bl0_5 bl3_4 nbl3_4 nbl2_4 bl2_4 vddc_4 bl1_4 nbl1_4 nbl0_4 bl0_4
+  bl3_3 nbl3_3 nbl2_3 bl2_3 vddc_3 bl1_3 nbl1_3 nbl0_3 bl0_3 bl3_2 nbl3_2
+  nbl2_2 bl2_2 vddc_2 bl1_2 nbl1_2 nbl0_2 bl0_2 bl3_1 nbl3_1 nbl2_1 bl2_1
+  vddc_1 bl1_1 nbl1_1 nbl0_1 bl0_1 bl3_0 nbl3_0 nbl2_0 bl2_0 vddc_0 bl1_0
+  nbl1_0 nbl0_0 bl0_0 q1_31 d1_31 wen1_31 weny1_term_31 weny0_term_31 wen0_31
+  d0_31 q0_31 q1_30 d1_30 wen1_30 weny1_term_30 weny0_term_30 wen0_30 d0_30
+  q0_30 q1_29 d1_29 wen1_29 weny1_term_29 weny0_term_29 wen0_29 d0_29 q0_29
+  q1_28 d1_28 wen1_28 weny1_term_28 weny0_term_28 wen0_28 d0_28 q0_28 q1_27
+  d1_27 wen1_27 weny1_term_27 weny0_term_27 wen0_27 d0_27 vddpe q0_27 q1_26
+  d1_26 wen1_26 weny1_term_26 weny0_term_26 wen0_26 d0_26 q0_26 q1_25 d1_25
+  wen1_25 weny1_term_25 weny0_term_25 wen0_25 d0_25 q0_25 q1_24 d1_24 wen1_24
+  weny1_term_24 weny0_term_24 wen0_24 d0_24 q0_24 q1_23 d1_23 wen1_23
+  weny1_term_23 weny0_term_23 wen0_23 d0_23 vpw q0_23 q1_22 d1_22 wen1_22
+  weny1_term_22 weny0_term_22 wen0_22 d0_22 q0_22 q1_21 d1_21 wen1_21
+  weny1_term_21 weny0_term_21 wen0_21 d0_21 q0_21 q1_20 d1_20 wen1_20
+  weny1_term_20 weny0_term_20 wen0_20 d0_20 q0_20 q1_19 d1_19 wen1_19
+  weny1_term_19 weny0_term_19 wen0_19 d0_19 q0_19 q1_18 d1_18 wen1_18
+  weny1_term_18 weny0_term_18 wen0_18 d0_18 q0_18 q1_17 d1_17 wen1_17
+  weny1_term_17 weny0_term_17 wen0_17 d0_17 q0_17 q1_16 d1_16 wen1_16
+  weny1_term_16 weny0_term_16 wen0_16 d0_16 q0_16 q1_15 d1_15 wen1_15
+  weny1_term_15 weny0_term_15 wen0_15 d0_15 q0_15 q1_14 d1_14 wen1_14
+  weny1_term_14 weny0_term_14 wen0_14 d0_14 q0_14 q1_13 d1_13 wen1_13
+  weny1_term_13 weny0_term_13 wen0_13 d0_13 q0_13 q1_12 d1_12 wen1_12
+  weny1_term_12 weny0_term_12 wen0_12 d0_12 q0_12 q1_11 d1_11 wen1_11
+  weny1_term_11 weny0_term_11 wen0_11 d0_11 q0_11 q1_10 d1_10 wen1_10
+  weny1_term_10 weny0_term_10 wen0_10 d0_10 q0_10 q1_9 d1_9 wen1_9
+  weny1_term_9 weny0_term_9 wen0_9 d0_9 q0_9 q1_8 d1_8 wen1_8 weny1_term_8
+  weny0_term_8 wen0_8 d0_8 q0_8 q1_7 d1_7 wen1_7 weny1_term_7 weny0_term_7
+  wen0_7 d0_7 q0_7 q1_6 d1_6 wen1_6 weny1_term_6 weny0_term_6 wen0_6 d0_6
+  q0_6 q1_5 d1_5 wen1_5 weny1_term_5 weny0_term_5 wen0_5 d0_5 q0_5 q1_4 d1_4
+  wen1_4 weny1_term_4 weny0_term_4 wen0_4 d0_4 q0_4 q1_3 d1_3 wen1_3
+  weny1_term_3 weny0_term_3 wen0_3 d0_3 q0_3 q1_2 d1_2 wen1_2 weny1_term_2
+  weny0_term_2 wen0_2 d0_2 q0_2 q1_1 d1_1 wen1_1 weny1_term_1 weny0_term_1
+  wen0_1 d0_1 q0_1 q1_0 d1_0 wen1_0 weny1_term_0 weny0_term_0 wen0_0 d0_0
+  q0_0 blprech nact_cc yw1 yw0 nyr1 nyr0 rdmux nsae saprech log0_sa iwclk0
+  iwclk1 dwl_main log0 yw3 yw2 nyr3 nyr2 wtdft log0 dwl_mainbreak wablm0
+  wa_en rf64x128iocdm_r
.ends rf64x128io_row_r
****
.subckt rf64x128io_slice bl3_63 nbl3_63 nbl2_63 bl2_63 vddc_64 bl1_63 nbl1_63
+  nbl0_63 bl0_63 bl3_62 nbl3_62 nbl2_62 bl2_62 vddc_63 bl1_62 nbl1_62 nbl0_62
+  bl0_62 bl3_61 nbl3_61 nbl2_61 bl2_61 vddc_62 bl1_61 nbl1_61 nbl0_61 bl0_61
+  bl3_60 nbl3_60 nbl2_60 bl2_60 vddc_61 bl1_60 nbl1_60 nbl0_60 bl0_60 bl3_59
+  nbl3_59 nbl2_59 bl2_59 vddc_60 bl1_59 nbl1_59 nbl0_59 bl0_59 bl3_58 nbl3_58
+  nbl2_58 bl2_58 vddc_59 bl1_58 nbl1_58 nbl0_58 bl0_58 bl3_57 nbl3_57 nbl2_57
+  bl2_57 vddc_58 bl1_57 nbl1_57 nbl0_57 bl0_57 bl3_56 nbl3_56 nbl2_56 bl2_56
+  vddc_57 bl1_56 nbl1_56 nbl0_56 bl0_56 bl3_55 nbl3_55 nbl2_55 bl2_55 vddc_56
+  bl1_55 nbl1_55 nbl0_55 bl0_55 bl3_54 nbl3_54 nbl2_54 bl2_54 vddc_55 bl1_54
+  nbl1_54 nbl0_54 bl0_54 bl3_53 nbl3_53 nbl2_53 bl2_53 vddc_54 bl1_53 nbl1_53
+  nbl0_53 bl0_53 bl3_52 nbl3_52 nbl2_52 bl2_52 vddc_53 bl1_52 nbl1_52 nbl0_52
+  bl0_52 bl3_51 nbl3_51 nbl2_51 bl2_51 vddc_52 bl1_51 nbl1_51 nbl0_51 bl0_51
+  bl3_50 nbl3_50 nbl2_50 bl2_50 vddc_51 bl1_50 nbl1_50 nbl0_50 bl0_50 bl3_49
+  nbl3_49 nbl2_49 bl2_49 vddc_50 bl1_49 nbl1_49 nbl0_49 bl0_49 bl3_48 nbl3_48
+  nbl2_48 bl2_48 vddc_49 bl1_48 nbl1_48 nbl0_48 bl0_48 bl3_47 nbl3_47 nbl2_47
+  bl2_47 vddc_48 bl1_47 nbl1_47 nbl0_47 bl0_47 bl3_46 nbl3_46 nbl2_46 bl2_46
+  vddc_47 bl1_46 nbl1_46 nbl0_46 bl0_46 bl3_45 nbl3_45 nbl2_45 bl2_45 vddc_46
+  bl1_45 nbl1_45 nbl0_45 bl0_45 bl3_44 nbl3_44 nbl2_44 bl2_44 vddc_45 bl1_44
+  nbl1_44 nbl0_44 bl0_44 bl3_43 nbl3_43 nbl2_43 bl2_43 vddc_44 bl1_43 nbl1_43
+  nbl0_43 bl0_43 bl3_42 nbl3_42 nbl2_42 bl2_42 vddc_43 bl1_42 nbl1_42 nbl0_42
+  bl0_42 bl3_41 nbl3_41 nbl2_41 bl2_41 vddc_42 bl1_41 nbl1_41 nbl0_41 bl0_41
+  bl3_40 nbl3_40 nbl2_40 bl2_40 vddc_41 bl1_40 nbl1_40 nbl0_40 bl0_40 bl3_39
+  nbl3_39 nbl2_39 bl2_39 vddc_40 bl1_39 nbl1_39 nbl0_39 bl0_39 bl3_38 nbl3_38
+  nbl2_38 bl2_38 vddc_39 bl1_38 nbl1_38 nbl0_38 bl0_38 bl3_37 nbl3_37 nbl2_37
+  bl2_37 vddc_38 vddce bl1_37 nbl1_37 nbl0_37 bl0_37 bl3_36 nbl3_36 nbl2_36
+  bl2_36 vddc_37 bl1_36 nbl1_36 nbl0_36 bl0_36 bl3_35 nbl3_35 nbl2_35 bl2_35
+  vddc_36 bl1_35 nbl1_35 nbl0_35 bl0_35 bl3_34 nbl3_34 nbl2_34 bl2_34 vddc_35
+  bl1_34 nbl1_34 nbl0_34 bl0_34 bl3_33 nbl3_33 nbl2_33 bl2_33 vddc_34 bl1_33
+  nbl1_33 nbl0_33 bl0_33 bl3_32 nbl3_32 nbl2_32 bl2_32 vpw vddc_33 bl1_32
+  nbl1_32 nbl0_32 bl0_32 dbl_nbl_wa_turn dbl_nbl_wa nact_cc nretnvt nactc
+  actp vddp_nor log0_sa dwl_turn gtp nla_p2[1] nla_p2[0] la_p2[1] la_p2[0]
+  nra_p2[5] nra_p2[4] nra_p2[3] nra_p2[2] nra_p2[1] nra_p2[0] ra_p2[5]
+  ra_p2[4] ra_p2[3] ra_p2[2] ra_p2[1] ra_p2[0] cen_p2 nret ret1n ema[0]
+  ema[1] ema[2] vddc_32 dbl bl0_31 nbl0_31 nbl1_31 bl1_31 vddc_31 bl2_31
+  nbl2_31 nbl3_31 bl3_31 bl0_30 nbl0_30 nbl1_30 bl1_30 vddc_30 bl2_30 nbl2_30
+  nbl3_30 bl3_30 bl0_29 nbl0_29 nbl1_29 bl1_29 vddc_29 bl2_29 nbl2_29 nbl3_29
+  bl3_29 bl0_28 nbl0_28 nbl1_28 bl1_28 vddc_28 bl2_28 nbl2_28 nbl3_28 bl3_28
+  bl0_27 nbl0_27 nbl1_27 bl1_27 vddc_27 bl2_27 nbl2_27 nbl3_27 bl3_27 bl0_26
+  nbl0_26 nbl1_26 bl1_26 vddc_26 bl2_26 nbl2_26 nbl3_26 bl3_26 bl0_25 nbl0_25
+  nbl1_25 bl1_25 vddc_25 bl2_25 nbl2_25 nbl3_25 bl3_25 bl0_24 nbl0_24 nbl1_24
+  bl1_24 vddc_24 bl2_24 nbl2_24 nbl3_24 bl3_24 bl0_23 nbl0_23 nbl1_23 bl1_23
+  vddc_23 bl2_23 nbl2_23 nbl3_23 bl3_23 bl0_22 nbl0_22 nbl1_22 bl1_22 vddc_22
+  bl2_22 nbl2_22 nbl3_22 bl3_22 bl0_21 nbl0_21 nbl1_21 bl1_21 vddc_21 bl2_21
+  nbl2_21 nbl3_21 bl3_21 bl0_20 nbl0_20 nbl1_20 bl1_20 vddc_20 bl2_20 nbl2_20
+  nbl3_20 bl3_20 bl0_19 nbl0_19 nbl1_19 bl1_19 vddc_19 bl2_19 nbl2_19 nbl3_19
+  bl3_19 bl0_18 nbl0_18 nbl1_18 bl1_18 vddc_18 bl2_18 nbl2_18 nbl3_18 bl3_18
+  bl0_17 nbl0_17 nbl1_17 bl1_17 vddc_17 bl2_17 nbl2_17 nbl3_17 bl3_17 bl0_16
+  nbl0_16 nbl1_16 bl1_16 vddc_16 bl2_16 nbl2_16 nbl3_16 bl3_16 bl0_15 nbl0_15
+  nbl1_15 bl1_15 vddc_15 bl2_15 nbl2_15 nbl3_15 bl3_15 bl0_14 nbl0_14 nbl1_14
+  bl1_14 vddc_14 bl2_14 nbl2_14 nbl3_14 bl3_14 bl0_13 nbl0_13 nbl1_13 bl1_13
+  vddc_13 bl2_13 nbl2_13 nbl3_13 bl3_13 bl0_12 nbl0_12 nbl1_12 bl1_12 vddc_12
+  bl2_12 nbl2_12 nbl3_12 bl3_12 bl0_11 nbl0_11 nbl1_11 bl1_11 vddc_11 bl2_11
+  nbl2_11 nbl3_11 bl3_11 bl0_10 nbl0_10 nbl1_10 bl1_10 vddc_10 bl2_10 nbl2_10
+  nbl3_10 bl3_10 bl0_9 nbl0_9 nbl1_9 bl1_9 vddc_9 bl2_9 nbl2_9 nbl3_9 bl3_9
+  bl0_8 nbl0_8 nbl1_8 bl1_8 vddc_8 bl2_8 nbl2_8 nbl3_8 bl3_8 bl0_7 nbl0_7
+  nbl1_7 bl1_7 vddc_7 bl2_7 nbl2_7 nbl3_7 bl3_7 bl0_6 nbl0_6 nbl1_6 bl1_6
+  vddc_6 bl2_6 nbl2_6 nbl3_6 bl3_6 bl0_5 nbl0_5 nbl1_5 bl1_5 vddc_5 bl2_5
+  nbl2_5 nbl3_5 bl3_5 bl0_4 nbl0_4 nbl1_4 bl1_4 vddc_4 bl2_4 nbl2_4 nbl3_4
+  bl3_4 bl0_3 nbl0_3 nbl1_3 bl1_3 vddc_3 bl2_3 nbl2_3 nbl3_3 bl3_3 bl0_2
+  nbl0_2 nbl1_2 bl1_2 vddc_2 bl2_2 nbl2_2 nbl3_2 bl3_2 bl0_1 nbl0_1 nbl1_1
+  bl1_1 vddc_1 bl2_1 nbl2_1 nbl3_1 bl3_1 bl0_0 nbl0_0 nbl1_0 bl1_0 vddc_0
+  bl2_0 nbl2_0 nbl3_0 bl3_0 q1_63 d1_63 wen1_63 weny1_term_63 weny0_term_63
+  wen0_63 d0_63 q0_63 q1_62 d1_62 wen1_62 weny1_term_62 weny0_term_62 wen0_62
+  d0_62 q0_62 q1_61 d1_61 wen1_61 weny1_term_61 weny0_term_61 wen0_61 d0_61
+  q0_61 q1_60 d1_60 wen1_60 weny1_term_60 weny0_term_60 wen0_60 d0_60 q0_60
+  q1_59 d1_59 wen1_59 weny1_term_59 weny0_term_59 wen0_59 d0_59 q0_59 q1_58
+  d1_58 wen1_58 weny1_term_58 weny0_term_58 wen0_58 d0_58 q0_58 q1_57 d1_57
+  wen1_57 weny1_term_57 weny0_term_57 wen0_57 d0_57 q0_57 q1_56 d1_56 wen1_56
+  weny1_term_56 weny0_term_56 wen0_56 d0_56 q0_56 q1_55 d1_55 wen1_55
+  weny1_term_55 weny0_term_55 wen0_55 d0_55 q0_55 q1_54 d1_54 wen1_54
+  weny1_term_54 weny0_term_54 wen0_54 d0_54 q0_54 q1_53 d1_53 wen1_53
+  weny1_term_53 weny0_term_53 wen0_53 d0_53 q0_53 q1_52 d1_52 wen1_52
+  weny1_term_52 weny0_term_52 wen0_52 d0_52 q0_52 q1_51 d1_51 wen1_51
+  weny1_term_51 weny0_term_51 wen0_51 d0_51 q0_51 q1_50 d1_50 wen1_50
+  weny1_term_50 weny0_term_50 wen0_50 d0_50 q0_50 q1_49 d1_49 wen1_49
+  weny1_term_49 weny0_term_49 wen0_49 d0_49 q0_49 q1_48 d1_48 wen1_48
+  weny1_term_48 weny0_term_48 wen0_48 d0_48 q0_48 q1_47 d1_47 wen1_47
+  weny1_term_47 weny0_term_47 wen0_47 d0_47 q0_47 q1_46 d1_46 wen1_46
+  weny1_term_46 weny0_term_46 wen0_46 d0_46 q0_46 q1_45 d1_45 wen1_45
+  weny1_term_45 weny0_term_45 wen0_45 d0_45 q0_45 q1_44 d1_44 wen1_44
+  weny1_term_44 weny0_term_44 wen0_44 d0_44 q0_44 q1_43 d1_43 wen1_43
+  weny1_term_43 weny0_term_43 wen0_43 d0_43 q0_43 q1_42 d1_42 wen1_42
+  weny1_term_42 weny0_term_42 wen0_42 d0_42 q0_42 q1_41 d1_41 wen1_41
+  weny1_term_41 weny0_term_41 wen0_41 d0_41 q0_41 q1_40 d1_40 wen1_40
+  weny1_term_40 weny0_term_40 wen0_40 d0_40 q0_40 q1_39 d1_39 wen1_39
+  weny1_term_39 weny0_term_39 wen0_39 d0_39 q0_39 q1_38 d1_38 wen1_38
+  weny1_term_38 weny0_term_38 wen0_38 d0_38 q0_38 q1_37 d1_37 wen1_37
+  weny1_term_37 weny0_term_37 wen0_37 d0_37 q0_37 q1_36 d1_36 wen1_36
+  weny1_term_36 weny0_term_36 wen0_36 d0_36 q0_36 q1_35 d1_35 wen1_35
+  weny1_term_35 weny0_term_35 wen0_35 d0_35 q0_35 q1_34 d1_34 wen1_34
+  weny1_term_34 weny0_term_34 wen0_34 d0_34 q0_34 q1_33 d1_33 wen1_33
+  weny1_term_33 weny0_term_33 wen0_33 d0_33 q0_33 q1_32 d1_32 wen1_32
+  weny1_term_32 weny0_term_32 wen0_32 d0_32 q0_32 penso_term pso1_term
+  pso0_term log1 wablm1 wablm0 wabl rawlm1 rawlm0 rawl log0 emas emaw[0]
+  emaw[1] rdt gwen cen clk a0 a1 a2 a3 a4 a5 a6 a7 a8 a9 a10 q0_31 d0_31
+  wen0_31 weny0_term_31 weny1_term_31 wen1_31 d1_31 q1_31 q0_30 d0_30 wen0_30
+  weny0_term_30 weny1_term_30 wen1_30 d1_30 q1_30 q0_29 d0_29 wen0_29
+  weny0_term_29 weny1_term_29 wen1_29 d1_29 q1_29 q0_28 d0_28 wen0_28
+  weny0_term_28 weny1_term_28 wen1_28 d1_28 vddpe q1_28 q0_27 d0_27 wen0_27
+  weny0_term_27 weny1_term_27 wen1_27 d1_27 q1_27 q0_26 d0_26 wen0_26
+  weny0_term_26 weny1_term_26 wen1_26 d1_26 q1_26 q0_25 d0_25 wen0_25
+  weny0_term_25 weny1_term_25 wen1_25 d1_25 q1_25 q0_24 d0_24 wen0_24
+  weny0_term_24 weny1_term_24 wen1_24 d1_24 q1_24 q0_23 d0_23 wen0_23
+  weny0_term_23 weny1_term_23 wen1_23 d1_23 q1_23 q0_22 d0_22 wen0_22
+  weny0_term_22 weny1_term_22 wen1_22 d1_22 q1_22 q0_21 d0_21 wen0_21
+  weny0_term_21 weny1_term_21 wen1_21 d1_21 q1_21 q0_20 d0_20 wen0_20
+  weny0_term_20 weny1_term_20 wen1_20 d1_20 q1_20 q0_19 d0_19 wen0_19
+  weny0_term_19 weny1_term_19 wen1_19 d1_19 q1_19 q0_18 d0_18 wen0_18
+  weny0_term_18 weny1_term_18 wen1_18 d1_18 q1_18 q0_17 d0_17 wen0_17
+  weny0_term_17 weny1_term_17 wen1_17 d1_17 q1_17 q0_16 d0_16 wen0_16
+  weny0_term_16 weny1_term_16 wen1_16 d1_16 q1_16 q0_15 d0_15 wen0_15
+  weny0_term_15 weny1_term_15 wen1_15 d1_15 q1_15 q0_14 d0_14 wen0_14
+  weny0_term_14 weny1_term_14 wen1_14 d1_14 q1_14 q0_13 d0_13 wen0_13
+  weny0_term_13 weny1_term_13 wen1_13 d1_13 q1_13 q0_12 d0_12 wen0_12
+  weny0_term_12 weny1_term_12 wen1_12 d1_12 q1_12 q0_11 d0_11 wen0_11
+  weny0_term_11 weny1_term_11 wen1_11 d1_11 q1_11 q0_10 d0_10 wen0_10
+  weny0_term_10 weny1_term_10 wen1_10 d1_10 q1_10 q0_9 d0_9 wen0_9
+  weny0_term_9 weny1_term_9 wen1_9 d1_9 q1_9 q0_8 d0_8 wen0_8 weny0_term_8
+  weny1_term_8 wen1_8 d1_8 q1_8 q0_7 d0_7 wen0_7 weny0_term_7 weny1_term_7
+  wen1_7 d1_7 q1_7 q0_6 d0_6 wen0_6 weny0_term_6 weny1_term_6 wen1_6 d1_6
+  q1_6 q0_5 d0_5 wen0_5 weny0_term_5 weny1_term_5 wen1_5 d1_5 q1_5 q0_4 d0_4
+  wen0_4 weny0_term_4 weny1_term_4 wen1_4 d1_4 q1_4 q0_3 d0_3 wen0_3
+  weny0_term_3 weny1_term_3 wen1_3 d1_3 q1_3 q0_2 d0_2 wen0_2 weny0_term_2
+  weny1_term_2 wen1_2 d1_2 q1_2 q0_1 d0_1 wen0_1 weny0_term_1 weny1_term_1
+  wen1_1 d1_1 q1_1 q0_0 d0_0 wen0_0 weny0_term_0 weny1_term_0 wen1_0 d1_0
+  q1_0
** rf64x128io_slice: 19071 flat devices **
xck_blk dbl_nbl_wa_turn dbl_nbl_wa nact_cc nretnvt nactc actp vddp_nor log0_sa
+  gtp nla_p2[1] nla_p2[0] la_p2[1] la_p2[0] nra_p2[5] nra_p2[4] nra_p2[3]
+  nra_p2[2] nra_p2[1] nra_p2[0] ra_p2[5] ra_p2[4] ra_p2[3] ra_p2[2] ra_p2[1]
+  ra_p2[0] cen_p2 nret ret1n ema[0] ema[1] ema[2] vddc_32 vddce vddpe dbl
+  penso_term pso1_term pso0_term log1 wablm1 wablm0 wabl rawlm1 rawlm0 rawl
+  emas emaw[0] emaw[1] vpw rdt gwen cen clk a0 a1 a2 a3 a4 a5 a6 a7 a8 a9 a10
+  vddpe blprech_r yw3_r yw2_r yw1_r yw0_r nsae_r iwclk0 iwclk1 dwl_turn
+  dwl_turn wablm0_right wa_en_right blprech yw3 yw2 yw1 yw0 nyr3 nyr2 nyr1
+  nyr0 rdmux nsae saprech wtdft log0 wablm0_15 wa_en rf64x128ck_blk
xio_left bl0_31 nbl0_31 nbl1_31 bl1_31 vddc_31 bl2_31 nbl2_31 nbl3_31 bl3_31
+  bl0_30 nbl0_30 nbl1_30 bl1_30 vddc_30 bl2_30 nbl2_30 nbl3_30 bl3_30 bl0_29
+  nbl0_29 nbl1_29 bl1_29 vddc_29 bl2_29 nbl2_29 nbl3_29 bl3_29 bl0_28 nbl0_28
+  nbl1_28 bl1_28 vddc_28 bl2_28 nbl2_28 nbl3_28 bl3_28 bl0_27 nbl0_27 nbl1_27
+  bl1_27 vddc_27 bl2_27 nbl2_27 nbl3_27 bl3_27 bl0_26 nbl0_26 nbl1_26 bl1_26
+  vddc_26 bl2_26 nbl2_26 nbl3_26 bl3_26 bl0_25 nbl0_25 nbl1_25 bl1_25 vddc_25
+  bl2_25 nbl2_25 nbl3_25 bl3_25 bl0_24 nbl0_24 nbl1_24 bl1_24 vddc_24 bl2_24
+  nbl2_24 nbl3_24 bl3_24 bl0_23 nbl0_23 nbl1_23 bl1_23 vddc_23 bl2_23 nbl2_23
+  nbl3_23 bl3_23 bl0_22 nbl0_22 nbl1_22 bl1_22 vddc_22 bl2_22 nbl2_22 nbl3_22
+  bl3_22 bl0_21 nbl0_21 nbl1_21 bl1_21 vddc_21 bl2_21 nbl2_21 nbl3_21 bl3_21
+  bl0_20 nbl0_20 nbl1_20 bl1_20 vddc_20 bl2_20 nbl2_20 nbl3_20 bl3_20 bl0_19
+  nbl0_19 nbl1_19 bl1_19 vddc_19 bl2_19 nbl2_19 nbl3_19 bl3_19 bl0_18 nbl0_18
+  nbl1_18 bl1_18 vddc_18 bl2_18 nbl2_18 nbl3_18 bl3_18 bl0_17 nbl0_17 nbl1_17
+  bl1_17 vddc_17 bl2_17 nbl2_17 nbl3_17 bl3_17 bl0_16 nbl0_16 nbl1_16 bl1_16
+  vddc_16 bl2_16 nbl2_16 nbl3_16 bl3_16 bl0_15 nbl0_15 nbl1_15 bl1_15 vddc_15
+  bl2_15 nbl2_15 nbl3_15 bl3_15 bl0_14 nbl0_14 nbl1_14 bl1_14 vddc_14 bl2_14
+  nbl2_14 nbl3_14 bl3_14 bl0_13 nbl0_13 nbl1_13 bl1_13 vddc_13 bl2_13 nbl2_13
+  nbl3_13 bl3_13 bl0_12 nbl0_12 nbl1_12 bl1_12 vddc_12 bl2_12 nbl2_12 nbl3_12
+  bl3_12 bl0_11 nbl0_11 nbl1_11 bl1_11 vddc_11 bl2_11 nbl2_11 nbl3_11 bl3_11
+  bl0_10 nbl0_10 nbl1_10 bl1_10 vddc_10 bl2_10 nbl2_10 nbl3_10 bl3_10 bl0_9
+  nbl0_9 nbl1_9 bl1_9 vddc_9 bl2_9 nbl2_9 nbl3_9 bl3_9 bl0_8 nbl0_8 nbl1_8
+  bl1_8 vddc_8 bl2_8 nbl2_8 nbl3_8 bl3_8 bl0_7 nbl0_7 nbl1_7 bl1_7 vddc_7
+  bl2_7 nbl2_7 nbl3_7 bl3_7 bl0_6 nbl0_6 nbl1_6 bl1_6 vddc_6 bl2_6 nbl2_6
+  nbl3_6 bl3_6 bl0_5 nbl0_5 nbl1_5 bl1_5 vddc_5 bl2_5 nbl2_5 nbl3_5 bl3_5
+  bl0_4 nbl0_4 nbl1_4 bl1_4 vddc_4 bl2_4 nbl2_4 nbl3_4 bl3_4 bl0_3 nbl0_3
+  nbl1_3 bl1_3 vddc_3 bl2_3 nbl2_3 nbl3_3 bl3_3 bl0_2 nbl0_2 nbl1_2 bl1_2
+  vddc_2 bl2_2 nbl2_2 nbl3_2 bl3_2 bl0_1 nbl0_1 nbl1_1 bl1_1 vddc_1 bl2_1
+  nbl2_1 nbl3_1 bl3_1 bl0_0 nbl0_0 nbl1_0 bl1_0 vddce vddc_0 bl2_0 nbl2_0
+  nbl3_0 bl3_0 q0_31 d0_31 wen0_31 weny0_term_31 weny1_term_31 wen1_31 d1_31
+  q1_31 q0_30 d0_30 wen0_30 weny0_term_30 weny1_term_30 wen1_30 d1_30 q1_30
+  q0_29 d0_29 wen0_29 weny0_term_29 weny1_term_29 wen1_29 d1_29 q1_29 q0_28
+  d0_28 wen0_28 weny0_term_28 weny1_term_28 wen1_28 d1_28 q1_28 q0_27 d0_27
+  wen0_27 weny0_term_27 weny1_term_27 wen1_27 d1_27 q1_27 q0_26 d0_26 wen0_26
+  weny0_term_26 weny1_term_26 wen1_26 d1_26 q1_26 q0_25 d0_25 wen0_25
+  weny0_term_25 weny1_term_25 wen1_25 d1_25 q1_25 q0_24 d0_24 wen0_24
+  weny0_term_24 weny1_term_24 wen1_24 d1_24 q1_24 q0_23 vddpe d0_23 wen0_23
+  weny0_term_23 weny1_term_23 wen1_23 d1_23 q1_23 q0_22 d0_22 wen0_22
+  weny0_term_22 weny1_term_22 wen1_22 d1_22 q1_22 q0_21 d0_21 wen0_21
+  weny0_term_21 weny1_term_21 wen1_21 d1_21 q1_21 q0_20 d0_20 wen0_20
+  weny0_term_20 weny1_term_20 wen1_20 d1_20 q1_20 q0_19 d0_19 wen0_19
+  weny0_term_19 weny1_term_19 wen1_19 d1_19 q1_19 q0_18 d0_18 wen0_18
+  weny0_term_18 weny1_term_18 wen1_18 d1_18 q1_18 q0_17 d0_17 wen0_17
+  weny0_term_17 weny1_term_17 wen1_17 d1_17 q1_17 q0_16 vpw d0_16 wen0_16
+  weny0_term_16 weny1_term_16 wen1_16 d1_16 q1_16 q0_15 d0_15 wen0_15
+  weny0_term_15 weny1_term_15 wen1_15 d1_15 q1_15 q0_14 d0_14 wen0_14
+  weny0_term_14 weny1_term_14 wen1_14 d1_14 q1_14 q0_13 d0_13 wen0_13
+  weny0_term_13 weny1_term_13 wen1_13 d1_13 q1_13 q0_12 d0_12 wen0_12
+  weny0_term_12 weny1_term_12 wen1_12 d1_12 q1_12 q0_11 d0_11 wen0_11
+  weny0_term_11 weny1_term_11 wen1_11 d1_11 q1_11 q0_10 d0_10 wen0_10
+  weny0_term_10 weny1_term_10 wen1_10 d1_10 q1_10 q0_9 d0_9 wen0_9
+  weny0_term_9 weny1_term_9 wen1_9 d1_9 q1_9 q0_8 d0_8 wen0_8 weny0_term_8
+  weny1_term_8 wen1_8 d1_8 q1_8 q0_7 d0_7 wen0_7 weny0_term_7 weny1_term_7
+  wen1_7 d1_7 q1_7 q0_6 d0_6 wen0_6 weny0_term_6 weny1_term_6 wen1_6 d1_6
+  q1_6 q0_5 d0_5 wen0_5 weny0_term_5 weny1_term_5 wen1_5 d1_5 q1_5 q0_4 d0_4
+  wen0_4 weny0_term_4 weny1_term_4 wen1_4 d1_4 q1_4 q0_3 d0_3 wen0_3
+  weny0_term_3 weny1_term_3 wen1_3 d1_3 q1_3 q0_2 d0_2 wen0_2 weny0_term_2
+  weny1_term_2 wen1_2 d1_2 q1_2 q0_1 d0_1 wen0_1 weny0_term_1 weny1_term_1
+  wen1_1 d1_1 q1_1 q0_0 d0_0 wen0_0 weny0_term_0 weny1_term_0 wen1_0 d1_0
+  q1_0 blprech nact_cc yw3 yw2 yw1 yw0 nyr3 nyr2 nyr1 nyr0 rdmux nsae saprech
+  wtdft log0_sa log0 iwclk0 iwclk1 log0 wablm0_15 wa_en rf64x128io_row_l
xio_right bl3_63 nbl3_63 nbl2_63 bl2_63 vddc_64 bl1_63 nbl1_63 nbl0_63 bl0_63
+  bl3_62 nbl3_62 nbl2_62 bl2_62 vddc_63 bl1_62 nbl1_62 nbl0_62 bl0_62 bl3_61
+  nbl3_61 nbl2_61 bl2_61 vddc_62 bl1_61 nbl1_61 nbl0_61 bl0_61 bl3_60 nbl3_60
+  nbl2_60 bl2_60 vddc_61 bl1_60 nbl1_60 nbl0_60 bl0_60 bl3_59 nbl3_59 nbl2_59
+  bl2_59 vddc_60 bl1_59 nbl1_59 nbl0_59 bl0_59 bl3_58 nbl3_58 nbl2_58 bl2_58
+  vddc_59 bl1_58 nbl1_58 nbl0_58 bl0_58 bl3_57 nbl3_57 nbl2_57 bl2_57 vddc_58
+  bl1_57 nbl1_57 nbl0_57 bl0_57 bl3_56 nbl3_56 nbl2_56 bl2_56 vddc_57 bl1_56
+  nbl1_56 nbl0_56 bl0_56 bl3_55 nbl3_55 nbl2_55 bl2_55 vddc_56 bl1_55 nbl1_55
+  nbl0_55 bl0_55 bl3_54 nbl3_54 nbl2_54 bl2_54 vddc_55 bl1_54 nbl1_54 nbl0_54
+  bl0_54 bl3_53 nbl3_53 nbl2_53 bl2_53 vddc_54 bl1_53 nbl1_53 nbl0_53 bl0_53
+  bl3_52 nbl3_52 nbl2_52 bl2_52 vddc_53 bl1_52 nbl1_52 nbl0_52 bl0_52 bl3_51
+  nbl3_51 nbl2_51 bl2_51 vddc_52 bl1_51 nbl1_51 nbl0_51 bl0_51 bl3_50 nbl3_50
+  nbl2_50 bl2_50 vddc_51 bl1_50 nbl1_50 nbl0_50 bl0_50 bl3_49 nbl3_49 nbl2_49
+  bl2_49 vddc_50 bl1_49 nbl1_49 nbl0_49 bl0_49 bl3_48 nbl3_48 nbl2_48 bl2_48
+  vddc_49 bl1_48 nbl1_48 nbl0_48 bl0_48 bl3_47 nbl3_47 nbl2_47 bl2_47 vddc_48
+  bl1_47 nbl1_47 nbl0_47 bl0_47 bl3_46 nbl3_46 nbl2_46 bl2_46 vddc_47 bl1_46
+  nbl1_46 nbl0_46 bl0_46 bl3_45 nbl3_45 nbl2_45 bl2_45 vddc_46 bl1_45 nbl1_45
+  nbl0_45 bl0_45 bl3_44 nbl3_44 nbl2_44 bl2_44 vddc_45 bl1_44 nbl1_44 nbl0_44
+  bl0_44 bl3_43 nbl3_43 nbl2_43 bl2_43 vddc_44 bl1_43 nbl1_43 nbl0_43 bl0_43
+  bl3_42 nbl3_42 nbl2_42 bl2_42 vddc_43 vddce bl1_42 nbl1_42 nbl0_42 bl0_42
+  bl3_41 nbl3_41 nbl2_41 bl2_41 vddc_42 bl1_41 nbl1_41 nbl0_41 bl0_41 bl3_40
+  nbl3_40 nbl2_40 bl2_40 vddc_41 bl1_40 nbl1_40 nbl0_40 bl0_40 bl3_39 nbl3_39
+  nbl2_39 bl2_39 vddc_40 bl1_39 nbl1_39 nbl0_39 bl0_39 bl3_38 nbl3_38 nbl2_38
+  bl2_38 vddc_39 bl1_38 nbl1_38 nbl0_38 bl0_38 bl3_37 nbl3_37 nbl2_37 bl2_37
+  vddc_38 bl1_37 nbl1_37 nbl0_37 bl0_37 bl3_36 nbl3_36 nbl2_36 bl2_36 vddc_37
+  bl1_36 nbl1_36 nbl0_36 bl0_36 bl3_35 nbl3_35 nbl2_35 bl2_35 vddc_36 bl1_35
+  nbl1_35 nbl0_35 bl0_35 bl3_34 nbl3_34 nbl2_34 bl2_34 vddc_35 bl1_34 nbl1_34
+  nbl0_34 bl0_34 bl3_33 nbl3_33 nbl2_33 bl2_33 vddc_34 bl1_33 nbl1_33 nbl0_33
+  bl0_33 bl3_32 nbl3_32 nbl2_32 bl2_32 vddc_33 bl1_32 nbl1_32 nbl0_32 bl0_32
+  q1_63 d1_63 wen1_63 weny1_term_63 weny0_term_63 wen0_63 d0_63 q0_63 q1_62
+  d1_62 wen1_62 weny1_term_62 weny0_term_62 wen0_62 d0_62 q0_62 q1_61 d1_61
+  wen1_61 weny1_term_61 weny0_term_61 wen0_61 d0_61 q0_61 q1_60 d1_60 wen1_60
+  weny1_term_60 weny0_term_60 wen0_60 d0_60 q0_60 q1_59 d1_59 wen1_59
+  weny1_term_59 weny0_term_59 wen0_59 d0_59 q0_59 q1_58 d1_58 wen1_58
+  weny1_term_58 weny0_term_58 wen0_58 d0_58 q0_58 q1_57 d1_57 wen1_57
+  weny1_term_57 weny0_term_57 wen0_57 d0_57 q0_57 q1_56 d1_56 wen1_56
+  weny1_term_56 weny0_term_56 wen0_56 d0_56 q0_56 q1_55 d1_55 wen1_55
+  weny1_term_55 weny0_term_55 wen0_55 d0_55 q0_55 q1_54 d1_54 wen1_54
+  weny1_term_54 weny0_term_54 wen0_54 d0_54 q0_54 q1_53 d1_53 wen1_53
+  weny1_term_53 weny0_term_53 wen0_53 d0_53 q0_53 q1_52 d1_52 wen1_52
+  weny1_term_52 weny0_term_52 wen0_52 d0_52 q0_52 q1_51 d1_51 wen1_51
+  weny1_term_51 weny0_term_51 wen0_51 d0_51 q0_51 q1_50 d1_50 wen1_50
+  weny1_term_50 weny0_term_50 wen0_50 d0_50 q0_50 q1_49 d1_49 wen1_49
+  weny1_term_49 weny0_term_49 wen0_49 d0_49 vpw q0_49 q1_48 d1_48 wen1_48
+  weny1_term_48 weny0_term_48 wen0_48 d0_48 q0_48 q1_47 d1_47 wen1_47
+  weny1_term_47 weny0_term_47 wen0_47 d0_47 q0_47 q1_46 d1_46 wen1_46
+  weny1_term_46 weny0_term_46 wen0_46 d0_46 vddpe q0_46 q1_45 d1_45 wen1_45
+  weny1_term_45 weny0_term_45 wen0_45 d0_45 q0_45 q1_44 d1_44 wen1_44
+  weny1_term_44 weny0_term_44 wen0_44 d0_44 q0_44 q1_43 d1_43 wen1_43
+  weny1_term_43 weny0_term_43 wen0_43 d0_43 q0_43 q1_42 d1_42 wen1_42
+  weny1_term_42 weny0_term_42 wen0_42 d0_42 q0_42 q1_41 d1_41 wen1_41
+  weny1_term_41 weny0_term_41 wen0_41 d0_41 q0_41 q1_40 d1_40 wen1_40
+  weny1_term_40 weny0_term_40 wen0_40 d0_40 q0_40 q1_39 d1_39 wen1_39
+  weny1_term_39 weny0_term_39 wen0_39 d0_39 q0_39 q1_38 d1_38 wen1_38
+  weny1_term_38 weny0_term_38 wen0_38 d0_38 q0_38 q1_37 d1_37 wen1_37
+  weny1_term_37 weny0_term_37 wen0_37 d0_37 q0_37 q1_36 d1_36 wen1_36
+  weny1_term_36 weny0_term_36 wen0_36 d0_36 q0_36 q1_35 d1_35 wen1_35
+  weny1_term_35 weny0_term_35 wen0_35 d0_35 q0_35 q1_34 d1_34 wen1_34
+  weny1_term_34 weny0_term_34 wen0_34 d0_34 q0_34 q1_33 d1_33 wen1_33
+  weny1_term_33 weny0_term_33 wen0_33 d0_33 q0_33 q1_32 d1_32 wen1_32
+  weny1_term_32 weny0_term_32 wen0_32 d0_32 q0_32 blprech_r nact_cc yw3_r
+  yw2_r yw1_r yw0_r nyr3 nyr2 nyr1 nyr0 rdmux nsae_r saprech wtdft log0_sa
+  log0 iwclk0 iwclk1 dwl_turn wablm0_right wa_en_right rf64x128io_row_r
.ends rf64x128io_slice
****
.subckt rf64x128cchs4 bl[0] bl[1] bl[2] bl[3] cored00 cored01 cored10 cored11
+  cored20 cored21 cored30 cored31 nbl[0] nbl[1] nbl[2] nbl[3] ncored00
+  ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31 vddc vddce
+  vddpe vnwc vpw vssc vsse wl[0] wl[1]
** rf64x128cchs4: 48 flat devices **
mi26.mxnpdl ncored01 cored01 vssc vpw nchpd_sr W=0.14U L=0.035U NF=1
mi26.mxnpdr cored01 ncored01 vssc vpw nchpd_sr W=0.14U L=0.035U NF=1
mi26.mxnpgl nbl[0] wl[1] ncored01 vpw nchpg_sr W=0.105U L=0.035U NF=1
mi26.mxnpgr bl[0] wl[1] cored01 vpw nchpg_sr W=0.105U L=0.035U NF=1
mi26.mxppul ncored01 cored01 vddc vnwc pchpu_sr W=0.05U L=0.035U NF=1
mi26.mxppur cored01 ncored01 vddc vnwc pchpu_sr W=0.05U L=0.035U NF=1
mi27.mxnpdl ncored00 cored00 vssc vpw nchpd_sr W=0.14U L=0.035U NF=1
mi27.mxnpdr cored00 ncored00 vssc vpw nchpd_sr W=0.14U L=0.035U NF=1
mi27.mxnpgl nbl[0] wl[0] ncored00 vpw nchpg_sr W=0.105U L=0.035U NF=1
mi27.mxnpgr bl[0] wl[0] cored00 vpw nchpg_sr W=0.105U L=0.035U NF=1
mi27.mxppul ncored00 cored00 vddc vnwc pchpu_sr W=0.05U L=0.035U NF=1
mi27.mxppur cored00 ncored00 vddc vnwc pchpu_sr W=0.05U L=0.035U NF=1
mi28.mxnpdl ncored11 cored11 vssc vpw nchpd_sr W=0.14U L=0.035U NF=1
mi28.mxnpdr cored11 ncored11 vssc vpw nchpd_sr W=0.14U L=0.035U NF=1
mi28.mxnpgl nbl[1] wl[1] ncored11 vpw nchpg_sr W=0.105U L=0.035U NF=1
mi28.mxnpgr bl[1] wl[1] cored11 vpw nchpg_sr W=0.105U L=0.035U NF=1
mi28.mxppul ncored11 cored11 vddc vnwc pchpu_sr W=0.05U L=0.035U NF=1
mi28.mxppur cored11 ncored11 vddc vnwc pchpu_sr W=0.05U L=0.035U NF=1
mi29.mxnpdl ncored10 cored10 vssc vpw nchpd_sr W=0.14U L=0.035U NF=1
mi29.mxnpdr cored10 ncored10 vssc vpw nchpd_sr W=0.14U L=0.035U NF=1
mi29.mxnpgl nbl[1] wl[0] ncored10 vpw nchpg_sr W=0.105U L=0.035U NF=1
mi29.mxnpgr bl[1] wl[0] cored10 vpw nchpg_sr W=0.105U L=0.035U NF=1
mi29.mxppul ncored10 cored10 vddc vnwc pchpu_sr W=0.05U L=0.035U NF=1
mi29.mxppur cored10 ncored10 vddc vnwc pchpu_sr W=0.05U L=0.035U NF=1
mi30.mxnpdl ncored21 cored21 vssc vpw nchpd_sr W=0.14U L=0.035U NF=1
mi30.mxnpdr cored21 ncored21 vssc vpw nchpd_sr W=0.14U L=0.035U NF=1
mi30.mxnpgl nbl[2] wl[1] ncored21 vpw nchpg_sr W=0.105U L=0.035U NF=1
mi30.mxnpgr bl[2] wl[1] cored21 vpw nchpg_sr W=0.105U L=0.035U NF=1
mi30.mxppul ncored21 cored21 vddc vnwc pchpu_sr W=0.05U L=0.035U NF=1
mi30.mxppur cored21 ncored21 vddc vnwc pchpu_sr W=0.05U L=0.035U NF=1
mi31.mxnpdl ncored20 cored20 vssc vpw nchpd_sr W=0.14U L=0.035U NF=1
mi31.mxnpdr cored20 ncored20 vssc vpw nchpd_sr W=0.14U L=0.035U NF=1
mi31.mxnpgl nbl[2] wl[0] ncored20 vpw nchpg_sr W=0.105U L=0.035U NF=1
mi31.mxnpgr bl[2] wl[0] cored20 vpw nchpg_sr W=0.105U L=0.035U NF=1
mi31.mxppul ncored20 cored20 vddc vnwc pchpu_sr W=0.05U L=0.035U NF=1
mi31.mxppur cored20 ncored20 vddc vnwc pchpu_sr W=0.05U L=0.035U NF=1
mi32.mxnpdl ncored31 cored31 vssc vpw nchpd_sr W=0.14U L=0.035U NF=1
mi32.mxnpdr cored31 ncored31 vssc vpw nchpd_sr W=0.14U L=0.035U NF=1
mi32.mxnpgl nbl[3] wl[1] ncored31 vpw nchpg_sr W=0.105U L=0.035U NF=1
mi32.mxnpgr bl[3] wl[1] cored31 vpw nchpg_sr W=0.105U L=0.035U NF=1
mi32.mxppul ncored31 cored31 vddc vnwc pchpu_sr W=0.05U L=0.035U NF=1
mi32.mxppur cored31 ncored31 vddc vnwc pchpu_sr W=0.05U L=0.035U NF=1
mi33.mxnpdl ncored30 cored30 vssc vpw nchpd_sr W=0.14U L=0.035U NF=1
mi33.mxnpdr cored30 ncored30 vssc vpw nchpd_sr W=0.14U L=0.035U NF=1
mi33.mxnpgl nbl[3] wl[0] ncored30 vpw nchpg_sr W=0.105U L=0.035U NF=1
mi33.mxnpgr bl[3] wl[0] cored30 vpw nchpg_sr W=0.105U L=0.035U NF=1
mi33.mxppul ncored30 cored30 vddc vnwc pchpu_sr W=0.05U L=0.035U NF=1
mi33.mxppur cored30 ncored30 vddc vnwc pchpu_sr W=0.05U L=0.035U NF=1
.ends rf64x128cchs4
****
.subckt rf64x128cchs4wd_edgbl_dummy dbl dwl vddc vnwc vnwp vpw vssc wl[0]
+  wl[1]
** rf64x128cchs4wd_edgbl_dummy: 12 flat devices **
mi0.mxn0 net11 wl[0] vssc vpw nchpg_sr W=0.105U L=0.035U NF=1
mi0.mxn1 i0.cored vssc vssc vpw nchpd_sr W=0.14U L=0.035U NF=1
mi0.mxn2 vssc i0.core vssc vpw nchpd_sr W=0.14U L=0.035U NF=1
mi0.mxn3 dbl vssc i0.cored vpw nchpg_sr W=0.105U L=0.035U NF=1
mi0.mxp0 vssc i0.core vddc vnwc pchpu_sr W=0.05U L=0.035U NF=1
mi0.mxp1 i0.core vssc vddc vnwc pchpu_sr W=0.05U L=0.035U NF=1
mi14.mxn0 net11 wl[1] vssc vpw nchpg_sr W=0.105U L=0.035U NF=1
mi14.mxn1 i14.cored vssc vssc vpw nchpd_sr W=0.14U L=0.035U NF=1
mi14.mxn2 vssc i14.core vssc vpw nchpd_sr W=0.14U L=0.035U NF=1
mi14.mxn3 dbl vssc i14.cored vpw nchpg_sr W=0.105U L=0.035U NF=1
mi14.mxp0 vssc i14.core vddc vnwc pchpu_sr W=0.05U L=0.035U NF=1
mi14.mxp1 i14.core vssc vddc vnwc pchpu_sr W=0.05U L=0.035U NF=1
.ends rf64x128cchs4wd_edgbl_dummy
****
.subckt rf64x128mem_l_test10row vddc_32 vnwc_33 dbl dwl vnwc_32 bl[2]_31
+  nbl[2]_31 nbl[3]_31 bl[3]_31 bl[1]_30 vddpe_30 bl[2]_30 nbl[2]_30 nbl[3]_30
+  bl[1]_29 vddpe_29 bl[2]_29 nbl[2]_29 bl[1]_28 vddpe_28 bl[2]_28 nbl[2]_28
+  bl[1]_27 vddpe_27 bl[2]_27 nbl[2]_27 bl[0]_26 bl[1]_26 vddpe_26 nbl[2]_26
+  nbl[3]_26 bl[0]_25 bl[1]_25 vddpe_25 vddce_25 vnwc_26 vssc nbl[2]_25
+  nbl[3]_25 bl[0]_24 nbl[0]_24 nbl[1]_24 bl[1]_24 vddpe_24 vddce_24 vnwc_25
+  vpw_25 bl[2]_24 nbl[2]_24 nbl[3]_24 bl[0]_23 nbl[0]_23 nbl[1]_23 bl[1]_23
+  vddpe_23 vddce_23 vnwc_24 vpw_24 bl[2]_23 nbl[2]_23 bl[0]_22 nbl[0]_22
+  nbl[1]_22 bl[1]_22 vddpe_22 vddce_22 vnwc_23 vpw_23 bl[2]_22 nbl[2]_22
+  bl[0]_21 nbl[0]_21 nbl[1]_21 bl[1]_21 vddpe_21 vddce_21 vddc_21 vnwc_22
+  vpw_22 bl[2]_21 nbl[2]_21 bl[0]_20 nbl[0]_20 nbl[1]_20 bl[1]_20 vddpe_20
+  vddce_20 vddc_20 vnwc_21 vpw_21 nbl[2]_20 bl[0]_19 nbl[0]_19 nbl[1]_19
+  bl[1]_19 vddpe_19 vddce_19 vddc_19 vnwc_20 vpw_20 bl[0]_18 nbl[0]_18
+  nbl[1]_18 bl[1]_18 vddpe_18 vddce_18 vnwc_19 vpw_19 bl[2]_18 nbl[2]_18
+  bl[0]_17 nbl[0]_17 nbl[1]_17 bl[1]_17 vddpe_17 vddce_17 vnwc_18 vpw_18
+  bl[2]_17 nbl[2]_17 bl[0]_16 nbl[0]_16 nbl[1]_16 bl[1]_16 vddpe_16 vddce_16
+  vddc_16 vnwc_17 vpw_17 bl[2]_16 nbl[2]_16 bl[0]_15 nbl[0]_15 nbl[1]_15
+  bl[1]_15 vddpe_15 vddce_15 vddc_15 vnwc_16 vpw_16 nbl[2]_15 bl[0]_14
+  nbl[0]_14 nbl[1]_14 bl[1]_14 vddpe_14 vddce_14 vddc_14 vnwc_15 vpw_15
+  nbl[2]_14 bl[0]_13 nbl[0]_13 nbl[1]_13 bl[1]_13 vddpe_13 vddce_13 vddc_13
+  vnwc_14 vpw_14 bl[0]_12 nbl[0]_12 nbl[1]_12 bl[1]_12 vddpe_12 vddce_12
+  vddc_12 vnwc_13 vpw_13 bl[0]_11 nbl[0]_11 nbl[1]_11 bl[1]_11 vddpe_11
+  vddce_11 vddc_11 vnwc_12 vpw_12 bl[2]_11 nbl[2]_11 bl[0]_10 nbl[0]_10
+  nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vddc_10 vnwc_11 vpw_11 nbl[2]_10
+  bl[0]_9 nbl[0]_9 nbl[1]_9 bl[1]_9 vddpe_9 vddce_9 vddc_9 vnwc_10 vpw_10
+  nbl[2]_9 bl[0]_8 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 vddce_8 vddc_8 vnwc_9
+  vpw_9 bl[0]_7 nbl[0]_7 nbl[1]_7 bl[1]_7 vddpe_7 vddce_7 vddc_7 vnwc_8 vpw_8
+  bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddpe_6 vddce_6 vddc_6 vnwc_7 vpw_7
+  bl[3]_6 bl[0]_5 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe_5 vddce_5 vddc_5 vnwc_6
+  vpw_6 nbl[2]_5 bl[0]_4 nbl[0]_4 nbl[1]_4 bl[1]_4 vddpe_4 vddce_4 vddc_4
+  vnwc_5 vpw_5 nbl[2]_4 bl[0]_3 nbl[0]_3 nbl[1]_3 bl[1]_3 vddpe_3 vddce_3
+  vddc_3 vnwc_4 vpw_4 bl[0]_2 nbl[0]_2 nbl[1]_2 bl[1]_2 vddpe_2 vddce_2
+  vddc_2 vnwc_3 vpw_3 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddpe_1 vddce_1
+  vddc_1 vnwc_2 vpw_2 bl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe_0
+  vddce_0 vddc_0 vnwc_1 vpw_1 bl[3]_0 vnwp_0 vnwc_0 vpw_0 vpw_33 vnwp_1
+  bl[0]_31 nbl[0]_31 nbl[1]_31 bl[1]_31 vddpe_31 vddce_31 vddc_31 vpw_32
+  bl[0]_30 nbl[0]_30 nbl[1]_30 vddce_30 vddc_30 vnwc_31 vpw_31 bl[3]_30
+  bl[0]_29 nbl[0]_29 nbl[1]_29 vddce_29 vddc_29 vnwc_30 vpw_30 nbl[3]_29
+  bl[3]_29 bl[0]_28 nbl[0]_28 nbl[1]_28 vddce_28 vddc_28 vnwc_29 vpw_29
+  nbl[3]_28 bl[3]_28 bl[0]_27 nbl[0]_27 nbl[1]_27 vddce_27 vddc_27 vnwc_28
+  vpw_28 nbl[3]_27 bl[3]_27 nbl[0]_26 nbl[1]_26 vddce_26 vddc_26 vnwc_27
+  vpw_27 bl[2]_26 bl[3]_26 nbl[0]_25 nbl[1]_25 vddc_25 vpw_26 bl[2]_25
+  bl[3]_25 vddc_24 bl[3]_24 vddc_23 nbl[3]_23 bl[3]_23 vddc_22 nbl[3]_22
+  bl[3]_22 nbl[3]_21 bl[3]_21 bl[2]_20 nbl[3]_20 bl[3]_20 bl[2]_19 nbl[2]_19
+  nbl[3]_19 bl[3]_19 vddc_18 nbl[3]_18 bl[3]_18 vddc_17 nbl[3]_17 bl[3]_17
+  nbl[3]_16 bl[3]_16 bl[2]_15 nbl[3]_15 bl[3]_15 bl[2]_14 nbl[3]_14 bl[3]_14
+  bl[2]_13 nbl[2]_13 nbl[3]_13 bl[3]_13 bl[2]_12 nbl[2]_12 nbl[3]_12 bl[3]_12
+  nbl[3]_11 bl[3]_11 bl[2]_10 nbl[3]_10 bl[3]_10 bl[2]_9 nbl[3]_9 bl[3]_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[2]_6
+  nbl[2]_6 nbl[3]_6 bl[2]_5 nbl[3]_5 bl[3]_5 bl[2]_4 nbl[3]_4 bl[3]_4 bl[2]_3
+  nbl[2]_3 nbl[3]_3 bl[3]_3 bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[2]_1
+  nbl[2]_1 nbl[3]_1 bl[2]_0 nbl[2]_0 nbl[3]_0 wl[1] wl[0]
** rf64x128mem_l_test10row: 1548 flat devices **
xmem_l_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0 ncored00_320 ncored01_322 ncored10_324
+  ncored11_326 ncored20_328 ncored21_330 ncored30_332 ncored31_334 vddc_0
+  vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_1 nbl[1]_1 nbl[2]_1 nbl[3]_1 ncored00_352 ncored01_354 ncored10_356
+  ncored11_358 ncored20_360 ncored21_362 ncored30_364 ncored31_366 vddc_1
+  vddce_1 vddpe_1 vnwc_2 vpw_2 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_624 cored01_626
+  cored10_628 cored11_630 cored20_632 cored21_634 cored30_636 cored31_638
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_640 ncored01_642
+  ncored10_644 ncored11_646 ncored20_648 ncored21_650 ncored30_652
+  ncored31_654 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_656 cored01_658
+  cored10_660 cored11_662 cored20_664 cored21_666 cored30_668 cored31_670
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_672 ncored01_674
+  ncored10_676 ncored11_678 ncored20_680 ncored21_682 ncored30_684
+  ncored31_686 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_12 bl[0]_12 bl[1]_12 bl[2]_12 bl[3]_12 cored00_688 cored01_690
+  cored10_692 cored11_694 cored20_696 cored21_698 cored30_700 cored31_702
+  nbl[0]_12 nbl[1]_12 nbl[2]_12 nbl[3]_12 ncored00_704 ncored01_706
+  ncored10_708 ncored11_710 ncored20_712 ncored21_714 ncored30_716
+  ncored31_718 vddc_12 vddce_12 vddpe_12 vnwc_13 vpw_13 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_13 bl[0]_13 bl[1]_13 bl[2]_13 bl[3]_13 cored00_752 cored01_754
+  cored10_756 cored11_758 cored20_760 cored21_762 cored30_764 cored31_766
+  nbl[0]_13 nbl[1]_13 nbl[2]_13 nbl[3]_13 ncored00_768 ncored01_770
+  ncored10_772 ncored11_774 ncored20_776 ncored21_778 ncored30_780
+  ncored31_782 vddc_13 vddce_13 vddpe_13 vnwc_14 vpw_14 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_14 bl[0]_14 bl[1]_14 bl[2]_14 bl[3]_14 cored00_816 cored01_818
+  cored10_820 cored11_822 cored20_824 cored21_826 cored30_828 cored31_830
+  nbl[0]_14 nbl[1]_14 nbl[2]_14 nbl[3]_14 ncored00_832 ncored01_834
+  ncored10_836 ncored11_838 ncored20_840 ncored21_842 ncored30_844
+  ncored31_846 vddc_14 vddce_14 vddpe_14 vnwc_15 vpw_15 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_15 bl[0]_15 bl[1]_15 bl[2]_15 bl[3]_15 cored00_848 cored01_850
+  cored10_852 cored11_854 cored20_856 cored21_858 cored30_860 cored31_862
+  nbl[0]_15 nbl[1]_15 nbl[2]_15 nbl[3]_15 ncored00_864 ncored01_866
+  ncored10_868 ncored11_870 ncored20_872 ncored21_874 ncored30_876
+  ncored31_878 vddc_15 vddce_15 vddpe_15 vnwc_16 vpw_16 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_16 bl[0]_16 bl[1]_16 bl[2]_16 bl[3]_16 cored00_880 cored01_882
+  cored10_884 cored11_886 cored20_888 cored21_890 cored30_892 cored31_894
+  nbl[0]_16 nbl[1]_16 nbl[2]_16 nbl[3]_16 ncored00_896 ncored01_898
+  ncored10_900 ncored11_902 ncored20_904 ncored21_906 ncored30_908
+  ncored31_910 vddc_16 vddce_16 vddpe_16 vnwc_17 vpw_17 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_17 bl[0]_17 bl[1]_17 bl[2]_17 bl[3]_17 cored00_912 cored01_914
+  cored10_916 cored11_918 cored20_920 cored21_922 cored30_924 cored31_926
+  nbl[0]_17 nbl[1]_17 nbl[2]_17 nbl[3]_17 ncored00_928 ncored01_930
+  ncored10_932 ncored11_934 ncored20_936 ncored21_938 ncored30_940
+  ncored31_942 vddc_17 vddce_17 vddpe_17 vnwc_18 vpw_18 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_18 bl[0]_18 bl[1]_18 bl[2]_18 bl[3]_18 cored00_944 cored01_946
+  cored10_948 cored11_950 cored20_952 cored21_954 cored30_956 cored31_958
+  nbl[0]_18 nbl[1]_18 nbl[2]_18 nbl[3]_18 ncored00_960 ncored01_962
+  ncored10_964 ncored11_966 ncored20_968 ncored21_970 ncored30_972
+  ncored31_974 vddc_18 vddce_18 vddpe_18 vnwc_19 vpw_19 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_19 bl[0]_19 bl[1]_19 bl[2]_19 bl[3]_19 cored00_976 cored01_978
+  cored10_980 cored11_982 cored20_984 cored21_986 cored30_988 cored31_990
+  nbl[0]_19 nbl[1]_19 nbl[2]_19 nbl[3]_19 ncored00_992 ncored01_994
+  ncored10_996 ncored11_998 ncored20_1000 ncored21_1002 ncored30_1004
+  ncored31_1006 vddc_19 vddce_19 vddpe_19 vnwc_20 vpw_20 vssc vssc wl[0]
+  wl[1] rf64x128cchs4
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_368 cored01_370
+  cored10_372 cored11_374 cored20_376 cored21_378 cored30_380 cored31_382
+  nbl[0]_2 nbl[1]_2 nbl[2]_2 nbl[3]_2 ncored00_384 ncored01_386 ncored10_388
+  ncored11_390 ncored20_392 ncored21_394 ncored30_396 ncored31_398 vddc_2
+  vddce_2 vddpe_2 vnwc_3 vpw_3 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_20 bl[0]_20 bl[1]_20 bl[2]_20 bl[3]_20 cored00 cored01 cored10
+  cored11 cored20 cored21 cored30 cored31 nbl[0]_20 nbl[1]_20 nbl[2]_20
+  nbl[3]_20 ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30
+  ncored31 vddc_20 vddce_20 vddpe_20 vnwc_21 vpw_21 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_21 bl[0]_21 bl[1]_21 bl[2]_21 bl[3]_21 cored00_16 cored01_18
+  cored10_20 cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_21
+  nbl[1]_21 nbl[2]_21 nbl[3]_21 ncored00_32 ncored01_34 ncored10_36
+  ncored11_38 ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_21
+  vddce_21 vddpe_21 vnwc_22 vpw_22 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_22 bl[0]_22 bl[1]_22 bl[2]_22 bl[3]_22 cored00_48 cored01_50
+  cored10_52 cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_22
+  nbl[1]_22 nbl[2]_22 nbl[3]_22 ncored00_64 ncored01_66 ncored10_68
+  ncored11_70 ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_22
+  vddce_22 vddpe_22 vnwc_23 vpw_23 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_23 bl[0]_23 bl[1]_23 bl[2]_23 bl[3]_23 cored00_80 cored01_82
+  cored10_84 cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_23
+  nbl[1]_23 nbl[2]_23 nbl[3]_23 ncored00_96 ncored01_98 ncored10_100
+  ncored11_102 ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_23
+  vddce_23 vddpe_23 vnwc_24 vpw_24 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_24 bl[0]_24 bl[1]_24 bl[2]_24 bl[3]_24 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_24 nbl[1]_24 nbl[2]_24 nbl[3]_24 ncored00_128 ncored01_130
+  ncored10_132 ncored11_134 ncored20_136 ncored21_138 ncored30_140
+  ncored31_142 vddc_24 vddce_24 vddpe_24 vnwc_25 vpw_25 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_25 bl[0]_25 bl[1]_25 bl[2]_25 bl[3]_25 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_25 nbl[1]_25 nbl[2]_25 nbl[3]_25 ncored00_160 ncored01_162
+  ncored10_164 ncored11_166 ncored20_168 ncored21_170 ncored30_172
+  ncored31_174 vddc_25 vddce_25 vddpe_25 vnwc_26 vpw_26 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_26 bl[0]_26 bl[1]_26 bl[2]_26 bl[3]_26 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_26 nbl[1]_26 nbl[2]_26 nbl[3]_26 ncored00_192 ncored01_194
+  ncored10_196 ncored11_198 ncored20_200 ncored21_202 ncored30_204
+  ncored31_206 vddc_26 vddce_26 vddpe_26 vnwc_27 vpw_27 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_27 bl[0]_27 bl[1]_27 bl[2]_27 bl[3]_27 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_27 nbl[1]_27 nbl[2]_27 nbl[3]_27 ncored00_224 ncored01_226
+  ncored10_228 ncored11_230 ncored20_232 ncored21_234 ncored30_236
+  ncored31_238 vddc_27 vddce_27 vddpe_27 vnwc_28 vpw_28 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_28 bl[0]_28 bl[1]_28 bl[2]_28 bl[3]_28 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_28 nbl[1]_28 nbl[2]_28 nbl[3]_28 ncored00_256 ncored01_258
+  ncored10_260 ncored11_262 ncored20_264 ncored21_266 ncored30_268
+  ncored31_270 vddc_28 vddce_28 vddpe_28 vnwc_29 vpw_29 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_29 bl[0]_29 bl[1]_29 bl[2]_29 bl[3]_29 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_29 nbl[1]_29 nbl[2]_29 nbl[3]_29 ncored00_288 ncored01_290
+  ncored10_292 ncored11_294 ncored20_296 ncored21_298 ncored30_300
+  ncored31_302 vddc_29 vddce_29 vddpe_29 vnwc_30 vpw_30 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_400 cored01_402
+  cored10_404 cored11_406 cored20_408 cored21_410 cored30_412 cored31_414
+  nbl[0]_3 nbl[1]_3 nbl[2]_3 nbl[3]_3 ncored00_416 ncored01_418 ncored10_420
+  ncored11_422 ncored20_424 ncored21_426 ncored30_428 ncored31_430 vddc_3
+  vddce_3 vddpe_3 vnwc_4 vpw_4 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_30 bl[0]_30 bl[1]_30 bl[2]_30 bl[3]_30 cored00_720 cored01_722
+  cored10_724 cored11_726 cored20_728 cored21_730 cored30_732 cored31_734
+  nbl[0]_30 nbl[1]_30 nbl[2]_30 nbl[3]_30 ncored00_736 ncored01_738
+  ncored10_740 ncored11_742 ncored20_744 ncored21_746 ncored30_748
+  ncored31_750 vddc_30 vddce_30 vddpe_30 vnwc_31 vpw_31 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_31 bl[0]_31 bl[1]_31 bl[2]_31 bl[3]_31 cored00_784 cored01_786
+  cored10_788 cored11_790 cored20_792 cored21_794 cored30_796 cored31_798
+  nbl[0]_31 nbl[1]_31 nbl[2]_31 nbl[3]_31 ncored00_800 ncored01_802
+  ncored10_804 ncored11_806 ncored20_808 ncored21_810 ncored30_812
+  ncored31_814 vddc_31 vddce_31 vddpe_31 vnwc_32 vpw_32 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_432 cored01_434
+  cored10_436 cored11_438 cored20_440 cored21_442 cored30_444 cored31_446
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_448 ncored01_450 ncored10_452
+  ncored11_454 ncored20_456 ncored21_458 ncored30_460 ncored31_462 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_464 cored01_466
+  cored10_468 cored11_470 cored20_472 cored21_474 cored30_476 cored31_478
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_480 ncored01_482 ncored10_484
+  ncored11_486 ncored20_488 ncored21_490 ncored30_492 ncored31_494 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_496 cored01_498
+  cored10_500 cored11_502 cored20_504 cored21_506 cored30_508 cored31_510
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_512 ncored01_514 ncored10_516
+  ncored11_518 ncored20_520 ncored21_522 ncored30_524 ncored31_526 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_528 cored01_530
+  cored10_532 cored11_534 cored20_536 cored21_538 cored30_540 cored31_542
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_544 ncored01_546 ncored10_548
+  ncored11_550 ncored20_552 ncored21_554 ncored30_556 ncored31_558 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_560 cored01_562
+  cored10_564 cored11_566 cored20_568 cored21_570 cored30_572 cored31_574
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_576 ncored01_578 ncored10_580
+  ncored11_582 ncored20_584 ncored21_586 ncored30_588 ncored31_590 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_592 cored01_594
+  cored10_596 cored11_598 cored20_600 cored21_602 cored30_604 cored31_606
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_608 ncored01_610 ncored10_612
+  ncored11_614 ncored20_616 ncored21_618 ncored30_620 ncored31_622 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_edger dbl dwl vddc_32 vnwc_33 vnwp_1 vpw_33 vssc wl[0] wl[1]
+  rf64x128cchs4wd_edgbl_dummy
.ends rf64x128mem_l_test10row
****
.subckt rf64x128cchs4wd_edgbl dbl dwl vddc vnwc vnwp vpw vssc wl[0] wl[1]
** rf64x128cchs4wd_edgbl: 12 flat devices **
mi0.mxn0 net11 wl[0] i0.ncored vpw nchpg_sr W=0.105U L=0.035U NF=1
mi0.mxn1 i0.ncored i0.core vssc vpw nchpd_sr W=0.14U L=0.035U NF=1
mi0.mxn2 i0.cored vddc vssc vpw nchpd_sr W=0.14U L=0.035U NF=1
mi0.mxn3 dbl dwl i0.cored vpw nchpg_sr W=0.105U L=0.035U NF=1
mi0.mxp0 vddc i0.core vddc vnwc pchpu_sr W=0.05U L=0.035U NF=1
mi0.mxp1 i0.core vddc vddc vnwc pchpu_sr W=0.05U L=0.035U NF=1
mi14.mxn0 net11 wl[1] i14.ncored vpw nchpg_sr W=0.105U L=0.035U NF=1
mi14.mxn1 i14.ncored i14.core vssc vpw nchpd_sr W=0.14U L=0.035U NF=1
mi14.mxn2 i14.cored vddc vssc vpw nchpd_sr W=0.14U L=0.035U NF=1
mi14.mxn3 dbl dwl i14.cored vpw nchpg_sr W=0.105U L=0.035U NF=1
mi14.mxp0 vddc i14.core vddc vnwc pchpu_sr W=0.05U L=0.035U NF=1
mi14.mxp1 i14.core vddc vddc vnwc pchpu_sr W=0.05U L=0.035U NF=1
.ends rf64x128cchs4wd_edgbl
****
.subckt rf64x128mem_l_test11row vddc_32 vpw_33 vnwc_33 dbl dwl vddc_31 vnwc_32
+  bl[2]_31 nbl[2]_31 nbl[3]_31 bl[3]_31 bl[1]_30 vddpe_30 bl[2]_30 nbl[2]_30
+  nbl[3]_30 bl[1]_29 vddpe_29 bl[2]_29 nbl[2]_29 bl[1]_28 vddpe_28 bl[2]_28
+  nbl[2]_28 bl[1]_27 vddpe_27 bl[2]_27 nbl[2]_27 bl[0]_26 bl[1]_26 vddpe_26
+  nbl[2]_26 nbl[3]_26 bl[0]_25 bl[1]_25 vddpe_25 vddce_25 vnwc_26 vssc
+  nbl[2]_25 nbl[3]_25 bl[0]_24 nbl[0]_24 nbl[1]_24 bl[1]_24 vddpe_24 vddce_24
+  vnwc_25 vpw_25 bl[2]_24 nbl[2]_24 nbl[3]_24 bl[0]_23 nbl[0]_23 nbl[1]_23
+  bl[1]_23 vddpe_23 vddce_23 vnwc_24 vpw_24 bl[2]_23 nbl[2]_23 bl[0]_22
+  nbl[0]_22 nbl[1]_22 bl[1]_22 vddpe_22 vddce_22 vnwc_23 vpw_23 bl[2]_22
+  nbl[2]_22 bl[0]_21 nbl[0]_21 nbl[1]_21 bl[1]_21 vddpe_21 vddce_21 vddc_21
+  vnwc_22 vpw_22 bl[2]_21 nbl[2]_21 bl[0]_20 nbl[0]_20 nbl[1]_20 bl[1]_20
+  vddpe_20 vddce_20 vddc_20 vnwc_21 vpw_21 nbl[2]_20 bl[0]_19 nbl[0]_19
+  nbl[1]_19 bl[1]_19 vddpe_19 vddce_19 vddc_19 vnwc_20 vpw_20 bl[0]_18
+  nbl[0]_18 nbl[1]_18 bl[1]_18 vddpe_18 vddce_18 vnwc_19 vpw_19 bl[2]_18
+  nbl[2]_18 bl[0]_17 nbl[0]_17 nbl[1]_17 bl[1]_17 vddpe_17 vddce_17 vnwc_18
+  vpw_18 bl[2]_17 nbl[2]_17 bl[0]_16 nbl[0]_16 nbl[1]_16 bl[1]_16 vddpe_16
+  vddce_16 vddc_16 vnwc_17 vpw_17 bl[2]_16 nbl[2]_16 bl[0]_15 nbl[0]_15
+  nbl[1]_15 bl[1]_15 vddpe_15 vddce_15 vddc_15 vnwc_16 vpw_16 nbl[2]_15
+  bl[0]_14 nbl[0]_14 nbl[1]_14 bl[1]_14 vddpe_14 vddce_14 vddc_14 vnwc_15
+  vpw_15 nbl[2]_14 bl[0]_13 nbl[0]_13 nbl[1]_13 bl[1]_13 vddpe_13 vddce_13
+  vddc_13 vnwc_14 vpw_14 bl[0]_12 nbl[0]_12 nbl[1]_12 bl[1]_12 vddpe_12
+  vddce_12 vddc_12 vnwc_13 vpw_13 bl[0]_11 nbl[0]_11 nbl[1]_11 bl[1]_11
+  vddpe_11 vddce_11 vddc_11 vnwc_12 vpw_12 bl[2]_11 nbl[2]_11 bl[0]_10
+  nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vddc_10 vnwc_11 vpw_11
+  nbl[2]_10 bl[0]_9 nbl[0]_9 nbl[1]_9 bl[1]_9 vddpe_9 vddce_9 vddc_9 vnwc_10
+  vpw_10 nbl[2]_9 bl[0]_8 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 vddce_8 vddc_8
+  vnwc_9 vpw_9 bl[0]_7 nbl[0]_7 nbl[1]_7 bl[1]_7 vddpe_7 vddce_7 vddc_7
+  vnwc_8 vpw_8 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddpe_6 vddce_6 vddc_6
+  vnwc_7 vpw_7 bl[3]_6 bl[0]_5 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe_5 vddce_5
+  vddc_5 vnwc_6 vpw_6 nbl[2]_5 bl[0]_4 nbl[0]_4 nbl[1]_4 bl[1]_4 vddpe_4
+  vddce_4 vddc_4 vnwc_5 vpw_5 nbl[2]_4 bl[0]_3 nbl[0]_3 nbl[1]_3 bl[1]_3
+  vddpe_3 vddce_3 vddc_3 vnwc_4 vpw_4 bl[0]_2 nbl[0]_2 nbl[1]_2 bl[1]_2
+  vddpe_2 vddce_2 vddc_2 vnwc_3 vpw_3 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1
+  vddpe_1 vddce_1 vddc_1 vnwc_2 vpw_2 bl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0
+  bl[1]_0 vddpe_0 vddce_0 vddc_0 vnwc_1 vpw_1 bl[3]_0 vnwp_0 vnwc_0 vpw_0
+  vnwp_1 bl[0]_31 nbl[0]_31 nbl[1]_31 bl[1]_31 vddpe_31 vddce_31 vpw_32
+  bl[0]_30 nbl[0]_30 nbl[1]_30 vddce_30 vddc_30 vnwc_31 vpw_31 bl[3]_30
+  bl[0]_29 nbl[0]_29 nbl[1]_29 vddce_29 vddc_29 vnwc_30 vpw_30 nbl[3]_29
+  bl[3]_29 bl[0]_28 nbl[0]_28 nbl[1]_28 vddce_28 vddc_28 vnwc_29 vpw_29
+  nbl[3]_28 bl[3]_28 bl[0]_27 nbl[0]_27 nbl[1]_27 vddce_27 vddc_27 vnwc_28
+  vpw_28 nbl[3]_27 bl[3]_27 nbl[0]_26 nbl[1]_26 vddce_26 vddc_26 vnwc_27
+  vpw_27 bl[2]_26 bl[3]_26 nbl[0]_25 nbl[1]_25 vddc_25 vpw_26 bl[2]_25
+  bl[3]_25 vddc_24 bl[3]_24 vddc_23 nbl[3]_23 bl[3]_23 vddc_22 nbl[3]_22
+  bl[3]_22 nbl[3]_21 bl[3]_21 bl[2]_20 nbl[3]_20 bl[3]_20 bl[2]_19 nbl[2]_19
+  nbl[3]_19 bl[3]_19 vddc_18 nbl[3]_18 bl[3]_18 vddc_17 nbl[3]_17 bl[3]_17
+  nbl[3]_16 bl[3]_16 bl[2]_15 nbl[3]_15 bl[3]_15 bl[2]_14 nbl[3]_14 bl[3]_14
+  bl[2]_13 nbl[2]_13 nbl[3]_13 bl[3]_13 bl[2]_12 nbl[2]_12 nbl[3]_12 bl[3]_12
+  nbl[3]_11 bl[3]_11 bl[2]_10 nbl[3]_10 bl[3]_10 bl[2]_9 nbl[3]_9 bl[3]_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[2]_6
+  nbl[2]_6 nbl[3]_6 bl[2]_5 nbl[3]_5 bl[3]_5 bl[2]_4 nbl[3]_4 bl[3]_4 bl[2]_3
+  nbl[2]_3 nbl[3]_3 bl[3]_3 bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[2]_1
+  nbl[2]_1 nbl[3]_1 bl[2]_0 nbl[2]_0 nbl[3]_0 wl[1] wl[0]
** rf64x128mem_l_test11row: 1548 flat devices **
xmem_l_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0 ncored00_320 ncored01_322 ncored10_324
+  ncored11_326 ncored20_328 ncored21_330 ncored30_332 ncored31_334 vddc_0
+  vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_1 nbl[1]_1 nbl[2]_1 nbl[3]_1 ncored00_352 ncored01_354 ncored10_356
+  ncored11_358 ncored20_360 ncored21_362 ncored30_364 ncored31_366 vddc_1
+  vddce_1 vddpe_1 vnwc_2 vpw_2 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_624 cored01_626
+  cored10_628 cored11_630 cored20_632 cored21_634 cored30_636 cored31_638
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_640 ncored01_642
+  ncored10_644 ncored11_646 ncored20_648 ncored21_650 ncored30_652
+  ncored31_654 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_656 cored01_658
+  cored10_660 cored11_662 cored20_664 cored21_666 cored30_668 cored31_670
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_672 ncored01_674
+  ncored10_676 ncored11_678 ncored20_680 ncored21_682 ncored30_684
+  ncored31_686 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_12 bl[0]_12 bl[1]_12 bl[2]_12 bl[3]_12 cored00_688 cored01_690
+  cored10_692 cored11_694 cored20_696 cored21_698 cored30_700 cored31_702
+  nbl[0]_12 nbl[1]_12 nbl[2]_12 nbl[3]_12 ncored00_704 ncored01_706
+  ncored10_708 ncored11_710 ncored20_712 ncored21_714 ncored30_716
+  ncored31_718 vddc_12 vddce_12 vddpe_12 vnwc_13 vpw_13 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_13 bl[0]_13 bl[1]_13 bl[2]_13 bl[3]_13 cored00_752 cored01_754
+  cored10_756 cored11_758 cored20_760 cored21_762 cored30_764 cored31_766
+  nbl[0]_13 nbl[1]_13 nbl[2]_13 nbl[3]_13 ncored00_768 ncored01_770
+  ncored10_772 ncored11_774 ncored20_776 ncored21_778 ncored30_780
+  ncored31_782 vddc_13 vddce_13 vddpe_13 vnwc_14 vpw_14 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_14 bl[0]_14 bl[1]_14 bl[2]_14 bl[3]_14 cored00_816 cored01_818
+  cored10_820 cored11_822 cored20_824 cored21_826 cored30_828 cored31_830
+  nbl[0]_14 nbl[1]_14 nbl[2]_14 nbl[3]_14 ncored00_832 ncored01_834
+  ncored10_836 ncored11_838 ncored20_840 ncored21_842 ncored30_844
+  ncored31_846 vddc_14 vddce_14 vddpe_14 vnwc_15 vpw_15 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_15 bl[0]_15 bl[1]_15 bl[2]_15 bl[3]_15 cored00_848 cored01_850
+  cored10_852 cored11_854 cored20_856 cored21_858 cored30_860 cored31_862
+  nbl[0]_15 nbl[1]_15 nbl[2]_15 nbl[3]_15 ncored00_864 ncored01_866
+  ncored10_868 ncored11_870 ncored20_872 ncored21_874 ncored30_876
+  ncored31_878 vddc_15 vddce_15 vddpe_15 vnwc_16 vpw_16 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_16 bl[0]_16 bl[1]_16 bl[2]_16 bl[3]_16 cored00_880 cored01_882
+  cored10_884 cored11_886 cored20_888 cored21_890 cored30_892 cored31_894
+  nbl[0]_16 nbl[1]_16 nbl[2]_16 nbl[3]_16 ncored00_896 ncored01_898
+  ncored10_900 ncored11_902 ncored20_904 ncored21_906 ncored30_908
+  ncored31_910 vddc_16 vddce_16 vddpe_16 vnwc_17 vpw_17 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_17 bl[0]_17 bl[1]_17 bl[2]_17 bl[3]_17 cored00_912 cored01_914
+  cored10_916 cored11_918 cored20_920 cored21_922 cored30_924 cored31_926
+  nbl[0]_17 nbl[1]_17 nbl[2]_17 nbl[3]_17 ncored00_928 ncored01_930
+  ncored10_932 ncored11_934 ncored20_936 ncored21_938 ncored30_940
+  ncored31_942 vddc_17 vddce_17 vddpe_17 vnwc_18 vpw_18 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_18 bl[0]_18 bl[1]_18 bl[2]_18 bl[3]_18 cored00_944 cored01_946
+  cored10_948 cored11_950 cored20_952 cored21_954 cored30_956 cored31_958
+  nbl[0]_18 nbl[1]_18 nbl[2]_18 nbl[3]_18 ncored00_960 ncored01_962
+  ncored10_964 ncored11_966 ncored20_968 ncored21_970 ncored30_972
+  ncored31_974 vddc_18 vddce_18 vddpe_18 vnwc_19 vpw_19 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_19 bl[0]_19 bl[1]_19 bl[2]_19 bl[3]_19 cored00_976 cored01_978
+  cored10_980 cored11_982 cored20_984 cored21_986 cored30_988 cored31_990
+  nbl[0]_19 nbl[1]_19 nbl[2]_19 nbl[3]_19 ncored00_992 ncored01_994
+  ncored10_996 ncored11_998 ncored20_1000 ncored21_1002 ncored30_1004
+  ncored31_1006 vddc_19 vddce_19 vddpe_19 vnwc_20 vpw_20 vssc vssc wl[0]
+  wl[1] rf64x128cchs4
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_368 cored01_370
+  cored10_372 cored11_374 cored20_376 cored21_378 cored30_380 cored31_382
+  nbl[0]_2 nbl[1]_2 nbl[2]_2 nbl[3]_2 ncored00_384 ncored01_386 ncored10_388
+  ncored11_390 ncored20_392 ncored21_394 ncored30_396 ncored31_398 vddc_2
+  vddce_2 vddpe_2 vnwc_3 vpw_3 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_20 bl[0]_20 bl[1]_20 bl[2]_20 bl[3]_20 cored00 cored01 cored10
+  cored11 cored20 cored21 cored30 cored31 nbl[0]_20 nbl[1]_20 nbl[2]_20
+  nbl[3]_20 ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30
+  ncored31 vddc_20 vddce_20 vddpe_20 vnwc_21 vpw_21 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_21 bl[0]_21 bl[1]_21 bl[2]_21 bl[3]_21 cored00_16 cored01_18
+  cored10_20 cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_21
+  nbl[1]_21 nbl[2]_21 nbl[3]_21 ncored00_32 ncored01_34 ncored10_36
+  ncored11_38 ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_21
+  vddce_21 vddpe_21 vnwc_22 vpw_22 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_22 bl[0]_22 bl[1]_22 bl[2]_22 bl[3]_22 cored00_48 cored01_50
+  cored10_52 cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_22
+  nbl[1]_22 nbl[2]_22 nbl[3]_22 ncored00_64 ncored01_66 ncored10_68
+  ncored11_70 ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_22
+  vddce_22 vddpe_22 vnwc_23 vpw_23 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_23 bl[0]_23 bl[1]_23 bl[2]_23 bl[3]_23 cored00_80 cored01_82
+  cored10_84 cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_23
+  nbl[1]_23 nbl[2]_23 nbl[3]_23 ncored00_96 ncored01_98 ncored10_100
+  ncored11_102 ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_23
+  vddce_23 vddpe_23 vnwc_24 vpw_24 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_24 bl[0]_24 bl[1]_24 bl[2]_24 bl[3]_24 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_24 nbl[1]_24 nbl[2]_24 nbl[3]_24 ncored00_128 ncored01_130
+  ncored10_132 ncored11_134 ncored20_136 ncored21_138 ncored30_140
+  ncored31_142 vddc_24 vddce_24 vddpe_24 vnwc_25 vpw_25 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_25 bl[0]_25 bl[1]_25 bl[2]_25 bl[3]_25 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_25 nbl[1]_25 nbl[2]_25 nbl[3]_25 ncored00_160 ncored01_162
+  ncored10_164 ncored11_166 ncored20_168 ncored21_170 ncored30_172
+  ncored31_174 vddc_25 vddce_25 vddpe_25 vnwc_26 vpw_26 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_26 bl[0]_26 bl[1]_26 bl[2]_26 bl[3]_26 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_26 nbl[1]_26 nbl[2]_26 nbl[3]_26 ncored00_192 ncored01_194
+  ncored10_196 ncored11_198 ncored20_200 ncored21_202 ncored30_204
+  ncored31_206 vddc_26 vddce_26 vddpe_26 vnwc_27 vpw_27 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_27 bl[0]_27 bl[1]_27 bl[2]_27 bl[3]_27 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_27 nbl[1]_27 nbl[2]_27 nbl[3]_27 ncored00_224 ncored01_226
+  ncored10_228 ncored11_230 ncored20_232 ncored21_234 ncored30_236
+  ncored31_238 vddc_27 vddce_27 vddpe_27 vnwc_28 vpw_28 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_28 bl[0]_28 bl[1]_28 bl[2]_28 bl[3]_28 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_28 nbl[1]_28 nbl[2]_28 nbl[3]_28 ncored00_256 ncored01_258
+  ncored10_260 ncored11_262 ncored20_264 ncored21_266 ncored30_268
+  ncored31_270 vddc_28 vddce_28 vddpe_28 vnwc_29 vpw_29 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_29 bl[0]_29 bl[1]_29 bl[2]_29 bl[3]_29 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_29 nbl[1]_29 nbl[2]_29 nbl[3]_29 ncored00_288 ncored01_290
+  ncored10_292 ncored11_294 ncored20_296 ncored21_298 ncored30_300
+  ncored31_302 vddc_29 vddce_29 vddpe_29 vnwc_30 vpw_30 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_400 cored01_402
+  cored10_404 cored11_406 cored20_408 cored21_410 cored30_412 cored31_414
+  nbl[0]_3 nbl[1]_3 nbl[2]_3 nbl[3]_3 ncored00_416 ncored01_418 ncored10_420
+  ncored11_422 ncored20_424 ncored21_426 ncored30_428 ncored31_430 vddc_3
+  vddce_3 vddpe_3 vnwc_4 vpw_4 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_30 bl[0]_30 bl[1]_30 bl[2]_30 bl[3]_30 cored00_720 cored01_722
+  cored10_724 cored11_726 cored20_728 cored21_730 cored30_732 cored31_734
+  nbl[0]_30 nbl[1]_30 nbl[2]_30 nbl[3]_30 ncored00_736 ncored01_738
+  ncored10_740 ncored11_742 ncored20_744 ncored21_746 ncored30_748
+  ncored31_750 vddc_30 vddce_30 vddpe_30 vnwc_31 vpw_31 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_31 bl[0]_31 bl[1]_31 bl[2]_31 bl[3]_31 cored00_784 cored01_786
+  cored10_788 cored11_790 cored20_792 cored21_794 cored30_796 cored31_798
+  nbl[0]_31 nbl[1]_31 nbl[2]_31 nbl[3]_31 ncored00_800 ncored01_802
+  ncored10_804 ncored11_806 ncored20_808 ncored21_810 ncored30_812
+  ncored31_814 vddc_31 vddce_31 vddpe_31 vnwc_32 vpw_32 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_432 cored01_434
+  cored10_436 cored11_438 cored20_440 cored21_442 cored30_444 cored31_446
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_448 ncored01_450 ncored10_452
+  ncored11_454 ncored20_456 ncored21_458 ncored30_460 ncored31_462 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_464 cored01_466
+  cored10_468 cored11_470 cored20_472 cored21_474 cored30_476 cored31_478
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_480 ncored01_482 ncored10_484
+  ncored11_486 ncored20_488 ncored21_490 ncored30_492 ncored31_494 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_496 cored01_498
+  cored10_500 cored11_502 cored20_504 cored21_506 cored30_508 cored31_510
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_512 ncored01_514 ncored10_516
+  ncored11_518 ncored20_520 ncored21_522 ncored30_524 ncored31_526 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_528 cored01_530
+  cored10_532 cored11_534 cored20_536 cored21_538 cored30_540 cored31_542
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_544 ncored01_546 ncored10_548
+  ncored11_550 ncored20_552 ncored21_554 ncored30_556 ncored31_558 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_560 cored01_562
+  cored10_564 cored11_566 cored20_568 cored21_570 cored30_572 cored31_574
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_576 ncored01_578 ncored10_580
+  ncored11_582 ncored20_584 ncored21_586 ncored30_588 ncored31_590 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_592 cored01_594
+  cored10_596 cored11_598 cored20_600 cored21_602 cored30_604 cored31_606
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_608 ncored01_610 ncored10_612
+  ncored11_614 ncored20_616 ncored21_618 ncored30_620 ncored31_622 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_edger dbl dwl vddc_32 vnwc_33 vnwp_1 vpw_33 vssc wl[0] wl[1]
+  rf64x128cchs4wd_edgbl
.ends rf64x128mem_l_test11row
****
.subckt rf64x128mem_l_test12row vddc_32 vpw_33 vnwc_33 vnwc_32 bl[2]_31
+  nbl[2]_31 nbl[3]_31 bl[3]_31 bl[1]_30 vddpe_30 bl[2]_30 nbl[2]_30 nbl[3]_30
+  bl[1]_29 vddpe_29 bl[2]_29 nbl[2]_29 bl[1]_28 vddpe_28 bl[2]_28 nbl[2]_28
+  bl[1]_27 vddpe_27 bl[2]_27 nbl[2]_27 bl[0]_26 bl[1]_26 vddpe_26 nbl[2]_26
+  nbl[3]_26 bl[0]_25 bl[1]_25 vddpe_25 vddce_25 vnwc_26 vssc nbl[2]_25
+  nbl[3]_25 bl[0]_24 nbl[0]_24 nbl[1]_24 bl[1]_24 vddpe_24 vddce_24 vnwc_25
+  vpw_25 bl[2]_24 nbl[2]_24 nbl[3]_24 bl[0]_23 nbl[0]_23 nbl[1]_23 bl[1]_23
+  vddpe_23 vddce_23 vnwc_24 vpw_24 bl[2]_23 nbl[2]_23 bl[0]_22 nbl[0]_22
+  nbl[1]_22 bl[1]_22 vddpe_22 vddce_22 vnwc_23 vpw_23 bl[2]_22 nbl[2]_22
+  bl[0]_21 nbl[0]_21 nbl[1]_21 bl[1]_21 vddpe_21 vddce_21 vddc_21 vnwc_22
+  vpw_22 bl[2]_21 nbl[2]_21 bl[0]_20 nbl[0]_20 nbl[1]_20 bl[1]_20 vddpe_20
+  vddce_20 vddc_20 vnwc_21 vpw_21 nbl[2]_20 bl[0]_19 nbl[0]_19 nbl[1]_19
+  bl[1]_19 vddpe_19 vddce_19 vddc_19 vnwc_20 vpw_20 bl[0]_18 nbl[0]_18
+  nbl[1]_18 bl[1]_18 vddpe_18 vddce_18 vnwc_19 vpw_19 bl[2]_18 nbl[2]_18
+  bl[0]_17 nbl[0]_17 nbl[1]_17 bl[1]_17 vddpe_17 vddce_17 vnwc_18 vpw_18
+  bl[2]_17 nbl[2]_17 bl[0]_16 nbl[0]_16 nbl[1]_16 bl[1]_16 vddpe_16 vddce_16
+  vddc_16 vnwc_17 vpw_17 bl[2]_16 nbl[2]_16 bl[0]_15 nbl[0]_15 nbl[1]_15
+  bl[1]_15 vddpe_15 vddce_15 vddc_15 vnwc_16 vpw_16 nbl[2]_15 bl[0]_14
+  nbl[0]_14 nbl[1]_14 bl[1]_14 vddpe_14 vddce_14 vddc_14 vnwc_15 vpw_15
+  nbl[2]_14 bl[0]_13 nbl[0]_13 nbl[1]_13 bl[1]_13 vddpe_13 vddce_13 vddc_13
+  vnwc_14 vpw_14 bl[0]_12 nbl[0]_12 nbl[1]_12 bl[1]_12 vddpe_12 vddce_12
+  vddc_12 vnwc_13 vpw_13 bl[0]_11 nbl[0]_11 nbl[1]_11 bl[1]_11 vddpe_11
+  vddce_11 vddc_11 vnwc_12 vpw_12 bl[2]_11 nbl[2]_11 bl[0]_10 nbl[0]_10
+  nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vddc_10 vnwc_11 vpw_11 nbl[2]_10
+  bl[0]_9 nbl[0]_9 nbl[1]_9 bl[1]_9 vddpe_9 vddce_9 vddc_9 vnwc_10 vpw_10
+  nbl[2]_9 bl[0]_8 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 vddce_8 vddc_8 vnwc_9
+  vpw_9 bl[0]_7 nbl[0]_7 nbl[1]_7 bl[1]_7 vddpe_7 vddce_7 vddc_7 vnwc_8 vpw_8
+  bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddpe_6 vddce_6 vddc_6 vnwc_7 vpw_7
+  bl[3]_6 bl[0]_5 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe_5 vddce_5 vddc_5 vnwc_6
+  vpw_6 nbl[2]_5 bl[0]_4 nbl[0]_4 nbl[1]_4 bl[1]_4 vddpe_4 vddce_4 vddc_4
+  vnwc_5 vpw_5 nbl[2]_4 bl[0]_3 nbl[0]_3 nbl[1]_3 bl[1]_3 vddpe_3 vddce_3
+  vddc_3 vnwc_4 vpw_4 bl[0]_2 nbl[0]_2 nbl[1]_2 bl[1]_2 vddpe_2 vddce_2
+  vddc_2 vnwc_3 vpw_3 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddpe_1 vddce_1
+  vddc_1 vnwc_2 vpw_2 bl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe_0
+  vddce_0 vddc_0 vnwc_1 vpw_1 bl[3]_0 vnwc_0 vpw_0 vnwp_1 dbl dwl bl[0]_31
+  nbl[0]_31 nbl[1]_31 bl[1]_31 vddpe_31 vddce_31 vddc_31 vpw_32 bl[0]_30
+  nbl[0]_30 nbl[1]_30 vddce_30 vddc_30 vnwc_31 vpw_31 bl[3]_30 bl[0]_29
+  nbl[0]_29 nbl[1]_29 vddce_29 vddc_29 vnwc_30 vpw_30 nbl[3]_29 bl[3]_29
+  bl[0]_28 nbl[0]_28 nbl[1]_28 vddce_28 vddc_28 vnwc_29 vpw_29 nbl[3]_28
+  bl[3]_28 bl[0]_27 nbl[0]_27 nbl[1]_27 vddce_27 vddc_27 vnwc_28 vpw_28
+  nbl[3]_27 bl[3]_27 nbl[0]_26 nbl[1]_26 vddce_26 vddc_26 vnwc_27 vpw_27
+  bl[2]_26 bl[3]_26 nbl[0]_25 nbl[1]_25 vddc_25 vpw_26 bl[2]_25 bl[3]_25
+  vddc_24 bl[3]_24 vddc_23 nbl[3]_23 bl[3]_23 vddc_22 nbl[3]_22 bl[3]_22
+  nbl[3]_21 bl[3]_21 bl[2]_20 nbl[3]_20 bl[3]_20 bl[2]_19 nbl[2]_19 nbl[3]_19
+  bl[3]_19 vddc_18 nbl[3]_18 bl[3]_18 vddc_17 nbl[3]_17 bl[3]_17 nbl[3]_16
+  bl[3]_16 bl[2]_15 nbl[3]_15 bl[3]_15 bl[2]_14 nbl[3]_14 bl[3]_14 bl[2]_13
+  nbl[2]_13 nbl[3]_13 bl[3]_13 bl[2]_12 nbl[2]_12 nbl[3]_12 bl[3]_12
+  nbl[3]_11 bl[3]_11 bl[2]_10 nbl[3]_10 bl[3]_10 bl[2]_9 nbl[3]_9 bl[3]_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[2]_6
+  nbl[2]_6 nbl[3]_6 bl[2]_5 nbl[3]_5 bl[3]_5 bl[2]_4 nbl[3]_4 bl[3]_4 bl[2]_3
+  nbl[2]_3 nbl[3]_3 bl[3]_3 bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[2]_1
+  nbl[2]_1 nbl[3]_1 bl[2]_0 nbl[2]_0 nbl[3]_0 vnwp_0 wl[0] wl[1]
** rf64x128mem_l_test12row: 1548 flat devices **
xmem_l_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0 ncored00_320 ncored01_322 ncored10_324
+  ncored11_326 ncored20_328 ncored21_330 ncored30_332 ncored31_334 vddc_0
+  vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_1 nbl[1]_1 nbl[2]_1 nbl[3]_1 ncored00_352 ncored01_354 ncored10_356
+  ncored11_358 ncored20_360 ncored21_362 ncored30_364 ncored31_366 vddc_1
+  vddce_1 vddpe_1 vnwc_2 vpw_2 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_624 cored01_626
+  cored10_628 cored11_630 cored20_632 cored21_634 cored30_636 cored31_638
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_640 ncored01_642
+  ncored10_644 ncored11_646 ncored20_648 ncored21_650 ncored30_652
+  ncored31_654 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_656 cored01_658
+  cored10_660 cored11_662 cored20_664 cored21_666 cored30_668 cored31_670
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_672 ncored01_674
+  ncored10_676 ncored11_678 ncored20_680 ncored21_682 ncored30_684
+  ncored31_686 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_12 bl[0]_12 bl[1]_12 bl[2]_12 bl[3]_12 cored00_688 cored01_690
+  cored10_692 cored11_694 cored20_696 cored21_698 cored30_700 cored31_702
+  nbl[0]_12 nbl[1]_12 nbl[2]_12 nbl[3]_12 ncored00_704 ncored01_706
+  ncored10_708 ncored11_710 ncored20_712 ncored21_714 ncored30_716
+  ncored31_718 vddc_12 vddce_12 vddpe_12 vnwc_13 vpw_13 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_13 bl[0]_13 bl[1]_13 bl[2]_13 bl[3]_13 cored00_752 cored01_754
+  cored10_756 cored11_758 cored20_760 cored21_762 cored30_764 cored31_766
+  nbl[0]_13 nbl[1]_13 nbl[2]_13 nbl[3]_13 ncored00_768 ncored01_770
+  ncored10_772 ncored11_774 ncored20_776 ncored21_778 ncored30_780
+  ncored31_782 vddc_13 vddce_13 vddpe_13 vnwc_14 vpw_14 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_14 bl[0]_14 bl[1]_14 bl[2]_14 bl[3]_14 cored00_816 cored01_818
+  cored10_820 cored11_822 cored20_824 cored21_826 cored30_828 cored31_830
+  nbl[0]_14 nbl[1]_14 nbl[2]_14 nbl[3]_14 ncored00_832 ncored01_834
+  ncored10_836 ncored11_838 ncored20_840 ncored21_842 ncored30_844
+  ncored31_846 vddc_14 vddce_14 vddpe_14 vnwc_15 vpw_15 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_15 bl[0]_15 bl[1]_15 bl[2]_15 bl[3]_15 cored00_848 cored01_850
+  cored10_852 cored11_854 cored20_856 cored21_858 cored30_860 cored31_862
+  nbl[0]_15 nbl[1]_15 nbl[2]_15 nbl[3]_15 ncored00_864 ncored01_866
+  ncored10_868 ncored11_870 ncored20_872 ncored21_874 ncored30_876
+  ncored31_878 vddc_15 vddce_15 vddpe_15 vnwc_16 vpw_16 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_16 bl[0]_16 bl[1]_16 bl[2]_16 bl[3]_16 cored00_880 cored01_882
+  cored10_884 cored11_886 cored20_888 cored21_890 cored30_892 cored31_894
+  nbl[0]_16 nbl[1]_16 nbl[2]_16 nbl[3]_16 ncored00_896 ncored01_898
+  ncored10_900 ncored11_902 ncored20_904 ncored21_906 ncored30_908
+  ncored31_910 vddc_16 vddce_16 vddpe_16 vnwc_17 vpw_17 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_17 bl[0]_17 bl[1]_17 bl[2]_17 bl[3]_17 cored00_912 cored01_914
+  cored10_916 cored11_918 cored20_920 cored21_922 cored30_924 cored31_926
+  nbl[0]_17 nbl[1]_17 nbl[2]_17 nbl[3]_17 ncored00_928 ncored01_930
+  ncored10_932 ncored11_934 ncored20_936 ncored21_938 ncored30_940
+  ncored31_942 vddc_17 vddce_17 vddpe_17 vnwc_18 vpw_18 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_18 bl[0]_18 bl[1]_18 bl[2]_18 bl[3]_18 cored00_944 cored01_946
+  cored10_948 cored11_950 cored20_952 cored21_954 cored30_956 cored31_958
+  nbl[0]_18 nbl[1]_18 nbl[2]_18 nbl[3]_18 ncored00_960 ncored01_962
+  ncored10_964 ncored11_966 ncored20_968 ncored21_970 ncored30_972
+  ncored31_974 vddc_18 vddce_18 vddpe_18 vnwc_19 vpw_19 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_19 bl[0]_19 bl[1]_19 bl[2]_19 bl[3]_19 cored00_976 cored01_978
+  cored10_980 cored11_982 cored20_984 cored21_986 cored30_988 cored31_990
+  nbl[0]_19 nbl[1]_19 nbl[2]_19 nbl[3]_19 ncored00_992 ncored01_994
+  ncored10_996 ncored11_998 ncored20_1000 ncored21_1002 ncored30_1004
+  ncored31_1006 vddc_19 vddce_19 vddpe_19 vnwc_20 vpw_20 vssc vssc wl[1]
+  wl[0] rf64x128cchs4
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_368 cored01_370
+  cored10_372 cored11_374 cored20_376 cored21_378 cored30_380 cored31_382
+  nbl[0]_2 nbl[1]_2 nbl[2]_2 nbl[3]_2 ncored00_384 ncored01_386 ncored10_388
+  ncored11_390 ncored20_392 ncored21_394 ncored30_396 ncored31_398 vddc_2
+  vddce_2 vddpe_2 vnwc_3 vpw_3 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_20 bl[0]_20 bl[1]_20 bl[2]_20 bl[3]_20 cored00 cored01 cored10
+  cored11 cored20 cored21 cored30 cored31 nbl[0]_20 nbl[1]_20 nbl[2]_20
+  nbl[3]_20 ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30
+  ncored31 vddc_20 vddce_20 vddpe_20 vnwc_21 vpw_21 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_21 bl[0]_21 bl[1]_21 bl[2]_21 bl[3]_21 cored00_16 cored01_18
+  cored10_20 cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_21
+  nbl[1]_21 nbl[2]_21 nbl[3]_21 ncored00_32 ncored01_34 ncored10_36
+  ncored11_38 ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_21
+  vddce_21 vddpe_21 vnwc_22 vpw_22 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_22 bl[0]_22 bl[1]_22 bl[2]_22 bl[3]_22 cored00_48 cored01_50
+  cored10_52 cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_22
+  nbl[1]_22 nbl[2]_22 nbl[3]_22 ncored00_64 ncored01_66 ncored10_68
+  ncored11_70 ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_22
+  vddce_22 vddpe_22 vnwc_23 vpw_23 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_23 bl[0]_23 bl[1]_23 bl[2]_23 bl[3]_23 cored00_80 cored01_82
+  cored10_84 cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_23
+  nbl[1]_23 nbl[2]_23 nbl[3]_23 ncored00_96 ncored01_98 ncored10_100
+  ncored11_102 ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_23
+  vddce_23 vddpe_23 vnwc_24 vpw_24 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_24 bl[0]_24 bl[1]_24 bl[2]_24 bl[3]_24 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_24 nbl[1]_24 nbl[2]_24 nbl[3]_24 ncored00_128 ncored01_130
+  ncored10_132 ncored11_134 ncored20_136 ncored21_138 ncored30_140
+  ncored31_142 vddc_24 vddce_24 vddpe_24 vnwc_25 vpw_25 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_25 bl[0]_25 bl[1]_25 bl[2]_25 bl[3]_25 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_25 nbl[1]_25 nbl[2]_25 nbl[3]_25 ncored00_160 ncored01_162
+  ncored10_164 ncored11_166 ncored20_168 ncored21_170 ncored30_172
+  ncored31_174 vddc_25 vddce_25 vddpe_25 vnwc_26 vpw_26 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_26 bl[0]_26 bl[1]_26 bl[2]_26 bl[3]_26 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_26 nbl[1]_26 nbl[2]_26 nbl[3]_26 ncored00_192 ncored01_194
+  ncored10_196 ncored11_198 ncored20_200 ncored21_202 ncored30_204
+  ncored31_206 vddc_26 vddce_26 vddpe_26 vnwc_27 vpw_27 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_27 bl[0]_27 bl[1]_27 bl[2]_27 bl[3]_27 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_27 nbl[1]_27 nbl[2]_27 nbl[3]_27 ncored00_224 ncored01_226
+  ncored10_228 ncored11_230 ncored20_232 ncored21_234 ncored30_236
+  ncored31_238 vddc_27 vddce_27 vddpe_27 vnwc_28 vpw_28 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_28 bl[0]_28 bl[1]_28 bl[2]_28 bl[3]_28 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_28 nbl[1]_28 nbl[2]_28 nbl[3]_28 ncored00_256 ncored01_258
+  ncored10_260 ncored11_262 ncored20_264 ncored21_266 ncored30_268
+  ncored31_270 vddc_28 vddce_28 vddpe_28 vnwc_29 vpw_29 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_29 bl[0]_29 bl[1]_29 bl[2]_29 bl[3]_29 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_29 nbl[1]_29 nbl[2]_29 nbl[3]_29 ncored00_288 ncored01_290
+  ncored10_292 ncored11_294 ncored20_296 ncored21_298 ncored30_300
+  ncored31_302 vddc_29 vddce_29 vddpe_29 vnwc_30 vpw_30 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_400 cored01_402
+  cored10_404 cored11_406 cored20_408 cored21_410 cored30_412 cored31_414
+  nbl[0]_3 nbl[1]_3 nbl[2]_3 nbl[3]_3 ncored00_416 ncored01_418 ncored10_420
+  ncored11_422 ncored20_424 ncored21_426 ncored30_428 ncored31_430 vddc_3
+  vddce_3 vddpe_3 vnwc_4 vpw_4 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_30 bl[0]_30 bl[1]_30 bl[2]_30 bl[3]_30 cored00_720 cored01_722
+  cored10_724 cored11_726 cored20_728 cored21_730 cored30_732 cored31_734
+  nbl[0]_30 nbl[1]_30 nbl[2]_30 nbl[3]_30 ncored00_736 ncored01_738
+  ncored10_740 ncored11_742 ncored20_744 ncored21_746 ncored30_748
+  ncored31_750 vddc_30 vddce_30 vddpe_30 vnwc_31 vpw_31 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_31 bl[0]_31 bl[1]_31 bl[2]_31 bl[3]_31 cored00_784 cored01_786
+  cored10_788 cored11_790 cored20_792 cored21_794 cored30_796 cored31_798
+  nbl[0]_31 nbl[1]_31 nbl[2]_31 nbl[3]_31 ncored00_800 ncored01_802
+  ncored10_804 ncored11_806 ncored20_808 ncored21_810 ncored30_812
+  ncored31_814 vddc_31 vddce_31 vddpe_31 vnwc_32 vpw_32 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_432 cored01_434
+  cored10_436 cored11_438 cored20_440 cored21_442 cored30_444 cored31_446
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_448 ncored01_450 ncored10_452
+  ncored11_454 ncored20_456 ncored21_458 ncored30_460 ncored31_462 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_464 cored01_466
+  cored10_468 cored11_470 cored20_472 cored21_474 cored30_476 cored31_478
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_480 ncored01_482 ncored10_484
+  ncored11_486 ncored20_488 ncored21_490 ncored30_492 ncored31_494 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_496 cored01_498
+  cored10_500 cored11_502 cored20_504 cored21_506 cored30_508 cored31_510
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_512 ncored01_514 ncored10_516
+  ncored11_518 ncored20_520 ncored21_522 ncored30_524 ncored31_526 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_528 cored01_530
+  cored10_532 cored11_534 cored20_536 cored21_538 cored30_540 cored31_542
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_544 ncored01_546 ncored10_548
+  ncored11_550 ncored20_552 ncored21_554 ncored30_556 ncored31_558 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_560 cored01_562
+  cored10_564 cored11_566 cored20_568 cored21_570 cored30_572 cored31_574
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_576 ncored01_578 ncored10_580
+  ncored11_582 ncored20_584 ncored21_586 ncored30_588 ncored31_590 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_592 cored01_594
+  cored10_596 cored11_598 cored20_600 cored21_602 cored30_604 cored31_606
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_608 ncored01_610 ncored10_612
+  ncored11_614 ncored20_616 ncored21_618 ncored30_620 ncored31_622 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_edger dbl dwl vddc_32 vnwc_33 vnwp_1 vpw_33 vssc wl[0] wl[1]
+  rf64x128cchs4wd_edgbl
.ends rf64x128mem_l_test12row
****
.subckt rf64x128mem_l_test13row vddc_32 vpw_33 vnwc_33 dbl dwl vddc_31 vnwc_32
+  bl[2]_31 nbl[2]_31 nbl[3]_31 bl[3]_31 bl[1]_30 vddpe_30 bl[2]_30 nbl[2]_30
+  nbl[3]_30 bl[1]_29 vddpe_29 bl[2]_29 nbl[2]_29 bl[1]_28 vddpe_28 bl[2]_28
+  nbl[2]_28 bl[1]_27 vddpe_27 bl[2]_27 nbl[2]_27 bl[0]_26 bl[1]_26 vddpe_26
+  nbl[2]_26 nbl[3]_26 bl[0]_25 bl[1]_25 vddpe_25 vddce_25 vnwc_26 vssc
+  nbl[2]_25 nbl[3]_25 bl[0]_24 nbl[0]_24 nbl[1]_24 bl[1]_24 vddpe_24 vddce_24
+  vnwc_25 vpw_25 bl[2]_24 nbl[2]_24 nbl[3]_24 bl[0]_23 nbl[0]_23 nbl[1]_23
+  bl[1]_23 vddpe_23 vddce_23 vnwc_24 vpw_24 bl[2]_23 nbl[2]_23 bl[0]_22
+  nbl[0]_22 nbl[1]_22 bl[1]_22 vddpe_22 vddce_22 vnwc_23 vpw_23 bl[2]_22
+  nbl[2]_22 bl[0]_21 nbl[0]_21 nbl[1]_21 bl[1]_21 vddpe_21 vddce_21 vddc_21
+  vnwc_22 vpw_22 bl[2]_21 nbl[2]_21 bl[0]_20 nbl[0]_20 nbl[1]_20 bl[1]_20
+  vddpe_20 vddce_20 vddc_20 vnwc_21 vpw_21 nbl[2]_20 bl[0]_19 nbl[0]_19
+  nbl[1]_19 bl[1]_19 vddpe_19 vddce_19 vddc_19 vnwc_20 vpw_20 bl[0]_18
+  nbl[0]_18 nbl[1]_18 bl[1]_18 vddpe_18 vddce_18 vnwc_19 vpw_19 bl[2]_18
+  nbl[2]_18 bl[0]_17 nbl[0]_17 nbl[1]_17 bl[1]_17 vddpe_17 vddce_17 vnwc_18
+  vpw_18 bl[2]_17 nbl[2]_17 bl[0]_16 nbl[0]_16 nbl[1]_16 bl[1]_16 vddpe_16
+  vddce_16 vddc_16 vnwc_17 vpw_17 bl[2]_16 nbl[2]_16 bl[0]_15 nbl[0]_15
+  nbl[1]_15 bl[1]_15 vddpe_15 vddce_15 vddc_15 vnwc_16 vpw_16 nbl[2]_15
+  bl[0]_14 nbl[0]_14 nbl[1]_14 bl[1]_14 vddpe_14 vddce_14 vddc_14 vnwc_15
+  vpw_15 nbl[2]_14 bl[0]_13 nbl[0]_13 nbl[1]_13 bl[1]_13 vddpe_13 vddce_13
+  vddc_13 vnwc_14 vpw_14 bl[0]_12 nbl[0]_12 nbl[1]_12 bl[1]_12 vddpe_12
+  vddce_12 vddc_12 vnwc_13 vpw_13 bl[0]_11 nbl[0]_11 nbl[1]_11 bl[1]_11
+  vddpe_11 vddce_11 vddc_11 vnwc_12 vpw_12 bl[2]_11 nbl[2]_11 bl[0]_10
+  nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vddc_10 vnwc_11 vpw_11
+  nbl[2]_10 bl[0]_9 nbl[0]_9 nbl[1]_9 bl[1]_9 vddpe_9 vddce_9 vddc_9 vnwc_10
+  vpw_10 nbl[2]_9 bl[0]_8 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 vddce_8 vddc_8
+  vnwc_9 vpw_9 bl[0]_7 nbl[0]_7 nbl[1]_7 bl[1]_7 vddpe_7 vddce_7 vddc_7
+  vnwc_8 vpw_8 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddpe_6 vddce_6 vddc_6
+  vnwc_7 vpw_7 bl[3]_6 bl[0]_5 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe_5 vddce_5
+  vddc_5 vnwc_6 vpw_6 nbl[2]_5 bl[0]_4 nbl[0]_4 nbl[1]_4 bl[1]_4 vddpe_4
+  vddce_4 vddc_4 vnwc_5 vpw_5 nbl[2]_4 bl[0]_3 nbl[0]_3 nbl[1]_3 bl[1]_3
+  vddpe_3 vddce_3 vddc_3 vnwc_4 vpw_4 bl[0]_2 nbl[0]_2 nbl[1]_2 bl[1]_2
+  vddpe_2 vddce_2 vddc_2 vnwc_3 vpw_3 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1
+  vddpe_1 vddce_1 vddc_1 vnwc_2 vpw_2 bl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0
+  bl[1]_0 vddpe_0 vddce_0 vddc_0 vnwc_1 vpw_1 bl[3]_0 vnwp_0 vnwc_0 vpw_0
+  vnwp_1 bl[0]_31 nbl[0]_31 nbl[1]_31 bl[1]_31 vddpe_31 vddce_31 vpw_32
+  bl[0]_30 nbl[0]_30 nbl[1]_30 vddce_30 vddc_30 vnwc_31 vpw_31 bl[3]_30
+  bl[0]_29 nbl[0]_29 nbl[1]_29 vddce_29 vddc_29 vnwc_30 vpw_30 nbl[3]_29
+  bl[3]_29 bl[0]_28 nbl[0]_28 nbl[1]_28 vddce_28 vddc_28 vnwc_29 vpw_29
+  nbl[3]_28 bl[3]_28 bl[0]_27 nbl[0]_27 nbl[1]_27 vddce_27 vddc_27 vnwc_28
+  vpw_28 nbl[3]_27 bl[3]_27 nbl[0]_26 nbl[1]_26 vddce_26 vddc_26 vnwc_27
+  vpw_27 bl[2]_26 bl[3]_26 nbl[0]_25 nbl[1]_25 vddc_25 vpw_26 bl[2]_25
+  bl[3]_25 vddc_24 bl[3]_24 vddc_23 nbl[3]_23 bl[3]_23 vddc_22 nbl[3]_22
+  bl[3]_22 nbl[3]_21 bl[3]_21 bl[2]_20 nbl[3]_20 bl[3]_20 bl[2]_19 nbl[2]_19
+  nbl[3]_19 bl[3]_19 vddc_18 nbl[3]_18 bl[3]_18 vddc_17 nbl[3]_17 bl[3]_17
+  nbl[3]_16 bl[3]_16 bl[2]_15 nbl[3]_15 bl[3]_15 bl[2]_14 nbl[3]_14 bl[3]_14
+  bl[2]_13 nbl[2]_13 nbl[3]_13 bl[3]_13 bl[2]_12 nbl[2]_12 nbl[3]_12 bl[3]_12
+  nbl[3]_11 bl[3]_11 bl[2]_10 nbl[3]_10 bl[3]_10 bl[2]_9 nbl[3]_9 bl[3]_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[2]_6
+  nbl[2]_6 nbl[3]_6 bl[2]_5 nbl[3]_5 bl[3]_5 bl[2]_4 nbl[3]_4 bl[3]_4 bl[2]_3
+  nbl[2]_3 nbl[3]_3 bl[3]_3 bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[2]_1
+  nbl[2]_1 nbl[3]_1 bl[2]_0 nbl[2]_0 nbl[3]_0 wl[1] wl[0]
** rf64x128mem_l_test13row: 1548 flat devices **
xmem_l_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0 ncored00_320 ncored01_322 ncored10_324
+  ncored11_326 ncored20_328 ncored21_330 ncored30_332 ncored31_334 vddc_0
+  vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_1 nbl[1]_1 nbl[2]_1 nbl[3]_1 ncored00_352 ncored01_354 ncored10_356
+  ncored11_358 ncored20_360 ncored21_362 ncored30_364 ncored31_366 vddc_1
+  vddce_1 vddpe_1 vnwc_2 vpw_2 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_624 cored01_626
+  cored10_628 cored11_630 cored20_632 cored21_634 cored30_636 cored31_638
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_640 ncored01_642
+  ncored10_644 ncored11_646 ncored20_648 ncored21_650 ncored30_652
+  ncored31_654 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_656 cored01_658
+  cored10_660 cored11_662 cored20_664 cored21_666 cored30_668 cored31_670
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_672 ncored01_674
+  ncored10_676 ncored11_678 ncored20_680 ncored21_682 ncored30_684
+  ncored31_686 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_12 bl[0]_12 bl[1]_12 bl[2]_12 bl[3]_12 cored00_688 cored01_690
+  cored10_692 cored11_694 cored20_696 cored21_698 cored30_700 cored31_702
+  nbl[0]_12 nbl[1]_12 nbl[2]_12 nbl[3]_12 ncored00_704 ncored01_706
+  ncored10_708 ncored11_710 ncored20_712 ncored21_714 ncored30_716
+  ncored31_718 vddc_12 vddce_12 vddpe_12 vnwc_13 vpw_13 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_13 bl[0]_13 bl[1]_13 bl[2]_13 bl[3]_13 cored00_752 cored01_754
+  cored10_756 cored11_758 cored20_760 cored21_762 cored30_764 cored31_766
+  nbl[0]_13 nbl[1]_13 nbl[2]_13 nbl[3]_13 ncored00_768 ncored01_770
+  ncored10_772 ncored11_774 ncored20_776 ncored21_778 ncored30_780
+  ncored31_782 vddc_13 vddce_13 vddpe_13 vnwc_14 vpw_14 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_14 bl[0]_14 bl[1]_14 bl[2]_14 bl[3]_14 cored00_816 cored01_818
+  cored10_820 cored11_822 cored20_824 cored21_826 cored30_828 cored31_830
+  nbl[0]_14 nbl[1]_14 nbl[2]_14 nbl[3]_14 ncored00_832 ncored01_834
+  ncored10_836 ncored11_838 ncored20_840 ncored21_842 ncored30_844
+  ncored31_846 vddc_14 vddce_14 vddpe_14 vnwc_15 vpw_15 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_15 bl[0]_15 bl[1]_15 bl[2]_15 bl[3]_15 cored00_848 cored01_850
+  cored10_852 cored11_854 cored20_856 cored21_858 cored30_860 cored31_862
+  nbl[0]_15 nbl[1]_15 nbl[2]_15 nbl[3]_15 ncored00_864 ncored01_866
+  ncored10_868 ncored11_870 ncored20_872 ncored21_874 ncored30_876
+  ncored31_878 vddc_15 vddce_15 vddpe_15 vnwc_16 vpw_16 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_16 bl[0]_16 bl[1]_16 bl[2]_16 bl[3]_16 cored00_880 cored01_882
+  cored10_884 cored11_886 cored20_888 cored21_890 cored30_892 cored31_894
+  nbl[0]_16 nbl[1]_16 nbl[2]_16 nbl[3]_16 ncored00_896 ncored01_898
+  ncored10_900 ncored11_902 ncored20_904 ncored21_906 ncored30_908
+  ncored31_910 vddc_16 vddce_16 vddpe_16 vnwc_17 vpw_17 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_17 bl[0]_17 bl[1]_17 bl[2]_17 bl[3]_17 cored00_912 cored01_914
+  cored10_916 cored11_918 cored20_920 cored21_922 cored30_924 cored31_926
+  nbl[0]_17 nbl[1]_17 nbl[2]_17 nbl[3]_17 ncored00_928 ncored01_930
+  ncored10_932 ncored11_934 ncored20_936 ncored21_938 ncored30_940
+  ncored31_942 vddc_17 vddce_17 vddpe_17 vnwc_18 vpw_18 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_18 bl[0]_18 bl[1]_18 bl[2]_18 bl[3]_18 cored00_944 cored01_946
+  cored10_948 cored11_950 cored20_952 cored21_954 cored30_956 cored31_958
+  nbl[0]_18 nbl[1]_18 nbl[2]_18 nbl[3]_18 ncored00_960 ncored01_962
+  ncored10_964 ncored11_966 ncored20_968 ncored21_970 ncored30_972
+  ncored31_974 vddc_18 vddce_18 vddpe_18 vnwc_19 vpw_19 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_19 bl[0]_19 bl[1]_19 bl[2]_19 bl[3]_19 cored00_976 cored01_978
+  cored10_980 cored11_982 cored20_984 cored21_986 cored30_988 cored31_990
+  nbl[0]_19 nbl[1]_19 nbl[2]_19 nbl[3]_19 ncored00_992 ncored01_994
+  ncored10_996 ncored11_998 ncored20_1000 ncored21_1002 ncored30_1004
+  ncored31_1006 vddc_19 vddce_19 vddpe_19 vnwc_20 vpw_20 vssc vssc wl[0]
+  wl[1] rf64x128cchs4
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_368 cored01_370
+  cored10_372 cored11_374 cored20_376 cored21_378 cored30_380 cored31_382
+  nbl[0]_2 nbl[1]_2 nbl[2]_2 nbl[3]_2 ncored00_384 ncored01_386 ncored10_388
+  ncored11_390 ncored20_392 ncored21_394 ncored30_396 ncored31_398 vddc_2
+  vddce_2 vddpe_2 vnwc_3 vpw_3 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_20 bl[0]_20 bl[1]_20 bl[2]_20 bl[3]_20 cored00 cored01 cored10
+  cored11 cored20 cored21 cored30 cored31 nbl[0]_20 nbl[1]_20 nbl[2]_20
+  nbl[3]_20 ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30
+  ncored31 vddc_20 vddce_20 vddpe_20 vnwc_21 vpw_21 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_21 bl[0]_21 bl[1]_21 bl[2]_21 bl[3]_21 cored00_16 cored01_18
+  cored10_20 cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_21
+  nbl[1]_21 nbl[2]_21 nbl[3]_21 ncored00_32 ncored01_34 ncored10_36
+  ncored11_38 ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_21
+  vddce_21 vddpe_21 vnwc_22 vpw_22 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_22 bl[0]_22 bl[1]_22 bl[2]_22 bl[3]_22 cored00_48 cored01_50
+  cored10_52 cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_22
+  nbl[1]_22 nbl[2]_22 nbl[3]_22 ncored00_64 ncored01_66 ncored10_68
+  ncored11_70 ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_22
+  vddce_22 vddpe_22 vnwc_23 vpw_23 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_23 bl[0]_23 bl[1]_23 bl[2]_23 bl[3]_23 cored00_80 cored01_82
+  cored10_84 cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_23
+  nbl[1]_23 nbl[2]_23 nbl[3]_23 ncored00_96 ncored01_98 ncored10_100
+  ncored11_102 ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_23
+  vddce_23 vddpe_23 vnwc_24 vpw_24 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_24 bl[0]_24 bl[1]_24 bl[2]_24 bl[3]_24 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_24 nbl[1]_24 nbl[2]_24 nbl[3]_24 ncored00_128 ncored01_130
+  ncored10_132 ncored11_134 ncored20_136 ncored21_138 ncored30_140
+  ncored31_142 vddc_24 vddce_24 vddpe_24 vnwc_25 vpw_25 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_25 bl[0]_25 bl[1]_25 bl[2]_25 bl[3]_25 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_25 nbl[1]_25 nbl[2]_25 nbl[3]_25 ncored00_160 ncored01_162
+  ncored10_164 ncored11_166 ncored20_168 ncored21_170 ncored30_172
+  ncored31_174 vddc_25 vddce_25 vddpe_25 vnwc_26 vpw_26 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_26 bl[0]_26 bl[1]_26 bl[2]_26 bl[3]_26 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_26 nbl[1]_26 nbl[2]_26 nbl[3]_26 ncored00_192 ncored01_194
+  ncored10_196 ncored11_198 ncored20_200 ncored21_202 ncored30_204
+  ncored31_206 vddc_26 vddce_26 vddpe_26 vnwc_27 vpw_27 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_27 bl[0]_27 bl[1]_27 bl[2]_27 bl[3]_27 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_27 nbl[1]_27 nbl[2]_27 nbl[3]_27 ncored00_224 ncored01_226
+  ncored10_228 ncored11_230 ncored20_232 ncored21_234 ncored30_236
+  ncored31_238 vddc_27 vddce_27 vddpe_27 vnwc_28 vpw_28 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_28 bl[0]_28 bl[1]_28 bl[2]_28 bl[3]_28 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_28 nbl[1]_28 nbl[2]_28 nbl[3]_28 ncored00_256 ncored01_258
+  ncored10_260 ncored11_262 ncored20_264 ncored21_266 ncored30_268
+  ncored31_270 vddc_28 vddce_28 vddpe_28 vnwc_29 vpw_29 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_29 bl[0]_29 bl[1]_29 bl[2]_29 bl[3]_29 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_29 nbl[1]_29 nbl[2]_29 nbl[3]_29 ncored00_288 ncored01_290
+  ncored10_292 ncored11_294 ncored20_296 ncored21_298 ncored30_300
+  ncored31_302 vddc_29 vddce_29 vddpe_29 vnwc_30 vpw_30 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_400 cored01_402
+  cored10_404 cored11_406 cored20_408 cored21_410 cored30_412 cored31_414
+  nbl[0]_3 nbl[1]_3 nbl[2]_3 nbl[3]_3 ncored00_416 ncored01_418 ncored10_420
+  ncored11_422 ncored20_424 ncored21_426 ncored30_428 ncored31_430 vddc_3
+  vddce_3 vddpe_3 vnwc_4 vpw_4 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_30 bl[0]_30 bl[1]_30 bl[2]_30 bl[3]_30 cored00_720 cored01_722
+  cored10_724 cored11_726 cored20_728 cored21_730 cored30_732 cored31_734
+  nbl[0]_30 nbl[1]_30 nbl[2]_30 nbl[3]_30 ncored00_736 ncored01_738
+  ncored10_740 ncored11_742 ncored20_744 ncored21_746 ncored30_748
+  ncored31_750 vddc_30 vddce_30 vddpe_30 vnwc_31 vpw_31 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_31 bl[0]_31 bl[1]_31 bl[2]_31 bl[3]_31 cored00_784 cored01_786
+  cored10_788 cored11_790 cored20_792 cored21_794 cored30_796 cored31_798
+  nbl[0]_31 nbl[1]_31 nbl[2]_31 nbl[3]_31 ncored00_800 ncored01_802
+  ncored10_804 ncored11_806 ncored20_808 ncored21_810 ncored30_812
+  ncored31_814 vddc_31 vddce_31 vddpe_31 vnwc_32 vpw_32 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_432 cored01_434
+  cored10_436 cored11_438 cored20_440 cored21_442 cored30_444 cored31_446
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_448 ncored01_450 ncored10_452
+  ncored11_454 ncored20_456 ncored21_458 ncored30_460 ncored31_462 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_464 cored01_466
+  cored10_468 cored11_470 cored20_472 cored21_474 cored30_476 cored31_478
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_480 ncored01_482 ncored10_484
+  ncored11_486 ncored20_488 ncored21_490 ncored30_492 ncored31_494 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_496 cored01_498
+  cored10_500 cored11_502 cored20_504 cored21_506 cored30_508 cored31_510
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_512 ncored01_514 ncored10_516
+  ncored11_518 ncored20_520 ncored21_522 ncored30_524 ncored31_526 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_528 cored01_530
+  cored10_532 cored11_534 cored20_536 cored21_538 cored30_540 cored31_542
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_544 ncored01_546 ncored10_548
+  ncored11_550 ncored20_552 ncored21_554 ncored30_556 ncored31_558 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_560 cored01_562
+  cored10_564 cored11_566 cored20_568 cored21_570 cored30_572 cored31_574
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_576 ncored01_578 ncored10_580
+  ncored11_582 ncored20_584 ncored21_586 ncored30_588 ncored31_590 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_592 cored01_594
+  cored10_596 cored11_598 cored20_600 cored21_602 cored30_604 cored31_606
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_608 ncored01_610 ncored10_612
+  ncored11_614 ncored20_616 ncored21_618 ncored30_620 ncored31_622 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_edger dbl dwl vddc_32 vnwc_33 vnwp_1 vpw_33 vssc wl[0] wl[1]
+  rf64x128cchs4wd_edgbl
.ends rf64x128mem_l_test13row
****
.subckt rf64x128mem_l_test14row vddc_32 vpw_33 vnwc_33 vnwc_32 bl[2]_31
+  nbl[2]_31 nbl[3]_31 bl[3]_31 bl[1]_30 vddpe_30 bl[2]_30 nbl[2]_30 nbl[3]_30
+  bl[1]_29 vddpe_29 bl[2]_29 nbl[2]_29 bl[1]_28 vddpe_28 bl[2]_28 nbl[2]_28
+  bl[1]_27 vddpe_27 bl[2]_27 nbl[2]_27 bl[0]_26 bl[1]_26 vddpe_26 nbl[2]_26
+  nbl[3]_26 bl[0]_25 bl[1]_25 vddpe_25 vddce_25 vnwc_26 vssc nbl[2]_25
+  nbl[3]_25 bl[0]_24 nbl[0]_24 nbl[1]_24 bl[1]_24 vddpe_24 vddce_24 vnwc_25
+  vpw_25 bl[2]_24 nbl[2]_24 nbl[3]_24 bl[0]_23 nbl[0]_23 nbl[1]_23 bl[1]_23
+  vddpe_23 vddce_23 vnwc_24 vpw_24 bl[2]_23 nbl[2]_23 bl[0]_22 nbl[0]_22
+  nbl[1]_22 bl[1]_22 vddpe_22 vddce_22 vnwc_23 vpw_23 bl[2]_22 nbl[2]_22
+  bl[0]_21 nbl[0]_21 nbl[1]_21 bl[1]_21 vddpe_21 vddce_21 vddc_21 vnwc_22
+  vpw_22 bl[2]_21 nbl[2]_21 bl[0]_20 nbl[0]_20 nbl[1]_20 bl[1]_20 vddpe_20
+  vddce_20 vddc_20 vnwc_21 vpw_21 nbl[2]_20 bl[0]_19 nbl[0]_19 nbl[1]_19
+  bl[1]_19 vddpe_19 vddce_19 vddc_19 vnwc_20 vpw_20 bl[0]_18 nbl[0]_18
+  nbl[1]_18 bl[1]_18 vddpe_18 vddce_18 vnwc_19 vpw_19 bl[2]_18 nbl[2]_18
+  bl[0]_17 nbl[0]_17 nbl[1]_17 bl[1]_17 vddpe_17 vddce_17 vnwc_18 vpw_18
+  bl[2]_17 nbl[2]_17 bl[0]_16 nbl[0]_16 nbl[1]_16 bl[1]_16 vddpe_16 vddce_16
+  vddc_16 vnwc_17 vpw_17 bl[2]_16 nbl[2]_16 bl[0]_15 nbl[0]_15 nbl[1]_15
+  bl[1]_15 vddpe_15 vddce_15 vddc_15 vnwc_16 vpw_16 nbl[2]_15 bl[0]_14
+  nbl[0]_14 nbl[1]_14 bl[1]_14 vddpe_14 vddce_14 vddc_14 vnwc_15 vpw_15
+  nbl[2]_14 bl[0]_13 nbl[0]_13 nbl[1]_13 bl[1]_13 vddpe_13 vddce_13 vddc_13
+  vnwc_14 vpw_14 bl[0]_12 nbl[0]_12 nbl[1]_12 bl[1]_12 vddpe_12 vddce_12
+  vddc_12 vnwc_13 vpw_13 bl[0]_11 nbl[0]_11 nbl[1]_11 bl[1]_11 vddpe_11
+  vddce_11 vddc_11 vnwc_12 vpw_12 bl[2]_11 nbl[2]_11 bl[0]_10 nbl[0]_10
+  nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vddc_10 vnwc_11 vpw_11 nbl[2]_10
+  bl[0]_9 nbl[0]_9 nbl[1]_9 bl[1]_9 vddpe_9 vddce_9 vddc_9 vnwc_10 vpw_10
+  nbl[2]_9 bl[0]_8 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 vddce_8 vddc_8 vnwc_9
+  vpw_9 bl[0]_7 nbl[0]_7 nbl[1]_7 bl[1]_7 vddpe_7 vddce_7 vddc_7 vnwc_8 vpw_8
+  bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddpe_6 vddce_6 vddc_6 vnwc_7 vpw_7
+  bl[3]_6 bl[0]_5 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe_5 vddce_5 vddc_5 vnwc_6
+  vpw_6 nbl[2]_5 bl[0]_4 nbl[0]_4 nbl[1]_4 bl[1]_4 vddpe_4 vddce_4 vddc_4
+  vnwc_5 vpw_5 nbl[2]_4 bl[0]_3 nbl[0]_3 nbl[1]_3 bl[1]_3 vddpe_3 vddce_3
+  vddc_3 vnwc_4 vpw_4 bl[0]_2 nbl[0]_2 nbl[1]_2 bl[1]_2 vddpe_2 vddce_2
+  vddc_2 vnwc_3 vpw_3 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddpe_1 vddce_1
+  vddc_1 vnwc_2 vpw_2 bl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe_0
+  vddce_0 vddc_0 vnwc_1 vpw_1 bl[3]_0 vnwc_0 vpw_0 vnwp_1 dbl dwl bl[0]_31
+  nbl[0]_31 nbl[1]_31 bl[1]_31 vddpe_31 vddce_31 vddc_31 vpw_32 bl[0]_30
+  nbl[0]_30 nbl[1]_30 vddce_30 vddc_30 vnwc_31 vpw_31 bl[3]_30 bl[0]_29
+  nbl[0]_29 nbl[1]_29 vddce_29 vddc_29 vnwc_30 vpw_30 nbl[3]_29 bl[3]_29
+  bl[0]_28 nbl[0]_28 nbl[1]_28 vddce_28 vddc_28 vnwc_29 vpw_29 nbl[3]_28
+  bl[3]_28 bl[0]_27 nbl[0]_27 nbl[1]_27 vddce_27 vddc_27 vnwc_28 vpw_28
+  nbl[3]_27 bl[3]_27 nbl[0]_26 nbl[1]_26 vddce_26 vddc_26 vnwc_27 vpw_27
+  bl[2]_26 bl[3]_26 nbl[0]_25 nbl[1]_25 vddc_25 vpw_26 bl[2]_25 bl[3]_25
+  vddc_24 bl[3]_24 vddc_23 nbl[3]_23 bl[3]_23 vddc_22 nbl[3]_22 bl[3]_22
+  nbl[3]_21 bl[3]_21 bl[2]_20 nbl[3]_20 bl[3]_20 bl[2]_19 nbl[2]_19 nbl[3]_19
+  bl[3]_19 vddc_18 nbl[3]_18 bl[3]_18 vddc_17 nbl[3]_17 bl[3]_17 nbl[3]_16
+  bl[3]_16 bl[2]_15 nbl[3]_15 bl[3]_15 bl[2]_14 nbl[3]_14 bl[3]_14 bl[2]_13
+  nbl[2]_13 nbl[3]_13 bl[3]_13 bl[2]_12 nbl[2]_12 nbl[3]_12 bl[3]_12
+  nbl[3]_11 bl[3]_11 bl[2]_10 nbl[3]_10 bl[3]_10 bl[2]_9 nbl[3]_9 bl[3]_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[2]_6
+  nbl[2]_6 nbl[3]_6 bl[2]_5 nbl[3]_5 bl[3]_5 bl[2]_4 nbl[3]_4 bl[3]_4 bl[2]_3
+  nbl[2]_3 nbl[3]_3 bl[3]_3 bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[2]_1
+  nbl[2]_1 nbl[3]_1 bl[2]_0 nbl[2]_0 nbl[3]_0 vnwp_0 wl[0] wl[1]
** rf64x128mem_l_test14row: 1548 flat devices **
xmem_l_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0 ncored00_320 ncored01_322 ncored10_324
+  ncored11_326 ncored20_328 ncored21_330 ncored30_332 ncored31_334 vddc_0
+  vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_1 nbl[1]_1 nbl[2]_1 nbl[3]_1 ncored00_352 ncored01_354 ncored10_356
+  ncored11_358 ncored20_360 ncored21_362 ncored30_364 ncored31_366 vddc_1
+  vddce_1 vddpe_1 vnwc_2 vpw_2 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_624 cored01_626
+  cored10_628 cored11_630 cored20_632 cored21_634 cored30_636 cored31_638
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_640 ncored01_642
+  ncored10_644 ncored11_646 ncored20_648 ncored21_650 ncored30_652
+  ncored31_654 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_656 cored01_658
+  cored10_660 cored11_662 cored20_664 cored21_666 cored30_668 cored31_670
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_672 ncored01_674
+  ncored10_676 ncored11_678 ncored20_680 ncored21_682 ncored30_684
+  ncored31_686 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_12 bl[0]_12 bl[1]_12 bl[2]_12 bl[3]_12 cored00_688 cored01_690
+  cored10_692 cored11_694 cored20_696 cored21_698 cored30_700 cored31_702
+  nbl[0]_12 nbl[1]_12 nbl[2]_12 nbl[3]_12 ncored00_704 ncored01_706
+  ncored10_708 ncored11_710 ncored20_712 ncored21_714 ncored30_716
+  ncored31_718 vddc_12 vddce_12 vddpe_12 vnwc_13 vpw_13 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_13 bl[0]_13 bl[1]_13 bl[2]_13 bl[3]_13 cored00_752 cored01_754
+  cored10_756 cored11_758 cored20_760 cored21_762 cored30_764 cored31_766
+  nbl[0]_13 nbl[1]_13 nbl[2]_13 nbl[3]_13 ncored00_768 ncored01_770
+  ncored10_772 ncored11_774 ncored20_776 ncored21_778 ncored30_780
+  ncored31_782 vddc_13 vddce_13 vddpe_13 vnwc_14 vpw_14 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_14 bl[0]_14 bl[1]_14 bl[2]_14 bl[3]_14 cored00_816 cored01_818
+  cored10_820 cored11_822 cored20_824 cored21_826 cored30_828 cored31_830
+  nbl[0]_14 nbl[1]_14 nbl[2]_14 nbl[3]_14 ncored00_832 ncored01_834
+  ncored10_836 ncored11_838 ncored20_840 ncored21_842 ncored30_844
+  ncored31_846 vddc_14 vddce_14 vddpe_14 vnwc_15 vpw_15 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_15 bl[0]_15 bl[1]_15 bl[2]_15 bl[3]_15 cored00_848 cored01_850
+  cored10_852 cored11_854 cored20_856 cored21_858 cored30_860 cored31_862
+  nbl[0]_15 nbl[1]_15 nbl[2]_15 nbl[3]_15 ncored00_864 ncored01_866
+  ncored10_868 ncored11_870 ncored20_872 ncored21_874 ncored30_876
+  ncored31_878 vddc_15 vddce_15 vddpe_15 vnwc_16 vpw_16 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_16 bl[0]_16 bl[1]_16 bl[2]_16 bl[3]_16 cored00_880 cored01_882
+  cored10_884 cored11_886 cored20_888 cored21_890 cored30_892 cored31_894
+  nbl[0]_16 nbl[1]_16 nbl[2]_16 nbl[3]_16 ncored00_896 ncored01_898
+  ncored10_900 ncored11_902 ncored20_904 ncored21_906 ncored30_908
+  ncored31_910 vddc_16 vddce_16 vddpe_16 vnwc_17 vpw_17 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_17 bl[0]_17 bl[1]_17 bl[2]_17 bl[3]_17 cored00_912 cored01_914
+  cored10_916 cored11_918 cored20_920 cored21_922 cored30_924 cored31_926
+  nbl[0]_17 nbl[1]_17 nbl[2]_17 nbl[3]_17 ncored00_928 ncored01_930
+  ncored10_932 ncored11_934 ncored20_936 ncored21_938 ncored30_940
+  ncored31_942 vddc_17 vddce_17 vddpe_17 vnwc_18 vpw_18 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_18 bl[0]_18 bl[1]_18 bl[2]_18 bl[3]_18 cored00_944 cored01_946
+  cored10_948 cored11_950 cored20_952 cored21_954 cored30_956 cored31_958
+  nbl[0]_18 nbl[1]_18 nbl[2]_18 nbl[3]_18 ncored00_960 ncored01_962
+  ncored10_964 ncored11_966 ncored20_968 ncored21_970 ncored30_972
+  ncored31_974 vddc_18 vddce_18 vddpe_18 vnwc_19 vpw_19 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_19 bl[0]_19 bl[1]_19 bl[2]_19 bl[3]_19 cored00_976 cored01_978
+  cored10_980 cored11_982 cored20_984 cored21_986 cored30_988 cored31_990
+  nbl[0]_19 nbl[1]_19 nbl[2]_19 nbl[3]_19 ncored00_992 ncored01_994
+  ncored10_996 ncored11_998 ncored20_1000 ncored21_1002 ncored30_1004
+  ncored31_1006 vddc_19 vddce_19 vddpe_19 vnwc_20 vpw_20 vssc vssc wl[1]
+  wl[0] rf64x128cchs4
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_368 cored01_370
+  cored10_372 cored11_374 cored20_376 cored21_378 cored30_380 cored31_382
+  nbl[0]_2 nbl[1]_2 nbl[2]_2 nbl[3]_2 ncored00_384 ncored01_386 ncored10_388
+  ncored11_390 ncored20_392 ncored21_394 ncored30_396 ncored31_398 vddc_2
+  vddce_2 vddpe_2 vnwc_3 vpw_3 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_20 bl[0]_20 bl[1]_20 bl[2]_20 bl[3]_20 cored00 cored01 cored10
+  cored11 cored20 cored21 cored30 cored31 nbl[0]_20 nbl[1]_20 nbl[2]_20
+  nbl[3]_20 ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30
+  ncored31 vddc_20 vddce_20 vddpe_20 vnwc_21 vpw_21 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_21 bl[0]_21 bl[1]_21 bl[2]_21 bl[3]_21 cored00_16 cored01_18
+  cored10_20 cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_21
+  nbl[1]_21 nbl[2]_21 nbl[3]_21 ncored00_32 ncored01_34 ncored10_36
+  ncored11_38 ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_21
+  vddce_21 vddpe_21 vnwc_22 vpw_22 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_22 bl[0]_22 bl[1]_22 bl[2]_22 bl[3]_22 cored00_48 cored01_50
+  cored10_52 cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_22
+  nbl[1]_22 nbl[2]_22 nbl[3]_22 ncored00_64 ncored01_66 ncored10_68
+  ncored11_70 ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_22
+  vddce_22 vddpe_22 vnwc_23 vpw_23 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_23 bl[0]_23 bl[1]_23 bl[2]_23 bl[3]_23 cored00_80 cored01_82
+  cored10_84 cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_23
+  nbl[1]_23 nbl[2]_23 nbl[3]_23 ncored00_96 ncored01_98 ncored10_100
+  ncored11_102 ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_23
+  vddce_23 vddpe_23 vnwc_24 vpw_24 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_24 bl[0]_24 bl[1]_24 bl[2]_24 bl[3]_24 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_24 nbl[1]_24 nbl[2]_24 nbl[3]_24 ncored00_128 ncored01_130
+  ncored10_132 ncored11_134 ncored20_136 ncored21_138 ncored30_140
+  ncored31_142 vddc_24 vddce_24 vddpe_24 vnwc_25 vpw_25 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_25 bl[0]_25 bl[1]_25 bl[2]_25 bl[3]_25 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_25 nbl[1]_25 nbl[2]_25 nbl[3]_25 ncored00_160 ncored01_162
+  ncored10_164 ncored11_166 ncored20_168 ncored21_170 ncored30_172
+  ncored31_174 vddc_25 vddce_25 vddpe_25 vnwc_26 vpw_26 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_26 bl[0]_26 bl[1]_26 bl[2]_26 bl[3]_26 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_26 nbl[1]_26 nbl[2]_26 nbl[3]_26 ncored00_192 ncored01_194
+  ncored10_196 ncored11_198 ncored20_200 ncored21_202 ncored30_204
+  ncored31_206 vddc_26 vddce_26 vddpe_26 vnwc_27 vpw_27 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_27 bl[0]_27 bl[1]_27 bl[2]_27 bl[3]_27 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_27 nbl[1]_27 nbl[2]_27 nbl[3]_27 ncored00_224 ncored01_226
+  ncored10_228 ncored11_230 ncored20_232 ncored21_234 ncored30_236
+  ncored31_238 vddc_27 vddce_27 vddpe_27 vnwc_28 vpw_28 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_28 bl[0]_28 bl[1]_28 bl[2]_28 bl[3]_28 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_28 nbl[1]_28 nbl[2]_28 nbl[3]_28 ncored00_256 ncored01_258
+  ncored10_260 ncored11_262 ncored20_264 ncored21_266 ncored30_268
+  ncored31_270 vddc_28 vddce_28 vddpe_28 vnwc_29 vpw_29 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_29 bl[0]_29 bl[1]_29 bl[2]_29 bl[3]_29 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_29 nbl[1]_29 nbl[2]_29 nbl[3]_29 ncored00_288 ncored01_290
+  ncored10_292 ncored11_294 ncored20_296 ncored21_298 ncored30_300
+  ncored31_302 vddc_29 vddce_29 vddpe_29 vnwc_30 vpw_30 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_400 cored01_402
+  cored10_404 cored11_406 cored20_408 cored21_410 cored30_412 cored31_414
+  nbl[0]_3 nbl[1]_3 nbl[2]_3 nbl[3]_3 ncored00_416 ncored01_418 ncored10_420
+  ncored11_422 ncored20_424 ncored21_426 ncored30_428 ncored31_430 vddc_3
+  vddce_3 vddpe_3 vnwc_4 vpw_4 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_30 bl[0]_30 bl[1]_30 bl[2]_30 bl[3]_30 cored00_720 cored01_722
+  cored10_724 cored11_726 cored20_728 cored21_730 cored30_732 cored31_734
+  nbl[0]_30 nbl[1]_30 nbl[2]_30 nbl[3]_30 ncored00_736 ncored01_738
+  ncored10_740 ncored11_742 ncored20_744 ncored21_746 ncored30_748
+  ncored31_750 vddc_30 vddce_30 vddpe_30 vnwc_31 vpw_31 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_31 bl[0]_31 bl[1]_31 bl[2]_31 bl[3]_31 cored00_784 cored01_786
+  cored10_788 cored11_790 cored20_792 cored21_794 cored30_796 cored31_798
+  nbl[0]_31 nbl[1]_31 nbl[2]_31 nbl[3]_31 ncored00_800 ncored01_802
+  ncored10_804 ncored11_806 ncored20_808 ncored21_810 ncored30_812
+  ncored31_814 vddc_31 vddce_31 vddpe_31 vnwc_32 vpw_32 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_432 cored01_434
+  cored10_436 cored11_438 cored20_440 cored21_442 cored30_444 cored31_446
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_448 ncored01_450 ncored10_452
+  ncored11_454 ncored20_456 ncored21_458 ncored30_460 ncored31_462 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_464 cored01_466
+  cored10_468 cored11_470 cored20_472 cored21_474 cored30_476 cored31_478
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_480 ncored01_482 ncored10_484
+  ncored11_486 ncored20_488 ncored21_490 ncored30_492 ncored31_494 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_496 cored01_498
+  cored10_500 cored11_502 cored20_504 cored21_506 cored30_508 cored31_510
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_512 ncored01_514 ncored10_516
+  ncored11_518 ncored20_520 ncored21_522 ncored30_524 ncored31_526 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_528 cored01_530
+  cored10_532 cored11_534 cored20_536 cored21_538 cored30_540 cored31_542
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_544 ncored01_546 ncored10_548
+  ncored11_550 ncored20_552 ncored21_554 ncored30_556 ncored31_558 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_560 cored01_562
+  cored10_564 cored11_566 cored20_568 cored21_570 cored30_572 cored31_574
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_576 ncored01_578 ncored10_580
+  ncored11_582 ncored20_584 ncored21_586 ncored30_588 ncored31_590 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_592 cored01_594
+  cored10_596 cored11_598 cored20_600 cored21_602 cored30_604 cored31_606
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_608 ncored01_610 ncored10_612
+  ncored11_614 ncored20_616 ncored21_618 ncored30_620 ncored31_622 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_edger dbl dwl vddc_32 vnwc_33 vnwp_1 vpw_33 vssc wl[0] wl[1]
+  rf64x128cchs4wd_edgbl
.ends rf64x128mem_l_test14row
****
.subckt rf64x128mem_l_midt_row vddc_32 vnwc_33 dbl dwl vnwc_32 bl[2]_31
+  nbl[2]_31 nbl[3]_31 bl[3]_31 bl[1]_30 vddpe_30 bl[2]_30 nbl[2]_30 nbl[3]_30
+  bl[1]_29 vddpe_29 bl[2]_29 nbl[2]_29 bl[1]_28 vddpe_28 bl[2]_28 nbl[2]_28
+  bl[1]_27 vddpe_27 bl[2]_27 nbl[2]_27 bl[0]_26 bl[1]_26 vddpe_26 nbl[2]_26
+  nbl[3]_26 bl[0]_25 bl[1]_25 vddpe_25 vddce_25 vnwc_26 vssc nbl[2]_25
+  nbl[3]_25 bl[0]_24 nbl[0]_24 nbl[1]_24 bl[1]_24 vddpe_24 vddce_24 vnwc_25
+  vpw_25 bl[2]_24 nbl[2]_24 nbl[3]_24 bl[0]_23 nbl[0]_23 nbl[1]_23 bl[1]_23
+  vddpe_23 vddce_23 vnwc_24 vpw_24 bl[2]_23 nbl[2]_23 bl[0]_22 nbl[0]_22
+  nbl[1]_22 bl[1]_22 vddpe_22 vddce_22 vnwc_23 vpw_23 bl[2]_22 nbl[2]_22
+  bl[0]_21 nbl[0]_21 nbl[1]_21 bl[1]_21 vddpe_21 vddce_21 vddc_21 vnwc_22
+  vpw_22 bl[2]_21 nbl[2]_21 bl[0]_20 nbl[0]_20 nbl[1]_20 bl[1]_20 vddpe_20
+  vddce_20 vddc_20 vnwc_21 vpw_21 nbl[2]_20 bl[0]_19 nbl[0]_19 nbl[1]_19
+  bl[1]_19 vddpe_19 vddce_19 vddc_19 vnwc_20 vpw_20 bl[0]_18 nbl[0]_18
+  nbl[1]_18 bl[1]_18 vddpe_18 vddce_18 vnwc_19 vpw_19 bl[2]_18 nbl[2]_18
+  bl[0]_17 nbl[0]_17 nbl[1]_17 bl[1]_17 vddpe_17 vddce_17 vnwc_18 vpw_18
+  bl[2]_17 nbl[2]_17 bl[0]_16 nbl[0]_16 nbl[1]_16 bl[1]_16 vddpe_16 vddce_16
+  vddc_16 vnwc_17 vpw_17 bl[2]_16 nbl[2]_16 bl[0]_15 nbl[0]_15 nbl[1]_15
+  bl[1]_15 vddpe_15 vddce_15 vddc_15 vnwc_16 vpw_16 nbl[2]_15 bl[0]_14
+  nbl[0]_14 nbl[1]_14 bl[1]_14 vddpe_14 vddce_14 vddc_14 vnwc_15 vpw_15
+  nbl[2]_14 bl[0]_13 nbl[0]_13 nbl[1]_13 bl[1]_13 vddpe_13 vddce_13 vddc_13
+  vnwc_14 vpw_14 bl[0]_12 nbl[0]_12 nbl[1]_12 bl[1]_12 vddpe_12 vddce_12
+  vddc_12 vnwc_13 vpw_13 bl[0]_11 nbl[0]_11 nbl[1]_11 bl[1]_11 vddpe_11
+  vddce_11 vddc_11 vnwc_12 vpw_12 bl[2]_11 nbl[2]_11 bl[0]_10 nbl[0]_10
+  nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vddc_10 vnwc_11 vpw_11 nbl[2]_10
+  bl[0]_9 nbl[0]_9 nbl[1]_9 bl[1]_9 vddpe_9 vddce_9 vddc_9 vnwc_10 vpw_10
+  nbl[2]_9 bl[0]_8 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 vddce_8 vddc_8 vnwc_9
+  vpw_9 bl[0]_7 nbl[0]_7 nbl[1]_7 bl[1]_7 vddpe_7 vddce_7 vddc_7 vnwc_8 vpw_8
+  bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddpe_6 vddce_6 vddc_6 vnwc_7 vpw_7
+  bl[3]_6 bl[0]_5 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe_5 vddce_5 vddc_5 vnwc_6
+  vpw_6 nbl[2]_5 bl[0]_4 nbl[0]_4 nbl[1]_4 bl[1]_4 vddpe_4 vddce_4 vddc_4
+  vnwc_5 vpw_5 nbl[2]_4 bl[0]_3 nbl[0]_3 nbl[1]_3 bl[1]_3 vddpe_3 vddce_3
+  vddc_3 vnwc_4 vpw_4 bl[0]_2 nbl[0]_2 nbl[1]_2 bl[1]_2 vddpe_2 vddce_2
+  vddc_2 vnwc_3 vpw_3 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddpe_1 vddce_1
+  vddc_1 vnwc_2 vpw_2 bl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe_0
+  vddce_0 vddc_0 vnwc_1 vpw_1 bl[3]_0 vnwp_0 vnwc_0 vpw_0 vpw_33 vnwp_1
+  bl[0]_31 nbl[0]_31 nbl[1]_31 bl[1]_31 vddpe_31 vddce_31 vddc_31 vpw_32
+  bl[0]_30 nbl[0]_30 nbl[1]_30 vddce_30 vddc_30 vnwc_31 vpw_31 bl[3]_30
+  bl[0]_29 nbl[0]_29 nbl[1]_29 vddce_29 vddc_29 vnwc_30 vpw_30 nbl[3]_29
+  bl[3]_29 bl[0]_28 nbl[0]_28 nbl[1]_28 vddce_28 vddc_28 vnwc_29 vpw_29
+  nbl[3]_28 bl[3]_28 bl[0]_27 nbl[0]_27 nbl[1]_27 vddce_27 vddc_27 vnwc_28
+  vpw_28 nbl[3]_27 bl[3]_27 nbl[0]_26 nbl[1]_26 vddce_26 vddc_26 vnwc_27
+  vpw_27 bl[2]_26 bl[3]_26 nbl[0]_25 nbl[1]_25 vddc_25 vpw_26 bl[2]_25
+  bl[3]_25 vddc_24 bl[3]_24 vddc_23 nbl[3]_23 bl[3]_23 vddc_22 nbl[3]_22
+  bl[3]_22 nbl[3]_21 bl[3]_21 bl[2]_20 nbl[3]_20 bl[3]_20 bl[2]_19 nbl[2]_19
+  nbl[3]_19 bl[3]_19 vddc_18 nbl[3]_18 bl[3]_18 vddc_17 nbl[3]_17 bl[3]_17
+  nbl[3]_16 bl[3]_16 bl[2]_15 nbl[3]_15 bl[3]_15 bl[2]_14 nbl[3]_14 bl[3]_14
+  bl[2]_13 nbl[2]_13 nbl[3]_13 bl[3]_13 bl[2]_12 nbl[2]_12 nbl[3]_12 bl[3]_12
+  nbl[3]_11 bl[3]_11 bl[2]_10 nbl[3]_10 bl[3]_10 bl[2]_9 nbl[3]_9 bl[3]_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[2]_6
+  nbl[2]_6 nbl[3]_6 bl[2]_5 nbl[3]_5 bl[3]_5 bl[2]_4 nbl[3]_4 bl[3]_4 bl[2]_3
+  nbl[2]_3 nbl[3]_3 bl[3]_3 bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[2]_1
+  nbl[2]_1 nbl[3]_1 bl[2]_0 nbl[2]_0 nbl[3]_0 wl[1] wl[0]
** rf64x128mem_l_midt_row: 1548 flat devices **
xmem_l_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0 ncored00_320 ncored01_322 ncored10_324
+  ncored11_326 ncored20_328 ncored21_330 ncored30_332 ncored31_334 vddc_0
+  vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_1 nbl[1]_1 nbl[2]_1 nbl[3]_1 ncored00_352 ncored01_354 ncored10_356
+  ncored11_358 ncored20_360 ncored21_362 ncored30_364 ncored31_366 vddc_1
+  vddce_1 vddpe_1 vnwc_2 vpw_2 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_624 cored01_626
+  cored10_628 cored11_630 cored20_632 cored21_634 cored30_636 cored31_638
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_640 ncored01_642
+  ncored10_644 ncored11_646 ncored20_648 ncored21_650 ncored30_652
+  ncored31_654 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_656 cored01_658
+  cored10_660 cored11_662 cored20_664 cored21_666 cored30_668 cored31_670
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_672 ncored01_674
+  ncored10_676 ncored11_678 ncored20_680 ncored21_682 ncored30_684
+  ncored31_686 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_12 bl[0]_12 bl[1]_12 bl[2]_12 bl[3]_12 cored00_688 cored01_690
+  cored10_692 cored11_694 cored20_696 cored21_698 cored30_700 cored31_702
+  nbl[0]_12 nbl[1]_12 nbl[2]_12 nbl[3]_12 ncored00_704 ncored01_706
+  ncored10_708 ncored11_710 ncored20_712 ncored21_714 ncored30_716
+  ncored31_718 vddc_12 vddce_12 vddpe_12 vnwc_13 vpw_13 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_13 bl[0]_13 bl[1]_13 bl[2]_13 bl[3]_13 cored00_752 cored01_754
+  cored10_756 cored11_758 cored20_760 cored21_762 cored30_764 cored31_766
+  nbl[0]_13 nbl[1]_13 nbl[2]_13 nbl[3]_13 ncored00_768 ncored01_770
+  ncored10_772 ncored11_774 ncored20_776 ncored21_778 ncored30_780
+  ncored31_782 vddc_13 vddce_13 vddpe_13 vnwc_14 vpw_14 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_14 bl[0]_14 bl[1]_14 bl[2]_14 bl[3]_14 cored00_816 cored01_818
+  cored10_820 cored11_822 cored20_824 cored21_826 cored30_828 cored31_830
+  nbl[0]_14 nbl[1]_14 nbl[2]_14 nbl[3]_14 ncored00_832 ncored01_834
+  ncored10_836 ncored11_838 ncored20_840 ncored21_842 ncored30_844
+  ncored31_846 vddc_14 vddce_14 vddpe_14 vnwc_15 vpw_15 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_15 bl[0]_15 bl[1]_15 bl[2]_15 bl[3]_15 cored00_848 cored01_850
+  cored10_852 cored11_854 cored20_856 cored21_858 cored30_860 cored31_862
+  nbl[0]_15 nbl[1]_15 nbl[2]_15 nbl[3]_15 ncored00_864 ncored01_866
+  ncored10_868 ncored11_870 ncored20_872 ncored21_874 ncored30_876
+  ncored31_878 vddc_15 vddce_15 vddpe_15 vnwc_16 vpw_16 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_16 bl[0]_16 bl[1]_16 bl[2]_16 bl[3]_16 cored00_880 cored01_882
+  cored10_884 cored11_886 cored20_888 cored21_890 cored30_892 cored31_894
+  nbl[0]_16 nbl[1]_16 nbl[2]_16 nbl[3]_16 ncored00_896 ncored01_898
+  ncored10_900 ncored11_902 ncored20_904 ncored21_906 ncored30_908
+  ncored31_910 vddc_16 vddce_16 vddpe_16 vnwc_17 vpw_17 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_17 bl[0]_17 bl[1]_17 bl[2]_17 bl[3]_17 cored00_912 cored01_914
+  cored10_916 cored11_918 cored20_920 cored21_922 cored30_924 cored31_926
+  nbl[0]_17 nbl[1]_17 nbl[2]_17 nbl[3]_17 ncored00_928 ncored01_930
+  ncored10_932 ncored11_934 ncored20_936 ncored21_938 ncored30_940
+  ncored31_942 vddc_17 vddce_17 vddpe_17 vnwc_18 vpw_18 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_18 bl[0]_18 bl[1]_18 bl[2]_18 bl[3]_18 cored00_944 cored01_946
+  cored10_948 cored11_950 cored20_952 cored21_954 cored30_956 cored31_958
+  nbl[0]_18 nbl[1]_18 nbl[2]_18 nbl[3]_18 ncored00_960 ncored01_962
+  ncored10_964 ncored11_966 ncored20_968 ncored21_970 ncored30_972
+  ncored31_974 vddc_18 vddce_18 vddpe_18 vnwc_19 vpw_19 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_19 bl[0]_19 bl[1]_19 bl[2]_19 bl[3]_19 cored00_976 cored01_978
+  cored10_980 cored11_982 cored20_984 cored21_986 cored30_988 cored31_990
+  nbl[0]_19 nbl[1]_19 nbl[2]_19 nbl[3]_19 ncored00_992 ncored01_994
+  ncored10_996 ncored11_998 ncored20_1000 ncored21_1002 ncored30_1004
+  ncored31_1006 vddc_19 vddce_19 vddpe_19 vnwc_20 vpw_20 vssc vssc wl[0]
+  wl[1] rf64x128cchs4
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_368 cored01_370
+  cored10_372 cored11_374 cored20_376 cored21_378 cored30_380 cored31_382
+  nbl[0]_2 nbl[1]_2 nbl[2]_2 nbl[3]_2 ncored00_384 ncored01_386 ncored10_388
+  ncored11_390 ncored20_392 ncored21_394 ncored30_396 ncored31_398 vddc_2
+  vddce_2 vddpe_2 vnwc_3 vpw_3 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_20 bl[0]_20 bl[1]_20 bl[2]_20 bl[3]_20 cored00 cored01 cored10
+  cored11 cored20 cored21 cored30 cored31 nbl[0]_20 nbl[1]_20 nbl[2]_20
+  nbl[3]_20 ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30
+  ncored31 vddc_20 vddce_20 vddpe_20 vnwc_21 vpw_21 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_21 bl[0]_21 bl[1]_21 bl[2]_21 bl[3]_21 cored00_16 cored01_18
+  cored10_20 cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_21
+  nbl[1]_21 nbl[2]_21 nbl[3]_21 ncored00_32 ncored01_34 ncored10_36
+  ncored11_38 ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_21
+  vddce_21 vddpe_21 vnwc_22 vpw_22 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_22 bl[0]_22 bl[1]_22 bl[2]_22 bl[3]_22 cored00_48 cored01_50
+  cored10_52 cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_22
+  nbl[1]_22 nbl[2]_22 nbl[3]_22 ncored00_64 ncored01_66 ncored10_68
+  ncored11_70 ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_22
+  vddce_22 vddpe_22 vnwc_23 vpw_23 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_23 bl[0]_23 bl[1]_23 bl[2]_23 bl[3]_23 cored00_80 cored01_82
+  cored10_84 cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_23
+  nbl[1]_23 nbl[2]_23 nbl[3]_23 ncored00_96 ncored01_98 ncored10_100
+  ncored11_102 ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_23
+  vddce_23 vddpe_23 vnwc_24 vpw_24 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_24 bl[0]_24 bl[1]_24 bl[2]_24 bl[3]_24 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_24 nbl[1]_24 nbl[2]_24 nbl[3]_24 ncored00_128 ncored01_130
+  ncored10_132 ncored11_134 ncored20_136 ncored21_138 ncored30_140
+  ncored31_142 vddc_24 vddce_24 vddpe_24 vnwc_25 vpw_25 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_25 bl[0]_25 bl[1]_25 bl[2]_25 bl[3]_25 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_25 nbl[1]_25 nbl[2]_25 nbl[3]_25 ncored00_160 ncored01_162
+  ncored10_164 ncored11_166 ncored20_168 ncored21_170 ncored30_172
+  ncored31_174 vddc_25 vddce_25 vddpe_25 vnwc_26 vpw_26 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_26 bl[0]_26 bl[1]_26 bl[2]_26 bl[3]_26 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_26 nbl[1]_26 nbl[2]_26 nbl[3]_26 ncored00_192 ncored01_194
+  ncored10_196 ncored11_198 ncored20_200 ncored21_202 ncored30_204
+  ncored31_206 vddc_26 vddce_26 vddpe_26 vnwc_27 vpw_27 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_27 bl[0]_27 bl[1]_27 bl[2]_27 bl[3]_27 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_27 nbl[1]_27 nbl[2]_27 nbl[3]_27 ncored00_224 ncored01_226
+  ncored10_228 ncored11_230 ncored20_232 ncored21_234 ncored30_236
+  ncored31_238 vddc_27 vddce_27 vddpe_27 vnwc_28 vpw_28 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_28 bl[0]_28 bl[1]_28 bl[2]_28 bl[3]_28 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_28 nbl[1]_28 nbl[2]_28 nbl[3]_28 ncored00_256 ncored01_258
+  ncored10_260 ncored11_262 ncored20_264 ncored21_266 ncored30_268
+  ncored31_270 vddc_28 vddce_28 vddpe_28 vnwc_29 vpw_29 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_29 bl[0]_29 bl[1]_29 bl[2]_29 bl[3]_29 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_29 nbl[1]_29 nbl[2]_29 nbl[3]_29 ncored00_288 ncored01_290
+  ncored10_292 ncored11_294 ncored20_296 ncored21_298 ncored30_300
+  ncored31_302 vddc_29 vddce_29 vddpe_29 vnwc_30 vpw_30 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_400 cored01_402
+  cored10_404 cored11_406 cored20_408 cored21_410 cored30_412 cored31_414
+  nbl[0]_3 nbl[1]_3 nbl[2]_3 nbl[3]_3 ncored00_416 ncored01_418 ncored10_420
+  ncored11_422 ncored20_424 ncored21_426 ncored30_428 ncored31_430 vddc_3
+  vddce_3 vddpe_3 vnwc_4 vpw_4 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_30 bl[0]_30 bl[1]_30 bl[2]_30 bl[3]_30 cored00_720 cored01_722
+  cored10_724 cored11_726 cored20_728 cored21_730 cored30_732 cored31_734
+  nbl[0]_30 nbl[1]_30 nbl[2]_30 nbl[3]_30 ncored00_736 ncored01_738
+  ncored10_740 ncored11_742 ncored20_744 ncored21_746 ncored30_748
+  ncored31_750 vddc_30 vddce_30 vddpe_30 vnwc_31 vpw_31 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_31 bl[0]_31 bl[1]_31 bl[2]_31 bl[3]_31 cored00_784 cored01_786
+  cored10_788 cored11_790 cored20_792 cored21_794 cored30_796 cored31_798
+  nbl[0]_31 nbl[1]_31 nbl[2]_31 nbl[3]_31 ncored00_800 ncored01_802
+  ncored10_804 ncored11_806 ncored20_808 ncored21_810 ncored30_812
+  ncored31_814 vddc_31 vddce_31 vddpe_31 vnwc_32 vpw_32 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_432 cored01_434
+  cored10_436 cored11_438 cored20_440 cored21_442 cored30_444 cored31_446
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_448 ncored01_450 ncored10_452
+  ncored11_454 ncored20_456 ncored21_458 ncored30_460 ncored31_462 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_464 cored01_466
+  cored10_468 cored11_470 cored20_472 cored21_474 cored30_476 cored31_478
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_480 ncored01_482 ncored10_484
+  ncored11_486 ncored20_488 ncored21_490 ncored30_492 ncored31_494 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_496 cored01_498
+  cored10_500 cored11_502 cored20_504 cored21_506 cored30_508 cored31_510
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_512 ncored01_514 ncored10_516
+  ncored11_518 ncored20_520 ncored21_522 ncored30_524 ncored31_526 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_528 cored01_530
+  cored10_532 cored11_534 cored20_536 cored21_538 cored30_540 cored31_542
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_544 ncored01_546 ncored10_548
+  ncored11_550 ncored20_552 ncored21_554 ncored30_556 ncored31_558 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_560 cored01_562
+  cored10_564 cored11_566 cored20_568 cored21_570 cored30_572 cored31_574
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_576 ncored01_578 ncored10_580
+  ncored11_582 ncored20_584 ncored21_586 ncored30_588 ncored31_590 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_592 cored01_594
+  cored10_596 cored11_598 cored20_600 cored21_602 cored30_604 cored31_606
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_608 ncored01_610 ncored10_612
+  ncored11_614 ncored20_616 ncored21_618 ncored30_620 ncored31_622 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_edger dbl dwl vddc_32 vnwc_33 vnwp_1 vpw_33 vssc wl[0] wl[1]
+  rf64x128cchs4wd_edgbl_dummy
.ends rf64x128mem_l_midt_row
****
.subckt rf64x128mem_l_mid_row vddc_32 vpw_33 vddc_31 vnwc_32 bl[2]_31
+  nbl[2]_31 nbl[3]_31 bl[3]_31 bl[1]_30 vddpe_30 bl[2]_30 nbl[2]_30 nbl[3]_30
+  bl[1]_29 vddpe_29 bl[2]_29 nbl[2]_29 bl[1]_28 vddpe_28 bl[2]_28 nbl[2]_28
+  bl[1]_27 vddpe_27 bl[2]_27 nbl[2]_27 bl[0]_26 bl[1]_26 vddpe_26 nbl[2]_26
+  nbl[3]_26 bl[0]_25 bl[1]_25 vddpe_25 vddce_25 vnwc_26 vssc nbl[2]_25
+  nbl[3]_25 bl[0]_24 nbl[0]_24 nbl[1]_24 bl[1]_24 vddpe_24 vddce_24 vnwc_25
+  vpw_25 bl[2]_24 nbl[2]_24 nbl[3]_24 bl[0]_23 nbl[0]_23 nbl[1]_23 bl[1]_23
+  vddpe_23 vddce_23 vnwc_24 vpw_24 bl[2]_23 nbl[2]_23 bl[0]_22 nbl[0]_22
+  nbl[1]_22 bl[1]_22 vddpe_22 vddce_22 vnwc_23 vpw_23 bl[2]_22 nbl[2]_22
+  bl[0]_21 nbl[0]_21 nbl[1]_21 bl[1]_21 vddpe_21 vddce_21 vddc_21 vnwc_22
+  vpw_22 bl[2]_21 nbl[2]_21 bl[0]_20 nbl[0]_20 nbl[1]_20 bl[1]_20 vddpe_20
+  vddce_20 vddc_20 vnwc_21 vpw_21 nbl[2]_20 bl[0]_19 nbl[0]_19 nbl[1]_19
+  bl[1]_19 vddpe_19 vddce_19 vddc_19 vnwc_20 vpw_20 bl[0]_18 nbl[0]_18
+  nbl[1]_18 bl[1]_18 vddpe_18 vddce_18 vnwc_19 vpw_19 bl[2]_18 nbl[2]_18
+  bl[0]_17 nbl[0]_17 nbl[1]_17 bl[1]_17 vddpe_17 vddce_17 vnwc_18 vpw_18
+  bl[2]_17 nbl[2]_17 bl[0]_16 nbl[0]_16 nbl[1]_16 bl[1]_16 vddpe_16 vddce_16
+  vddc_16 vnwc_17 vpw_17 bl[2]_16 nbl[2]_16 bl[0]_15 nbl[0]_15 nbl[1]_15
+  bl[1]_15 vddpe_15 vddce_15 vddc_15 vnwc_16 vpw_16 nbl[2]_15 bl[0]_14
+  nbl[0]_14 nbl[1]_14 bl[1]_14 vddpe_14 vddce_14 vddc_14 vnwc_15 vpw_15
+  nbl[2]_14 bl[0]_13 nbl[0]_13 nbl[1]_13 bl[1]_13 vddpe_13 vddce_13 vddc_13
+  vnwc_14 vpw_14 bl[0]_12 nbl[0]_12 nbl[1]_12 bl[1]_12 vddpe_12 vddce_12
+  vddc_12 vnwc_13 vpw_13 bl[0]_11 nbl[0]_11 nbl[1]_11 bl[1]_11 vddpe_11
+  vddce_11 vddc_11 vnwc_12 vpw_12 bl[2]_11 nbl[2]_11 bl[0]_10 nbl[0]_10
+  nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vddc_10 vnwc_11 vpw_11 nbl[2]_10
+  bl[0]_9 nbl[0]_9 nbl[1]_9 bl[1]_9 vddpe_9 vddce_9 vddc_9 vnwc_10 vpw_10
+  nbl[2]_9 bl[0]_8 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 vddce_8 vddc_8 vnwc_9
+  vpw_9 bl[0]_7 nbl[0]_7 nbl[1]_7 bl[1]_7 vddpe_7 vddce_7 vddc_7 vnwc_8 vpw_8
+  bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddpe_6 vddce_6 vddc_6 vnwc_7 vpw_7
+  bl[3]_6 bl[0]_5 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe_5 vddce_5 vddc_5 vnwc_6
+  vpw_6 nbl[2]_5 bl[0]_4 nbl[0]_4 nbl[1]_4 bl[1]_4 vddpe_4 vddce_4 vddc_4
+  vnwc_5 vpw_5 nbl[2]_4 bl[0]_3 nbl[0]_3 nbl[1]_3 bl[1]_3 vddpe_3 vddce_3
+  vddc_3 vnwc_4 vpw_4 bl[0]_2 nbl[0]_2 nbl[1]_2 bl[1]_2 vddpe_2 vddce_2
+  vddc_2 vnwc_3 vpw_3 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddpe_1 vddce_1
+  vddc_1 vnwc_2 vpw_2 bl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe_0
+  vddce_0 vddc_0 vnwc_1 vpw_1 bl[3]_0 vnwc_0 vpw_0 vnwc_33 vnwp_1 dbl dwl
+  bl[0]_31 nbl[0]_31 nbl[1]_31 bl[1]_31 vddpe_31 vddce_31 vpw_32 bl[0]_30
+  nbl[0]_30 nbl[1]_30 vddce_30 vddc_30 vnwc_31 vpw_31 bl[3]_30 bl[0]_29
+  nbl[0]_29 nbl[1]_29 vddce_29 vddc_29 vnwc_30 vpw_30 nbl[3]_29 bl[3]_29
+  bl[0]_28 nbl[0]_28 nbl[1]_28 vddce_28 vddc_28 vnwc_29 vpw_29 nbl[3]_28
+  bl[3]_28 bl[0]_27 nbl[0]_27 nbl[1]_27 vddce_27 vddc_27 vnwc_28 vpw_28
+  nbl[3]_27 bl[3]_27 nbl[0]_26 nbl[1]_26 vddce_26 vddc_26 vnwc_27 vpw_27
+  bl[2]_26 bl[3]_26 nbl[0]_25 nbl[1]_25 vddc_25 vpw_26 bl[2]_25 bl[3]_25
+  vddc_24 bl[3]_24 vddc_23 nbl[3]_23 bl[3]_23 vddc_22 nbl[3]_22 bl[3]_22
+  nbl[3]_21 bl[3]_21 bl[2]_20 nbl[3]_20 bl[3]_20 bl[2]_19 nbl[2]_19 nbl[3]_19
+  bl[3]_19 vddc_18 nbl[3]_18 bl[3]_18 vddc_17 nbl[3]_17 bl[3]_17 nbl[3]_16
+  bl[3]_16 bl[2]_15 nbl[3]_15 bl[3]_15 bl[2]_14 nbl[3]_14 bl[3]_14 bl[2]_13
+  nbl[2]_13 nbl[3]_13 bl[3]_13 bl[2]_12 nbl[2]_12 nbl[3]_12 bl[3]_12
+  nbl[3]_11 bl[3]_11 bl[2]_10 nbl[3]_10 bl[3]_10 bl[2]_9 nbl[3]_9 bl[3]_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[2]_6
+  nbl[2]_6 nbl[3]_6 bl[2]_5 nbl[3]_5 bl[3]_5 bl[2]_4 nbl[3]_4 bl[3]_4 bl[2]_3
+  nbl[2]_3 nbl[3]_3 bl[3]_3 bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[2]_1
+  nbl[2]_1 nbl[3]_1 bl[2]_0 nbl[2]_0 nbl[3]_0 vnwp_0 wl[0] wl[1]
** rf64x128mem_l_mid_row: 1548 flat devices **
xmem_l_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0 ncored00_320 ncored01_322 ncored10_324
+  ncored11_326 ncored20_328 ncored21_330 ncored30_332 ncored31_334 vddc_0
+  vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_1 nbl[1]_1 nbl[2]_1 nbl[3]_1 ncored00_352 ncored01_354 ncored10_356
+  ncored11_358 ncored20_360 ncored21_362 ncored30_364 ncored31_366 vddc_1
+  vddce_1 vddpe_1 vnwc_2 vpw_2 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_624 cored01_626
+  cored10_628 cored11_630 cored20_632 cored21_634 cored30_636 cored31_638
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_640 ncored01_642
+  ncored10_644 ncored11_646 ncored20_648 ncored21_650 ncored30_652
+  ncored31_654 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_656 cored01_658
+  cored10_660 cored11_662 cored20_664 cored21_666 cored30_668 cored31_670
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_672 ncored01_674
+  ncored10_676 ncored11_678 ncored20_680 ncored21_682 ncored30_684
+  ncored31_686 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_12 bl[0]_12 bl[1]_12 bl[2]_12 bl[3]_12 cored00_688 cored01_690
+  cored10_692 cored11_694 cored20_696 cored21_698 cored30_700 cored31_702
+  nbl[0]_12 nbl[1]_12 nbl[2]_12 nbl[3]_12 ncored00_704 ncored01_706
+  ncored10_708 ncored11_710 ncored20_712 ncored21_714 ncored30_716
+  ncored31_718 vddc_12 vddce_12 vddpe_12 vnwc_13 vpw_13 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_13 bl[0]_13 bl[1]_13 bl[2]_13 bl[3]_13 cored00_752 cored01_754
+  cored10_756 cored11_758 cored20_760 cored21_762 cored30_764 cored31_766
+  nbl[0]_13 nbl[1]_13 nbl[2]_13 nbl[3]_13 ncored00_768 ncored01_770
+  ncored10_772 ncored11_774 ncored20_776 ncored21_778 ncored30_780
+  ncored31_782 vddc_13 vddce_13 vddpe_13 vnwc_14 vpw_14 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_14 bl[0]_14 bl[1]_14 bl[2]_14 bl[3]_14 cored00_816 cored01_818
+  cored10_820 cored11_822 cored20_824 cored21_826 cored30_828 cored31_830
+  nbl[0]_14 nbl[1]_14 nbl[2]_14 nbl[3]_14 ncored00_832 ncored01_834
+  ncored10_836 ncored11_838 ncored20_840 ncored21_842 ncored30_844
+  ncored31_846 vddc_14 vddce_14 vddpe_14 vnwc_15 vpw_15 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_15 bl[0]_15 bl[1]_15 bl[2]_15 bl[3]_15 cored00_848 cored01_850
+  cored10_852 cored11_854 cored20_856 cored21_858 cored30_860 cored31_862
+  nbl[0]_15 nbl[1]_15 nbl[2]_15 nbl[3]_15 ncored00_864 ncored01_866
+  ncored10_868 ncored11_870 ncored20_872 ncored21_874 ncored30_876
+  ncored31_878 vddc_15 vddce_15 vddpe_15 vnwc_16 vpw_16 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_16 bl[0]_16 bl[1]_16 bl[2]_16 bl[3]_16 cored00_880 cored01_882
+  cored10_884 cored11_886 cored20_888 cored21_890 cored30_892 cored31_894
+  nbl[0]_16 nbl[1]_16 nbl[2]_16 nbl[3]_16 ncored00_896 ncored01_898
+  ncored10_900 ncored11_902 ncored20_904 ncored21_906 ncored30_908
+  ncored31_910 vddc_16 vddce_16 vddpe_16 vnwc_17 vpw_17 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_17 bl[0]_17 bl[1]_17 bl[2]_17 bl[3]_17 cored00_912 cored01_914
+  cored10_916 cored11_918 cored20_920 cored21_922 cored30_924 cored31_926
+  nbl[0]_17 nbl[1]_17 nbl[2]_17 nbl[3]_17 ncored00_928 ncored01_930
+  ncored10_932 ncored11_934 ncored20_936 ncored21_938 ncored30_940
+  ncored31_942 vddc_17 vddce_17 vddpe_17 vnwc_18 vpw_18 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_18 bl[0]_18 bl[1]_18 bl[2]_18 bl[3]_18 cored00_944 cored01_946
+  cored10_948 cored11_950 cored20_952 cored21_954 cored30_956 cored31_958
+  nbl[0]_18 nbl[1]_18 nbl[2]_18 nbl[3]_18 ncored00_960 ncored01_962
+  ncored10_964 ncored11_966 ncored20_968 ncored21_970 ncored30_972
+  ncored31_974 vddc_18 vddce_18 vddpe_18 vnwc_19 vpw_19 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_19 bl[0]_19 bl[1]_19 bl[2]_19 bl[3]_19 cored00_976 cored01_978
+  cored10_980 cored11_982 cored20_984 cored21_986 cored30_988 cored31_990
+  nbl[0]_19 nbl[1]_19 nbl[2]_19 nbl[3]_19 ncored00_992 ncored01_994
+  ncored10_996 ncored11_998 ncored20_1000 ncored21_1002 ncored30_1004
+  ncored31_1006 vddc_19 vddce_19 vddpe_19 vnwc_20 vpw_20 vssc vssc wl[1]
+  wl[0] rf64x128cchs4
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_368 cored01_370
+  cored10_372 cored11_374 cored20_376 cored21_378 cored30_380 cored31_382
+  nbl[0]_2 nbl[1]_2 nbl[2]_2 nbl[3]_2 ncored00_384 ncored01_386 ncored10_388
+  ncored11_390 ncored20_392 ncored21_394 ncored30_396 ncored31_398 vddc_2
+  vddce_2 vddpe_2 vnwc_3 vpw_3 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_20 bl[0]_20 bl[1]_20 bl[2]_20 bl[3]_20 cored00 cored01 cored10
+  cored11 cored20 cored21 cored30 cored31 nbl[0]_20 nbl[1]_20 nbl[2]_20
+  nbl[3]_20 ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30
+  ncored31 vddc_20 vddce_20 vddpe_20 vnwc_21 vpw_21 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_21 bl[0]_21 bl[1]_21 bl[2]_21 bl[3]_21 cored00_16 cored01_18
+  cored10_20 cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_21
+  nbl[1]_21 nbl[2]_21 nbl[3]_21 ncored00_32 ncored01_34 ncored10_36
+  ncored11_38 ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_21
+  vddce_21 vddpe_21 vnwc_22 vpw_22 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_22 bl[0]_22 bl[1]_22 bl[2]_22 bl[3]_22 cored00_48 cored01_50
+  cored10_52 cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_22
+  nbl[1]_22 nbl[2]_22 nbl[3]_22 ncored00_64 ncored01_66 ncored10_68
+  ncored11_70 ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_22
+  vddce_22 vddpe_22 vnwc_23 vpw_23 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_23 bl[0]_23 bl[1]_23 bl[2]_23 bl[3]_23 cored00_80 cored01_82
+  cored10_84 cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_23
+  nbl[1]_23 nbl[2]_23 nbl[3]_23 ncored00_96 ncored01_98 ncored10_100
+  ncored11_102 ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_23
+  vddce_23 vddpe_23 vnwc_24 vpw_24 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_24 bl[0]_24 bl[1]_24 bl[2]_24 bl[3]_24 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_24 nbl[1]_24 nbl[2]_24 nbl[3]_24 ncored00_128 ncored01_130
+  ncored10_132 ncored11_134 ncored20_136 ncored21_138 ncored30_140
+  ncored31_142 vddc_24 vddce_24 vddpe_24 vnwc_25 vpw_25 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_25 bl[0]_25 bl[1]_25 bl[2]_25 bl[3]_25 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_25 nbl[1]_25 nbl[2]_25 nbl[3]_25 ncored00_160 ncored01_162
+  ncored10_164 ncored11_166 ncored20_168 ncored21_170 ncored30_172
+  ncored31_174 vddc_25 vddce_25 vddpe_25 vnwc_26 vpw_26 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_26 bl[0]_26 bl[1]_26 bl[2]_26 bl[3]_26 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_26 nbl[1]_26 nbl[2]_26 nbl[3]_26 ncored00_192 ncored01_194
+  ncored10_196 ncored11_198 ncored20_200 ncored21_202 ncored30_204
+  ncored31_206 vddc_26 vddce_26 vddpe_26 vnwc_27 vpw_27 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_27 bl[0]_27 bl[1]_27 bl[2]_27 bl[3]_27 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_27 nbl[1]_27 nbl[2]_27 nbl[3]_27 ncored00_224 ncored01_226
+  ncored10_228 ncored11_230 ncored20_232 ncored21_234 ncored30_236
+  ncored31_238 vddc_27 vddce_27 vddpe_27 vnwc_28 vpw_28 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_28 bl[0]_28 bl[1]_28 bl[2]_28 bl[3]_28 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_28 nbl[1]_28 nbl[2]_28 nbl[3]_28 ncored00_256 ncored01_258
+  ncored10_260 ncored11_262 ncored20_264 ncored21_266 ncored30_268
+  ncored31_270 vddc_28 vddce_28 vddpe_28 vnwc_29 vpw_29 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_29 bl[0]_29 bl[1]_29 bl[2]_29 bl[3]_29 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_29 nbl[1]_29 nbl[2]_29 nbl[3]_29 ncored00_288 ncored01_290
+  ncored10_292 ncored11_294 ncored20_296 ncored21_298 ncored30_300
+  ncored31_302 vddc_29 vddce_29 vddpe_29 vnwc_30 vpw_30 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_400 cored01_402
+  cored10_404 cored11_406 cored20_408 cored21_410 cored30_412 cored31_414
+  nbl[0]_3 nbl[1]_3 nbl[2]_3 nbl[3]_3 ncored00_416 ncored01_418 ncored10_420
+  ncored11_422 ncored20_424 ncored21_426 ncored30_428 ncored31_430 vddc_3
+  vddce_3 vddpe_3 vnwc_4 vpw_4 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_30 bl[0]_30 bl[1]_30 bl[2]_30 bl[3]_30 cored00_720 cored01_722
+  cored10_724 cored11_726 cored20_728 cored21_730 cored30_732 cored31_734
+  nbl[0]_30 nbl[1]_30 nbl[2]_30 nbl[3]_30 ncored00_736 ncored01_738
+  ncored10_740 ncored11_742 ncored20_744 ncored21_746 ncored30_748
+  ncored31_750 vddc_30 vddce_30 vddpe_30 vnwc_31 vpw_31 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_31 bl[0]_31 bl[1]_31 bl[2]_31 bl[3]_31 cored00_784 cored01_786
+  cored10_788 cored11_790 cored20_792 cored21_794 cored30_796 cored31_798
+  nbl[0]_31 nbl[1]_31 nbl[2]_31 nbl[3]_31 ncored00_800 ncored01_802
+  ncored10_804 ncored11_806 ncored20_808 ncored21_810 ncored30_812
+  ncored31_814 vddc_31 vddce_31 vddpe_31 vnwc_32 vpw_32 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_432 cored01_434
+  cored10_436 cored11_438 cored20_440 cored21_442 cored30_444 cored31_446
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_448 ncored01_450 ncored10_452
+  ncored11_454 ncored20_456 ncored21_458 ncored30_460 ncored31_462 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_464 cored01_466
+  cored10_468 cored11_470 cored20_472 cored21_474 cored30_476 cored31_478
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_480 ncored01_482 ncored10_484
+  ncored11_486 ncored20_488 ncored21_490 ncored30_492 ncored31_494 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_496 cored01_498
+  cored10_500 cored11_502 cored20_504 cored21_506 cored30_508 cored31_510
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_512 ncored01_514 ncored10_516
+  ncored11_518 ncored20_520 ncored21_522 ncored30_524 ncored31_526 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_528 cored01_530
+  cored10_532 cored11_534 cored20_536 cored21_538 cored30_540 cored31_542
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_544 ncored01_546 ncored10_548
+  ncored11_550 ncored20_552 ncored21_554 ncored30_556 ncored31_558 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_560 cored01_562
+  cored10_564 cored11_566 cored20_568 cored21_570 cored30_572 cored31_574
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_576 ncored01_578 ncored10_580
+  ncored11_582 ncored20_584 ncored21_586 ncored30_588 ncored31_590 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_592 cored01_594
+  cored10_596 cored11_598 cored20_600 cored21_602 cored30_604 cored31_606
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_608 ncored01_610 ncored10_612
+  ncored11_614 ncored20_616 ncored21_618 ncored30_620 ncored31_622 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_edger dbl dwl vddc_32 vnwc_33 vnwp_1 vpw_33 vssc wl[0] wl[1]
+  rf64x128cchs4wd_edgbl_dummy
.ends rf64x128mem_l_mid_row
****
.subckt rf64x128mem_l_bot_row vddc_32 vnwc_33 dbl dwl vnwc_32 bl[2]_31
+  nbl[2]_31 nbl[3]_31 bl[3]_31 bl[1]_30 vddpe_30 bl[2]_30 nbl[2]_30 nbl[3]_30
+  bl[1]_29 vddpe_29 bl[2]_29 nbl[2]_29 bl[1]_28 vddpe_28 bl[2]_28 nbl[2]_28
+  bl[1]_27 vddpe_27 bl[2]_27 nbl[2]_27 bl[0]_26 bl[1]_26 vddpe_26 nbl[2]_26
+  nbl[3]_26 bl[0]_25 bl[1]_25 vddpe_25 vddce_25 vnwc_26 vssc nbl[2]_25
+  nbl[3]_25 bl[0]_24 nbl[0]_24 nbl[1]_24 bl[1]_24 vddpe_24 vddce_24 vnwc_25
+  vpw_25 bl[2]_24 nbl[2]_24 nbl[3]_24 bl[0]_23 nbl[0]_23 nbl[1]_23 bl[1]_23
+  vddpe_23 vddce_23 vnwc_24 vpw_24 bl[2]_23 nbl[2]_23 bl[0]_22 nbl[0]_22
+  nbl[1]_22 bl[1]_22 vddpe_22 vddce_22 vnwc_23 vpw_23 bl[2]_22 nbl[2]_22
+  bl[0]_21 nbl[0]_21 nbl[1]_21 bl[1]_21 vddpe_21 vddce_21 vddc_21 vnwc_22
+  vpw_22 bl[2]_21 nbl[2]_21 bl[0]_20 nbl[0]_20 nbl[1]_20 bl[1]_20 vddpe_20
+  vddce_20 vddc_20 vnwc_21 vpw_21 nbl[2]_20 bl[0]_19 nbl[0]_19 nbl[1]_19
+  bl[1]_19 vddpe_19 vddce_19 vddc_19 vnwc_20 vpw_20 bl[0]_18 nbl[0]_18
+  nbl[1]_18 bl[1]_18 vddpe_18 vddce_18 vnwc_19 vpw_19 bl[2]_18 nbl[2]_18
+  bl[0]_17 nbl[0]_17 nbl[1]_17 bl[1]_17 vddpe_17 vddce_17 vnwc_18 vpw_18
+  bl[2]_17 nbl[2]_17 bl[0]_16 nbl[0]_16 nbl[1]_16 bl[1]_16 vddpe_16 vddce_16
+  vddc_16 vnwc_17 vpw_17 bl[2]_16 nbl[2]_16 bl[0]_15 nbl[0]_15 nbl[1]_15
+  bl[1]_15 vddpe_15 vddce_15 vddc_15 vnwc_16 vpw_16 nbl[2]_15 bl[0]_14
+  nbl[0]_14 nbl[1]_14 bl[1]_14 vddpe_14 vddce_14 vddc_14 vnwc_15 vpw_15
+  nbl[2]_14 bl[0]_13 nbl[0]_13 nbl[1]_13 bl[1]_13 vddpe_13 vddce_13 vddc_13
+  vnwc_14 vpw_14 bl[0]_12 nbl[0]_12 nbl[1]_12 bl[1]_12 vddpe_12 vddce_12
+  vddc_12 vnwc_13 vpw_13 bl[0]_11 nbl[0]_11 nbl[1]_11 bl[1]_11 vddpe_11
+  vddce_11 vddc_11 vnwc_12 vpw_12 bl[2]_11 nbl[2]_11 bl[0]_10 nbl[0]_10
+  nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vddc_10 vnwc_11 vpw_11 nbl[2]_10
+  bl[0]_9 nbl[0]_9 nbl[1]_9 bl[1]_9 vddpe_9 vddce_9 vddc_9 vnwc_10 vpw_10
+  nbl[2]_9 bl[0]_8 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 vddce_8 vddc_8 vnwc_9
+  vpw_9 bl[0]_7 nbl[0]_7 nbl[1]_7 bl[1]_7 vddpe_7 vddce_7 vddc_7 vnwc_8 vpw_8
+  bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddpe_6 vddce_6 vddc_6 vnwc_7 vpw_7
+  bl[3]_6 bl[0]_5 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe_5 vddce_5 vddc_5 vnwc_6
+  vpw_6 nbl[2]_5 bl[0]_4 nbl[0]_4 nbl[1]_4 bl[1]_4 vddpe_4 vddce_4 vddc_4
+  vnwc_5 vpw_5 nbl[2]_4 bl[0]_3 nbl[0]_3 nbl[1]_3 bl[1]_3 vddpe_3 vddce_3
+  vddc_3 vnwc_4 vpw_4 bl[0]_2 nbl[0]_2 nbl[1]_2 bl[1]_2 vddpe_2 vddce_2
+  vddc_2 vnwc_3 vpw_3 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddpe_1 vddce_1
+  vddc_1 vnwc_2 vpw_2 bl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe_0
+  vddce_0 vddc_0 vnwc_1 vsse_0 vpw_1 bl[3]_0 vnwp_0 vnwc_0 vpw_0 vpw_33
+  vnwp_1 bl[0]_31 nbl[0]_31 nbl[1]_31 bl[1]_31 vddpe_31 vddce_31 vddc_31
+  vsse_1 vpw_32 bl[0]_30 nbl[0]_30 nbl[1]_30 vddce_30 vddc_30 vnwc_31 vpw_31
+  bl[3]_30 bl[0]_29 nbl[0]_29 nbl[1]_29 vddce_29 vddc_29 vnwc_30 vpw_30
+  nbl[3]_29 bl[3]_29 bl[0]_28 nbl[0]_28 nbl[1]_28 vddce_28 vddc_28 vnwc_29
+  vpw_29 nbl[3]_28 bl[3]_28 bl[0]_27 nbl[0]_27 nbl[1]_27 vddce_27 vddc_27
+  vnwc_28 vpw_28 nbl[3]_27 bl[3]_27 nbl[0]_26 nbl[1]_26 vddce_26 vddc_26
+  vnwc_27 vpw_27 bl[2]_26 bl[3]_26 nbl[0]_25 nbl[1]_25 vddc_25 vpw_26
+  bl[2]_25 bl[3]_25 vddc_24 bl[3]_24 vddc_23 nbl[3]_23 bl[3]_23 vddc_22
+  nbl[3]_22 bl[3]_22 nbl[3]_21 bl[3]_21 bl[2]_20 nbl[3]_20 bl[3]_20 bl[2]_19
+  nbl[2]_19 nbl[3]_19 bl[3]_19 vddc_18 nbl[3]_18 bl[3]_18 vddc_17 nbl[3]_17
+  bl[3]_17 nbl[3]_16 bl[3]_16 bl[2]_15 nbl[3]_15 bl[3]_15 bl[2]_14 nbl[3]_14
+  bl[3]_14 bl[2]_13 nbl[2]_13 nbl[3]_13 bl[3]_13 bl[2]_12 nbl[2]_12 nbl[3]_12
+  bl[3]_12 nbl[3]_11 bl[3]_11 bl[2]_10 nbl[3]_10 bl[3]_10 bl[2]_9 nbl[3]_9
+  bl[3]_9 bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7
+  bl[2]_6 nbl[2]_6 nbl[3]_6 bl[2]_5 nbl[3]_5 bl[3]_5 bl[2]_4 nbl[3]_4 bl[3]_4
+  bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3 bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[2]_1
+  nbl[2]_1 nbl[3]_1 bl[2]_0 nbl[2]_0 nbl[3]_0 wl[1] wl[0]
** rf64x128mem_l_bot_row: 1548 flat devices **
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_1 nbl[1]_1 nbl[2]_1 nbl[3]_1 ncored00_320 ncored01_322 ncored10_324
+  ncored11_326 ncored20_328 ncored21_330 ncored30_332 ncored31_334 vddc_1
+  vddce_1 vddpe_1 vnwc_2 vpw_2 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_592 cored01_594
+  cored10_596 cored11_598 cored20_600 cored21_602 cored30_604 cored31_606
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_608 ncored01_610
+  ncored10_612 ncored11_614 ncored20_616 ncored21_618 ncored30_620
+  ncored31_622 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_624 cored01_626
+  cored10_628 cored11_630 cored20_632 cored21_634 cored30_636 cored31_638
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_640 ncored01_642
+  ncored10_644 ncored11_646 ncored20_648 ncored21_650 ncored30_652
+  ncored31_654 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_12 bl[0]_12 bl[1]_12 bl[2]_12 bl[3]_12 cored00_656 cored01_658
+  cored10_660 cored11_662 cored20_664 cored21_666 cored30_668 cored31_670
+  nbl[0]_12 nbl[1]_12 nbl[2]_12 nbl[3]_12 ncored00_672 ncored01_674
+  ncored10_676 ncored11_678 ncored20_680 ncored21_682 ncored30_684
+  ncored31_686 vddc_12 vddce_12 vddpe_12 vnwc_13 vpw_13 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_13 bl[0]_13 bl[1]_13 bl[2]_13 bl[3]_13 cored00_720 cored01_722
+  cored10_724 cored11_726 cored20_728 cored21_730 cored30_732 cored31_734
+  nbl[0]_13 nbl[1]_13 nbl[2]_13 nbl[3]_13 ncored00_736 ncored01_738
+  ncored10_740 ncored11_742 ncored20_744 ncored21_746 ncored30_748
+  ncored31_750 vddc_13 vddce_13 vddpe_13 vnwc_14 vpw_14 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_14 bl[0]_14 bl[1]_14 bl[2]_14 bl[3]_14 cored00_752 cored01_754
+  cored10_756 cored11_758 cored20_760 cored21_762 cored30_764 cored31_766
+  nbl[0]_14 nbl[1]_14 nbl[2]_14 nbl[3]_14 ncored00_768 ncored01_770
+  ncored10_772 ncored11_774 ncored20_776 ncored21_778 ncored30_780
+  ncored31_782 vddc_14 vddce_14 vddpe_14 vnwc_15 vpw_15 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_15 bl[0]_15 bl[1]_15 bl[2]_15 bl[3]_15 cored00_784 cored01_786
+  cored10_788 cored11_790 cored20_792 cored21_794 cored30_796 cored31_798
+  nbl[0]_15 nbl[1]_15 nbl[2]_15 nbl[3]_15 ncored00_800 ncored01_802
+  ncored10_804 ncored11_806 ncored20_808 ncored21_810 ncored30_812
+  ncored31_814 vddc_15 vddce_15 vddpe_15 vnwc_16 vpw_16 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_16 bl[0]_16 bl[1]_16 bl[2]_16 bl[3]_16 cored00_816 cored01_818
+  cored10_820 cored11_822 cored20_824 cored21_826 cored30_828 cored31_830
+  nbl[0]_16 nbl[1]_16 nbl[2]_16 nbl[3]_16 ncored00_832 ncored01_834
+  ncored10_836 ncored11_838 ncored20_840 ncored21_842 ncored30_844
+  ncored31_846 vddc_16 vddce_16 vddpe_16 vnwc_17 vpw_17 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_17 bl[0]_17 bl[1]_17 bl[2]_17 bl[3]_17 cored00_848 cored01_850
+  cored10_852 cored11_854 cored20_856 cored21_858 cored30_860 cored31_862
+  nbl[0]_17 nbl[1]_17 nbl[2]_17 nbl[3]_17 ncored00_864 ncored01_866
+  ncored10_868 ncored11_870 ncored20_872 ncored21_874 ncored30_876
+  ncored31_878 vddc_17 vddce_17 vddpe_17 vnwc_18 vpw_18 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_18 bl[0]_18 bl[1]_18 bl[2]_18 bl[3]_18 cored00_880 cored01_882
+  cored10_884 cored11_886 cored20_888 cored21_890 cored30_892 cored31_894
+  nbl[0]_18 nbl[1]_18 nbl[2]_18 nbl[3]_18 ncored00_896 ncored01_898
+  ncored10_900 ncored11_902 ncored20_904 ncored21_906 ncored30_908
+  ncored31_910 vddc_18 vddce_18 vddpe_18 vnwc_19 vpw_19 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_19 bl[0]_19 bl[1]_19 bl[2]_19 bl[3]_19 cored00_912 cored01_914
+  cored10_916 cored11_918 cored20_920 cored21_922 cored30_924 cored31_926
+  nbl[0]_19 nbl[1]_19 nbl[2]_19 nbl[3]_19 ncored00_928 ncored01_930
+  ncored10_932 ncored11_934 ncored20_936 ncored21_938 ncored30_940
+  ncored31_942 vddc_19 vddce_19 vddpe_19 vnwc_20 vpw_20 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_2 nbl[1]_2 nbl[2]_2 nbl[3]_2 ncored00_352 ncored01_354 ncored10_356
+  ncored11_358 ncored20_360 ncored21_362 ncored30_364 ncored31_366 vddc_2
+  vddce_2 vddpe_2 vnwc_3 vpw_3 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_20 bl[0]_20 bl[1]_20 bl[2]_20 bl[3]_20 cored00 cored01 cored10
+  cored11 cored20 cored21 cored30 cored31 nbl[0]_20 nbl[1]_20 nbl[2]_20
+  nbl[3]_20 ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30
+  ncored31 vddc_20 vddce_20 vddpe_20 vnwc_21 vpw_21 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_21 bl[0]_21 bl[1]_21 bl[2]_21 bl[3]_21 cored00_16 cored01_18
+  cored10_20 cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_21
+  nbl[1]_21 nbl[2]_21 nbl[3]_21 ncored00_32 ncored01_34 ncored10_36
+  ncored11_38 ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_21
+  vddce_21 vddpe_21 vnwc_22 vpw_22 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_22 bl[0]_22 bl[1]_22 bl[2]_22 bl[3]_22 cored00_48 cored01_50
+  cored10_52 cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_22
+  nbl[1]_22 nbl[2]_22 nbl[3]_22 ncored00_64 ncored01_66 ncored10_68
+  ncored11_70 ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_22
+  vddce_22 vddpe_22 vnwc_23 vpw_23 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_23 bl[0]_23 bl[1]_23 bl[2]_23 bl[3]_23 cored00_80 cored01_82
+  cored10_84 cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_23
+  nbl[1]_23 nbl[2]_23 nbl[3]_23 ncored00_96 ncored01_98 ncored10_100
+  ncored11_102 ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_23
+  vddce_23 vddpe_23 vnwc_24 vpw_24 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_24 bl[0]_24 bl[1]_24 bl[2]_24 bl[3]_24 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_24 nbl[1]_24 nbl[2]_24 nbl[3]_24 ncored00_128 ncored01_130
+  ncored10_132 ncored11_134 ncored20_136 ncored21_138 ncored30_140
+  ncored31_142 vddc_24 vddce_24 vddpe_24 vnwc_25 vpw_25 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_25 bl[0]_25 bl[1]_25 bl[2]_25 bl[3]_25 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_25 nbl[1]_25 nbl[2]_25 nbl[3]_25 ncored00_160 ncored01_162
+  ncored10_164 ncored11_166 ncored20_168 ncored21_170 ncored30_172
+  ncored31_174 vddc_25 vddce_25 vddpe_25 vnwc_26 vpw_26 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_26 bl[0]_26 bl[1]_26 bl[2]_26 bl[3]_26 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_26 nbl[1]_26 nbl[2]_26 nbl[3]_26 ncored00_192 ncored01_194
+  ncored10_196 ncored11_198 ncored20_200 ncored21_202 ncored30_204
+  ncored31_206 vddc_26 vddce_26 vddpe_26 vnwc_27 vpw_27 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_27 bl[0]_27 bl[1]_27 bl[2]_27 bl[3]_27 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_27 nbl[1]_27 nbl[2]_27 nbl[3]_27 ncored00_224 ncored01_226
+  ncored10_228 ncored11_230 ncored20_232 ncored21_234 ncored30_236
+  ncored31_238 vddc_27 vddce_27 vddpe_27 vnwc_28 vpw_28 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_28 bl[0]_28 bl[1]_28 bl[2]_28 bl[3]_28 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_28 nbl[1]_28 nbl[2]_28 nbl[3]_28 ncored00_256 ncored01_258
+  ncored10_260 ncored11_262 ncored20_264 ncored21_266 ncored30_268
+  ncored31_270 vddc_28 vddce_28 vddpe_28 vnwc_29 vpw_29 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_29 bl[0]_29 bl[1]_29 bl[2]_29 bl[3]_29 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_29 nbl[1]_29 nbl[2]_29 nbl[3]_29 ncored00_288 ncored01_290
+  ncored10_292 ncored11_294 ncored20_296 ncored21_298 ncored30_300
+  ncored31_302 vddc_29 vddce_29 vddpe_29 vnwc_30 vpw_30 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_368 cored01_370
+  cored10_372 cored11_374 cored20_376 cored21_378 cored30_380 cored31_382
+  nbl[0]_3 nbl[1]_3 nbl[2]_3 nbl[3]_3 ncored00_384 ncored01_386 ncored10_388
+  ncored11_390 ncored20_392 ncored21_394 ncored30_396 ncored31_398 vddc_3
+  vddce_3 vddpe_3 vnwc_4 vpw_4 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_30 bl[0]_30 bl[1]_30 bl[2]_30 bl[3]_30 cored00_688 cored01_690
+  cored10_692 cored11_694 cored20_696 cored21_698 cored30_700 cored31_702
+  nbl[0]_30 nbl[1]_30 nbl[2]_30 nbl[3]_30 ncored00_704 ncored01_706
+  ncored10_708 ncored11_710 ncored20_712 ncored21_714 ncored30_716
+  ncored31_718 vddc_30 vddce_30 vddpe_30 vnwc_31 vpw_31 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_400 cored01_402
+  cored10_404 cored11_406 cored20_408 cored21_410 cored30_412 cored31_414
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_416 ncored01_418 ncored10_420
+  ncored11_422 ncored20_424 ncored21_426 ncored30_428 ncored31_430 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_432 cored01_434
+  cored10_436 cored11_438 cored20_440 cored21_442 cored30_444 cored31_446
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_448 ncored01_450 ncored10_452
+  ncored11_454 ncored20_456 ncored21_458 ncored30_460 ncored31_462 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_464 cored01_466
+  cored10_468 cored11_470 cored20_472 cored21_474 cored30_476 cored31_478
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_480 ncored01_482 ncored10_484
+  ncored11_486 ncored20_488 ncored21_490 ncored30_492 ncored31_494 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_496 cored01_498
+  cored10_500 cored11_502 cored20_504 cored21_506 cored30_508 cored31_510
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_512 ncored01_514 ncored10_516
+  ncored11_518 ncored20_520 ncored21_522 ncored30_524 ncored31_526 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_528 cored01_530
+  cored10_532 cored11_534 cored20_536 cored21_538 cored30_540 cored31_542
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_544 ncored01_546 ncored10_548
+  ncored11_550 ncored20_552 ncored21_554 ncored30_556 ncored31_558 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_560 cored01_562
+  cored10_564 cored11_566 cored20_568 cored21_570 cored30_572 cored31_574
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_576 ncored01_578 ncored10_580
+  ncored11_582 ncored20_584 ncored21_586 ncored30_588 ncored31_590 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_bot_l bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00_944 cored01_946
+  cored10_948 cored11_950 cored20_952 cored21_954 cored30_956 cored31_958
+  nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0 ncored00_960 ncored01_962 ncored10_964
+  ncored11_966 ncored20_968 ncored21_970 ncored30_972 ncored31_974 vddc_0
+  vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vsse_0 wl[0] wl[1] rf64x128cchs4
xmem_l_col_bot_r bl[0]_31 bl[1]_31 bl[2]_31 bl[3]_31 cored00_976 cored01_978
+  cored10_980 cored11_982 cored20_984 cored21_986 cored30_988 cored31_990
+  nbl[0]_31 nbl[1]_31 nbl[2]_31 nbl[3]_31 ncored00_992 ncored01_994
+  ncored10_996 ncored11_998 ncored20_1000 ncored21_1002 ncored30_1004
+  ncored31_1006 vddc_31 vddce_31 vddpe_31 vnwc_32 vpw_32 vssc vsse_1 wl[0]
+  wl[1] rf64x128cchs4
xmem_l_col_edger dbl dwl vddc_32 vnwc_33 vnwp_1 vpw_33 vssc wl[0] wl[1]
+  rf64x128cchs4wd_edgbl_dummy
.ends rf64x128mem_l_bot_row
****
.subckt rf64x128mem_l_test1row vddc_32 vpw_33 vddc_31 vnwc_32 bl[2]_31
+  nbl[2]_31 nbl[3]_31 bl[3]_31 bl[1]_30 vddpe_30 bl[2]_30 nbl[2]_30 nbl[3]_30
+  bl[1]_29 vddpe_29 bl[2]_29 nbl[2]_29 bl[1]_28 vddpe_28 bl[2]_28 nbl[2]_28
+  bl[1]_27 vddpe_27 bl[2]_27 nbl[2]_27 bl[0]_26 bl[1]_26 vddpe_26 nbl[2]_26
+  nbl[3]_26 bl[0]_25 bl[1]_25 vddpe_25 vddce_25 vnwc_26 vssc nbl[2]_25
+  nbl[3]_25 bl[0]_24 nbl[0]_24 nbl[1]_24 bl[1]_24 vddpe_24 vddce_24 vnwc_25
+  vpw_25 bl[2]_24 nbl[2]_24 nbl[3]_24 bl[0]_23 nbl[0]_23 nbl[1]_23 bl[1]_23
+  vddpe_23 vddce_23 vnwc_24 vpw_24 bl[2]_23 nbl[2]_23 bl[0]_22 nbl[0]_22
+  nbl[1]_22 bl[1]_22 vddpe_22 vddce_22 vnwc_23 vpw_23 bl[2]_22 nbl[2]_22
+  bl[0]_21 nbl[0]_21 nbl[1]_21 bl[1]_21 vddpe_21 vddce_21 vddc_21 vnwc_22
+  vpw_22 bl[2]_21 nbl[2]_21 bl[0]_20 nbl[0]_20 nbl[1]_20 bl[1]_20 vddpe_20
+  vddce_20 vddc_20 vnwc_21 vpw_21 nbl[2]_20 bl[0]_19 nbl[0]_19 nbl[1]_19
+  bl[1]_19 vddpe_19 vddce_19 vddc_19 vnwc_20 vpw_20 bl[0]_18 nbl[0]_18
+  nbl[1]_18 bl[1]_18 vddpe_18 vddce_18 vnwc_19 vpw_19 bl[2]_18 nbl[2]_18
+  bl[0]_17 nbl[0]_17 nbl[1]_17 bl[1]_17 vddpe_17 vddce_17 vnwc_18 vpw_18
+  bl[2]_17 nbl[2]_17 bl[0]_16 nbl[0]_16 nbl[1]_16 bl[1]_16 vddpe_16 vddce_16
+  vddc_16 vnwc_17 vpw_17 bl[2]_16 nbl[2]_16 bl[0]_15 nbl[0]_15 nbl[1]_15
+  bl[1]_15 vddpe_15 vddce_15 vddc_15 vnwc_16 vpw_16 nbl[2]_15 bl[0]_14
+  nbl[0]_14 nbl[1]_14 bl[1]_14 vddpe_14 vddce_14 vddc_14 vnwc_15 vpw_15
+  nbl[2]_14 bl[0]_13 nbl[0]_13 nbl[1]_13 bl[1]_13 vddpe_13 vddce_13 vddc_13
+  vnwc_14 vpw_14 bl[0]_12 nbl[0]_12 nbl[1]_12 bl[1]_12 vddpe_12 vddce_12
+  vddc_12 vnwc_13 vpw_13 bl[0]_11 nbl[0]_11 nbl[1]_11 bl[1]_11 vddpe_11
+  vddce_11 vddc_11 vnwc_12 vpw_12 bl[2]_11 nbl[2]_11 bl[0]_10 nbl[0]_10
+  nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vddc_10 vnwc_11 vpw_11 nbl[2]_10
+  bl[0]_9 nbl[0]_9 nbl[1]_9 bl[1]_9 vddpe_9 vddce_9 vddc_9 vnwc_10 vpw_10
+  nbl[2]_9 bl[0]_8 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 vddce_8 vddc_8 vnwc_9
+  vpw_9 bl[0]_7 nbl[0]_7 nbl[1]_7 bl[1]_7 vddpe_7 vddce_7 vddc_7 vnwc_8 vpw_8
+  bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddpe_6 vddce_6 vddc_6 vnwc_7 vpw_7
+  bl[3]_6 bl[0]_5 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe_5 vddce_5 vddc_5 vnwc_6
+  vpw_6 nbl[2]_5 bl[0]_4 nbl[0]_4 nbl[1]_4 bl[1]_4 vddpe_4 vddce_4 vddc_4
+  vnwc_5 vpw_5 nbl[2]_4 bl[0]_3 nbl[0]_3 nbl[1]_3 bl[1]_3 vddpe_3 vddce_3
+  vddc_3 vnwc_4 vpw_4 bl[0]_2 nbl[0]_2 nbl[1]_2 bl[1]_2 vddpe_2 vddce_2
+  vddc_2 vnwc_3 vpw_3 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddpe_1 vddce_1
+  vddc_1 vnwc_2 vpw_2 bl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe_0
+  vddce_0 vddc_0 vnwc_1 vpw_1 bl[3]_0 vnwc_0 vpw_0 vnwc_33 vnwp_1 dbl dwl
+  bl[0]_31 nbl[0]_31 nbl[1]_31 bl[1]_31 vddpe_31 vddce_31 vpw_32 bl[0]_30
+  nbl[0]_30 nbl[1]_30 vddce_30 vddc_30 vnwc_31 vpw_31 bl[3]_30 bl[0]_29
+  nbl[0]_29 nbl[1]_29 vddce_29 vddc_29 vnwc_30 vpw_30 nbl[3]_29 bl[3]_29
+  bl[0]_28 nbl[0]_28 nbl[1]_28 vddce_28 vddc_28 vnwc_29 vpw_29 nbl[3]_28
+  bl[3]_28 bl[0]_27 nbl[0]_27 nbl[1]_27 vddce_27 vddc_27 vnwc_28 vpw_28
+  nbl[3]_27 bl[3]_27 nbl[0]_26 nbl[1]_26 vddce_26 vddc_26 vnwc_27 vpw_27
+  bl[2]_26 bl[3]_26 nbl[0]_25 nbl[1]_25 vddc_25 vpw_26 bl[2]_25 bl[3]_25
+  vddc_24 bl[3]_24 vddc_23 nbl[3]_23 bl[3]_23 vddc_22 nbl[3]_22 bl[3]_22
+  nbl[3]_21 bl[3]_21 bl[2]_20 nbl[3]_20 bl[3]_20 bl[2]_19 nbl[2]_19 nbl[3]_19
+  bl[3]_19 vddc_18 nbl[3]_18 bl[3]_18 vddc_17 nbl[3]_17 bl[3]_17 nbl[3]_16
+  bl[3]_16 bl[2]_15 nbl[3]_15 bl[3]_15 bl[2]_14 nbl[3]_14 bl[3]_14 bl[2]_13
+  nbl[2]_13 nbl[3]_13 bl[3]_13 bl[2]_12 nbl[2]_12 nbl[3]_12 bl[3]_12
+  nbl[3]_11 bl[3]_11 bl[2]_10 nbl[3]_10 bl[3]_10 bl[2]_9 nbl[3]_9 bl[3]_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[2]_6
+  nbl[2]_6 nbl[3]_6 bl[2]_5 nbl[3]_5 bl[3]_5 bl[2]_4 nbl[3]_4 bl[3]_4 bl[2]_3
+  nbl[2]_3 nbl[3]_3 bl[3]_3 bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[2]_1
+  nbl[2]_1 nbl[3]_1 bl[2]_0 nbl[2]_0 nbl[3]_0 vnwp_0 wl[0] wl[1]
** rf64x128mem_l_test1row: 1548 flat devices **
xmem_l_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0 ncored00_320 ncored01_322 ncored10_324
+  ncored11_326 ncored20_328 ncored21_330 ncored30_332 ncored31_334 vddc_0
+  vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_1 nbl[1]_1 nbl[2]_1 nbl[3]_1 ncored00_352 ncored01_354 ncored10_356
+  ncored11_358 ncored20_360 ncored21_362 ncored30_364 ncored31_366 vddc_1
+  vddce_1 vddpe_1 vnwc_2 vpw_2 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_624 cored01_626
+  cored10_628 cored11_630 cored20_632 cored21_634 cored30_636 cored31_638
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_640 ncored01_642
+  ncored10_644 ncored11_646 ncored20_648 ncored21_650 ncored30_652
+  ncored31_654 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_656 cored01_658
+  cored10_660 cored11_662 cored20_664 cored21_666 cored30_668 cored31_670
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_672 ncored01_674
+  ncored10_676 ncored11_678 ncored20_680 ncored21_682 ncored30_684
+  ncored31_686 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_12 bl[0]_12 bl[1]_12 bl[2]_12 bl[3]_12 cored00_688 cored01_690
+  cored10_692 cored11_694 cored20_696 cored21_698 cored30_700 cored31_702
+  nbl[0]_12 nbl[1]_12 nbl[2]_12 nbl[3]_12 ncored00_704 ncored01_706
+  ncored10_708 ncored11_710 ncored20_712 ncored21_714 ncored30_716
+  ncored31_718 vddc_12 vddce_12 vddpe_12 vnwc_13 vpw_13 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_13 bl[0]_13 bl[1]_13 bl[2]_13 bl[3]_13 cored00_752 cored01_754
+  cored10_756 cored11_758 cored20_760 cored21_762 cored30_764 cored31_766
+  nbl[0]_13 nbl[1]_13 nbl[2]_13 nbl[3]_13 ncored00_768 ncored01_770
+  ncored10_772 ncored11_774 ncored20_776 ncored21_778 ncored30_780
+  ncored31_782 vddc_13 vddce_13 vddpe_13 vnwc_14 vpw_14 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_14 bl[0]_14 bl[1]_14 bl[2]_14 bl[3]_14 cored00_816 cored01_818
+  cored10_820 cored11_822 cored20_824 cored21_826 cored30_828 cored31_830
+  nbl[0]_14 nbl[1]_14 nbl[2]_14 nbl[3]_14 ncored00_832 ncored01_834
+  ncored10_836 ncored11_838 ncored20_840 ncored21_842 ncored30_844
+  ncored31_846 vddc_14 vddce_14 vddpe_14 vnwc_15 vpw_15 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_15 bl[0]_15 bl[1]_15 bl[2]_15 bl[3]_15 cored00_848 cored01_850
+  cored10_852 cored11_854 cored20_856 cored21_858 cored30_860 cored31_862
+  nbl[0]_15 nbl[1]_15 nbl[2]_15 nbl[3]_15 ncored00_864 ncored01_866
+  ncored10_868 ncored11_870 ncored20_872 ncored21_874 ncored30_876
+  ncored31_878 vddc_15 vddce_15 vddpe_15 vnwc_16 vpw_16 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_16 bl[0]_16 bl[1]_16 bl[2]_16 bl[3]_16 cored00_880 cored01_882
+  cored10_884 cored11_886 cored20_888 cored21_890 cored30_892 cored31_894
+  nbl[0]_16 nbl[1]_16 nbl[2]_16 nbl[3]_16 ncored00_896 ncored01_898
+  ncored10_900 ncored11_902 ncored20_904 ncored21_906 ncored30_908
+  ncored31_910 vddc_16 vddce_16 vddpe_16 vnwc_17 vpw_17 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_17 bl[0]_17 bl[1]_17 bl[2]_17 bl[3]_17 cored00_912 cored01_914
+  cored10_916 cored11_918 cored20_920 cored21_922 cored30_924 cored31_926
+  nbl[0]_17 nbl[1]_17 nbl[2]_17 nbl[3]_17 ncored00_928 ncored01_930
+  ncored10_932 ncored11_934 ncored20_936 ncored21_938 ncored30_940
+  ncored31_942 vddc_17 vddce_17 vddpe_17 vnwc_18 vpw_18 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_18 bl[0]_18 bl[1]_18 bl[2]_18 bl[3]_18 cored00_944 cored01_946
+  cored10_948 cored11_950 cored20_952 cored21_954 cored30_956 cored31_958
+  nbl[0]_18 nbl[1]_18 nbl[2]_18 nbl[3]_18 ncored00_960 ncored01_962
+  ncored10_964 ncored11_966 ncored20_968 ncored21_970 ncored30_972
+  ncored31_974 vddc_18 vddce_18 vddpe_18 vnwc_19 vpw_19 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_19 bl[0]_19 bl[1]_19 bl[2]_19 bl[3]_19 cored00_976 cored01_978
+  cored10_980 cored11_982 cored20_984 cored21_986 cored30_988 cored31_990
+  nbl[0]_19 nbl[1]_19 nbl[2]_19 nbl[3]_19 ncored00_992 ncored01_994
+  ncored10_996 ncored11_998 ncored20_1000 ncored21_1002 ncored30_1004
+  ncored31_1006 vddc_19 vddce_19 vddpe_19 vnwc_20 vpw_20 vssc vssc wl[1]
+  wl[0] rf64x128cchs4
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_368 cored01_370
+  cored10_372 cored11_374 cored20_376 cored21_378 cored30_380 cored31_382
+  nbl[0]_2 nbl[1]_2 nbl[2]_2 nbl[3]_2 ncored00_384 ncored01_386 ncored10_388
+  ncored11_390 ncored20_392 ncored21_394 ncored30_396 ncored31_398 vddc_2
+  vddce_2 vddpe_2 vnwc_3 vpw_3 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_20 bl[0]_20 bl[1]_20 bl[2]_20 bl[3]_20 cored00 cored01 cored10
+  cored11 cored20 cored21 cored30 cored31 nbl[0]_20 nbl[1]_20 nbl[2]_20
+  nbl[3]_20 ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30
+  ncored31 vddc_20 vddce_20 vddpe_20 vnwc_21 vpw_21 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_21 bl[0]_21 bl[1]_21 bl[2]_21 bl[3]_21 cored00_16 cored01_18
+  cored10_20 cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_21
+  nbl[1]_21 nbl[2]_21 nbl[3]_21 ncored00_32 ncored01_34 ncored10_36
+  ncored11_38 ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_21
+  vddce_21 vddpe_21 vnwc_22 vpw_22 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_22 bl[0]_22 bl[1]_22 bl[2]_22 bl[3]_22 cored00_48 cored01_50
+  cored10_52 cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_22
+  nbl[1]_22 nbl[2]_22 nbl[3]_22 ncored00_64 ncored01_66 ncored10_68
+  ncored11_70 ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_22
+  vddce_22 vddpe_22 vnwc_23 vpw_23 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_23 bl[0]_23 bl[1]_23 bl[2]_23 bl[3]_23 cored00_80 cored01_82
+  cored10_84 cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_23
+  nbl[1]_23 nbl[2]_23 nbl[3]_23 ncored00_96 ncored01_98 ncored10_100
+  ncored11_102 ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_23
+  vddce_23 vddpe_23 vnwc_24 vpw_24 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_24 bl[0]_24 bl[1]_24 bl[2]_24 bl[3]_24 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_24 nbl[1]_24 nbl[2]_24 nbl[3]_24 ncored00_128 ncored01_130
+  ncored10_132 ncored11_134 ncored20_136 ncored21_138 ncored30_140
+  ncored31_142 vddc_24 vddce_24 vddpe_24 vnwc_25 vpw_25 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_25 bl[0]_25 bl[1]_25 bl[2]_25 bl[3]_25 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_25 nbl[1]_25 nbl[2]_25 nbl[3]_25 ncored00_160 ncored01_162
+  ncored10_164 ncored11_166 ncored20_168 ncored21_170 ncored30_172
+  ncored31_174 vddc_25 vddce_25 vddpe_25 vnwc_26 vpw_26 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_26 bl[0]_26 bl[1]_26 bl[2]_26 bl[3]_26 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_26 nbl[1]_26 nbl[2]_26 nbl[3]_26 ncored00_192 ncored01_194
+  ncored10_196 ncored11_198 ncored20_200 ncored21_202 ncored30_204
+  ncored31_206 vddc_26 vddce_26 vddpe_26 vnwc_27 vpw_27 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_27 bl[0]_27 bl[1]_27 bl[2]_27 bl[3]_27 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_27 nbl[1]_27 nbl[2]_27 nbl[3]_27 ncored00_224 ncored01_226
+  ncored10_228 ncored11_230 ncored20_232 ncored21_234 ncored30_236
+  ncored31_238 vddc_27 vddce_27 vddpe_27 vnwc_28 vpw_28 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_28 bl[0]_28 bl[1]_28 bl[2]_28 bl[3]_28 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_28 nbl[1]_28 nbl[2]_28 nbl[3]_28 ncored00_256 ncored01_258
+  ncored10_260 ncored11_262 ncored20_264 ncored21_266 ncored30_268
+  ncored31_270 vddc_28 vddce_28 vddpe_28 vnwc_29 vpw_29 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_29 bl[0]_29 bl[1]_29 bl[2]_29 bl[3]_29 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_29 nbl[1]_29 nbl[2]_29 nbl[3]_29 ncored00_288 ncored01_290
+  ncored10_292 ncored11_294 ncored20_296 ncored21_298 ncored30_300
+  ncored31_302 vddc_29 vddce_29 vddpe_29 vnwc_30 vpw_30 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_400 cored01_402
+  cored10_404 cored11_406 cored20_408 cored21_410 cored30_412 cored31_414
+  nbl[0]_3 nbl[1]_3 nbl[2]_3 nbl[3]_3 ncored00_416 ncored01_418 ncored10_420
+  ncored11_422 ncored20_424 ncored21_426 ncored30_428 ncored31_430 vddc_3
+  vddce_3 vddpe_3 vnwc_4 vpw_4 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_30 bl[0]_30 bl[1]_30 bl[2]_30 bl[3]_30 cored00_720 cored01_722
+  cored10_724 cored11_726 cored20_728 cored21_730 cored30_732 cored31_734
+  nbl[0]_30 nbl[1]_30 nbl[2]_30 nbl[3]_30 ncored00_736 ncored01_738
+  ncored10_740 ncored11_742 ncored20_744 ncored21_746 ncored30_748
+  ncored31_750 vddc_30 vddce_30 vddpe_30 vnwc_31 vpw_31 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_31 bl[0]_31 bl[1]_31 bl[2]_31 bl[3]_31 cored00_784 cored01_786
+  cored10_788 cored11_790 cored20_792 cored21_794 cored30_796 cored31_798
+  nbl[0]_31 nbl[1]_31 nbl[2]_31 nbl[3]_31 ncored00_800 ncored01_802
+  ncored10_804 ncored11_806 ncored20_808 ncored21_810 ncored30_812
+  ncored31_814 vddc_31 vddce_31 vddpe_31 vnwc_32 vpw_32 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_432 cored01_434
+  cored10_436 cored11_438 cored20_440 cored21_442 cored30_444 cored31_446
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_448 ncored01_450 ncored10_452
+  ncored11_454 ncored20_456 ncored21_458 ncored30_460 ncored31_462 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_464 cored01_466
+  cored10_468 cored11_470 cored20_472 cored21_474 cored30_476 cored31_478
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_480 ncored01_482 ncored10_484
+  ncored11_486 ncored20_488 ncored21_490 ncored30_492 ncored31_494 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_496 cored01_498
+  cored10_500 cored11_502 cored20_504 cored21_506 cored30_508 cored31_510
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_512 ncored01_514 ncored10_516
+  ncored11_518 ncored20_520 ncored21_522 ncored30_524 ncored31_526 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_528 cored01_530
+  cored10_532 cored11_534 cored20_536 cored21_538 cored30_540 cored31_542
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_544 ncored01_546 ncored10_548
+  ncored11_550 ncored20_552 ncored21_554 ncored30_556 ncored31_558 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_560 cored01_562
+  cored10_564 cored11_566 cored20_568 cored21_570 cored30_572 cored31_574
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_576 ncored01_578 ncored10_580
+  ncored11_582 ncored20_584 ncored21_586 ncored30_588 ncored31_590 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_592 cored01_594
+  cored10_596 cored11_598 cored20_600 cored21_602 cored30_604 cored31_606
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_608 ncored01_610 ncored10_612
+  ncored11_614 ncored20_616 ncored21_618 ncored30_620 ncored31_622 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_edger dbl dwl vddc_32 vnwc_33 vnwp_1 vpw_33 vssc wl[0] wl[1]
+  rf64x128cchs4wd_edgbl_dummy
.ends rf64x128mem_l_test1row
****
.subckt rf64x128mem_l_test2row vddc_32 vnwc_33 dbl dwl vnwc_32 bl[2]_31
+  nbl[2]_31 nbl[3]_31 bl[3]_31 bl[1]_30 vddpe_30 bl[2]_30 nbl[2]_30 nbl[3]_30
+  bl[1]_29 vddpe_29 bl[2]_29 nbl[2]_29 bl[1]_28 vddpe_28 bl[2]_28 nbl[2]_28
+  bl[1]_27 vddpe_27 bl[2]_27 nbl[2]_27 bl[0]_26 bl[1]_26 vddpe_26 nbl[2]_26
+  nbl[3]_26 bl[0]_25 bl[1]_25 vddpe_25 vddce_25 vnwc_26 vssc nbl[2]_25
+  nbl[3]_25 bl[0]_24 nbl[0]_24 nbl[1]_24 bl[1]_24 vddpe_24 vddce_24 vnwc_25
+  vpw_25 bl[2]_24 nbl[2]_24 nbl[3]_24 bl[0]_23 nbl[0]_23 nbl[1]_23 bl[1]_23
+  vddpe_23 vddce_23 vnwc_24 vpw_24 bl[2]_23 nbl[2]_23 bl[0]_22 nbl[0]_22
+  nbl[1]_22 bl[1]_22 vddpe_22 vddce_22 vnwc_23 vpw_23 bl[2]_22 nbl[2]_22
+  bl[0]_21 nbl[0]_21 nbl[1]_21 bl[1]_21 vddpe_21 vddce_21 vddc_21 vnwc_22
+  vpw_22 bl[2]_21 nbl[2]_21 bl[0]_20 nbl[0]_20 nbl[1]_20 bl[1]_20 vddpe_20
+  vddce_20 vddc_20 vnwc_21 vpw_21 nbl[2]_20 bl[0]_19 nbl[0]_19 nbl[1]_19
+  bl[1]_19 vddpe_19 vddce_19 vddc_19 vnwc_20 vpw_20 bl[0]_18 nbl[0]_18
+  nbl[1]_18 bl[1]_18 vddpe_18 vddce_18 vnwc_19 vpw_19 bl[2]_18 nbl[2]_18
+  bl[0]_17 nbl[0]_17 nbl[1]_17 bl[1]_17 vddpe_17 vddce_17 vnwc_18 vpw_18
+  bl[2]_17 nbl[2]_17 bl[0]_16 nbl[0]_16 nbl[1]_16 bl[1]_16 vddpe_16 vddce_16
+  vddc_16 vnwc_17 vpw_17 bl[2]_16 nbl[2]_16 bl[0]_15 nbl[0]_15 nbl[1]_15
+  bl[1]_15 vddpe_15 vddce_15 vddc_15 vnwc_16 vpw_16 nbl[2]_15 bl[0]_14
+  nbl[0]_14 nbl[1]_14 bl[1]_14 vddpe_14 vddce_14 vddc_14 vnwc_15 vpw_15
+  nbl[2]_14 bl[0]_13 nbl[0]_13 nbl[1]_13 bl[1]_13 vddpe_13 vddce_13 vddc_13
+  vnwc_14 vpw_14 bl[0]_12 nbl[0]_12 nbl[1]_12 bl[1]_12 vddpe_12 vddce_12
+  vddc_12 vnwc_13 vpw_13 bl[0]_11 nbl[0]_11 nbl[1]_11 bl[1]_11 vddpe_11
+  vddce_11 vddc_11 vnwc_12 vpw_12 bl[2]_11 nbl[2]_11 bl[0]_10 nbl[0]_10
+  nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vddc_10 vnwc_11 vpw_11 nbl[2]_10
+  bl[0]_9 nbl[0]_9 nbl[1]_9 bl[1]_9 vddpe_9 vddce_9 vddc_9 vnwc_10 vpw_10
+  nbl[2]_9 bl[0]_8 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 vddce_8 vddc_8 vnwc_9
+  vpw_9 bl[0]_7 nbl[0]_7 nbl[1]_7 bl[1]_7 vddpe_7 vddce_7 vddc_7 vnwc_8 vpw_8
+  bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddpe_6 vddce_6 vddc_6 vnwc_7 vpw_7
+  bl[3]_6 bl[0]_5 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe_5 vddce_5 vddc_5 vnwc_6
+  vpw_6 nbl[2]_5 bl[0]_4 nbl[0]_4 nbl[1]_4 bl[1]_4 vddpe_4 vddce_4 vddc_4
+  vnwc_5 vpw_5 nbl[2]_4 bl[0]_3 nbl[0]_3 nbl[1]_3 bl[1]_3 vddpe_3 vddce_3
+  vddc_3 vnwc_4 vpw_4 bl[0]_2 nbl[0]_2 nbl[1]_2 bl[1]_2 vddpe_2 vddce_2
+  vddc_2 vnwc_3 vpw_3 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddpe_1 vddce_1
+  vddc_1 vnwc_2 vpw_2 bl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe_0
+  vddce_0 vddc_0 vnwc_1 vpw_1 bl[3]_0 vnwp_0 vnwc_0 vpw_0 vpw_33 vnwp_1
+  bl[0]_31 nbl[0]_31 nbl[1]_31 bl[1]_31 vddpe_31 vddce_31 vddc_31 vpw_32
+  bl[0]_30 nbl[0]_30 nbl[1]_30 vddce_30 vddc_30 vnwc_31 vpw_31 bl[3]_30
+  bl[0]_29 nbl[0]_29 nbl[1]_29 vddce_29 vddc_29 vnwc_30 vpw_30 nbl[3]_29
+  bl[3]_29 bl[0]_28 nbl[0]_28 nbl[1]_28 vddce_28 vddc_28 vnwc_29 vpw_29
+  nbl[3]_28 bl[3]_28 bl[0]_27 nbl[0]_27 nbl[1]_27 vddce_27 vddc_27 vnwc_28
+  vpw_28 nbl[3]_27 bl[3]_27 nbl[0]_26 nbl[1]_26 vddce_26 vddc_26 vnwc_27
+  vpw_27 bl[2]_26 bl[3]_26 nbl[0]_25 nbl[1]_25 vddc_25 vpw_26 bl[2]_25
+  bl[3]_25 vddc_24 bl[3]_24 vddc_23 nbl[3]_23 bl[3]_23 vddc_22 nbl[3]_22
+  bl[3]_22 nbl[3]_21 bl[3]_21 bl[2]_20 nbl[3]_20 bl[3]_20 bl[2]_19 nbl[2]_19
+  nbl[3]_19 bl[3]_19 vddc_18 nbl[3]_18 bl[3]_18 vddc_17 nbl[3]_17 bl[3]_17
+  nbl[3]_16 bl[3]_16 bl[2]_15 nbl[3]_15 bl[3]_15 bl[2]_14 nbl[3]_14 bl[3]_14
+  bl[2]_13 nbl[2]_13 nbl[3]_13 bl[3]_13 bl[2]_12 nbl[2]_12 nbl[3]_12 bl[3]_12
+  nbl[3]_11 bl[3]_11 bl[2]_10 nbl[3]_10 bl[3]_10 bl[2]_9 nbl[3]_9 bl[3]_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[2]_6
+  nbl[2]_6 nbl[3]_6 bl[2]_5 nbl[3]_5 bl[3]_5 bl[2]_4 nbl[3]_4 bl[3]_4 bl[2]_3
+  nbl[2]_3 nbl[3]_3 bl[3]_3 bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[2]_1
+  nbl[2]_1 nbl[3]_1 bl[2]_0 nbl[2]_0 nbl[3]_0 wl[1] wl[0]
** rf64x128mem_l_test2row: 1548 flat devices **
xmem_l_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0 ncored00_320 ncored01_322 ncored10_324
+  ncored11_326 ncored20_328 ncored21_330 ncored30_332 ncored31_334 vddc_0
+  vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_1 nbl[1]_1 nbl[2]_1 nbl[3]_1 ncored00_352 ncored01_354 ncored10_356
+  ncored11_358 ncored20_360 ncored21_362 ncored30_364 ncored31_366 vddc_1
+  vddce_1 vddpe_1 vnwc_2 vpw_2 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_624 cored01_626
+  cored10_628 cored11_630 cored20_632 cored21_634 cored30_636 cored31_638
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_640 ncored01_642
+  ncored10_644 ncored11_646 ncored20_648 ncored21_650 ncored30_652
+  ncored31_654 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_656 cored01_658
+  cored10_660 cored11_662 cored20_664 cored21_666 cored30_668 cored31_670
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_672 ncored01_674
+  ncored10_676 ncored11_678 ncored20_680 ncored21_682 ncored30_684
+  ncored31_686 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_12 bl[0]_12 bl[1]_12 bl[2]_12 bl[3]_12 cored00_688 cored01_690
+  cored10_692 cored11_694 cored20_696 cored21_698 cored30_700 cored31_702
+  nbl[0]_12 nbl[1]_12 nbl[2]_12 nbl[3]_12 ncored00_704 ncored01_706
+  ncored10_708 ncored11_710 ncored20_712 ncored21_714 ncored30_716
+  ncored31_718 vddc_12 vddce_12 vddpe_12 vnwc_13 vpw_13 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_13 bl[0]_13 bl[1]_13 bl[2]_13 bl[3]_13 cored00_752 cored01_754
+  cored10_756 cored11_758 cored20_760 cored21_762 cored30_764 cored31_766
+  nbl[0]_13 nbl[1]_13 nbl[2]_13 nbl[3]_13 ncored00_768 ncored01_770
+  ncored10_772 ncored11_774 ncored20_776 ncored21_778 ncored30_780
+  ncored31_782 vddc_13 vddce_13 vddpe_13 vnwc_14 vpw_14 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_14 bl[0]_14 bl[1]_14 bl[2]_14 bl[3]_14 cored00_816 cored01_818
+  cored10_820 cored11_822 cored20_824 cored21_826 cored30_828 cored31_830
+  nbl[0]_14 nbl[1]_14 nbl[2]_14 nbl[3]_14 ncored00_832 ncored01_834
+  ncored10_836 ncored11_838 ncored20_840 ncored21_842 ncored30_844
+  ncored31_846 vddc_14 vddce_14 vddpe_14 vnwc_15 vpw_15 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_15 bl[0]_15 bl[1]_15 bl[2]_15 bl[3]_15 cored00_848 cored01_850
+  cored10_852 cored11_854 cored20_856 cored21_858 cored30_860 cored31_862
+  nbl[0]_15 nbl[1]_15 nbl[2]_15 nbl[3]_15 ncored00_864 ncored01_866
+  ncored10_868 ncored11_870 ncored20_872 ncored21_874 ncored30_876
+  ncored31_878 vddc_15 vddce_15 vddpe_15 vnwc_16 vpw_16 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_16 bl[0]_16 bl[1]_16 bl[2]_16 bl[3]_16 cored00_880 cored01_882
+  cored10_884 cored11_886 cored20_888 cored21_890 cored30_892 cored31_894
+  nbl[0]_16 nbl[1]_16 nbl[2]_16 nbl[3]_16 ncored00_896 ncored01_898
+  ncored10_900 ncored11_902 ncored20_904 ncored21_906 ncored30_908
+  ncored31_910 vddc_16 vddce_16 vddpe_16 vnwc_17 vpw_17 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_17 bl[0]_17 bl[1]_17 bl[2]_17 bl[3]_17 cored00_912 cored01_914
+  cored10_916 cored11_918 cored20_920 cored21_922 cored30_924 cored31_926
+  nbl[0]_17 nbl[1]_17 nbl[2]_17 nbl[3]_17 ncored00_928 ncored01_930
+  ncored10_932 ncored11_934 ncored20_936 ncored21_938 ncored30_940
+  ncored31_942 vddc_17 vddce_17 vddpe_17 vnwc_18 vpw_18 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_18 bl[0]_18 bl[1]_18 bl[2]_18 bl[3]_18 cored00_944 cored01_946
+  cored10_948 cored11_950 cored20_952 cored21_954 cored30_956 cored31_958
+  nbl[0]_18 nbl[1]_18 nbl[2]_18 nbl[3]_18 ncored00_960 ncored01_962
+  ncored10_964 ncored11_966 ncored20_968 ncored21_970 ncored30_972
+  ncored31_974 vddc_18 vddce_18 vddpe_18 vnwc_19 vpw_19 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_19 bl[0]_19 bl[1]_19 bl[2]_19 bl[3]_19 cored00_976 cored01_978
+  cored10_980 cored11_982 cored20_984 cored21_986 cored30_988 cored31_990
+  nbl[0]_19 nbl[1]_19 nbl[2]_19 nbl[3]_19 ncored00_992 ncored01_994
+  ncored10_996 ncored11_998 ncored20_1000 ncored21_1002 ncored30_1004
+  ncored31_1006 vddc_19 vddce_19 vddpe_19 vnwc_20 vpw_20 vssc vssc wl[0]
+  wl[1] rf64x128cchs4
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_368 cored01_370
+  cored10_372 cored11_374 cored20_376 cored21_378 cored30_380 cored31_382
+  nbl[0]_2 nbl[1]_2 nbl[2]_2 nbl[3]_2 ncored00_384 ncored01_386 ncored10_388
+  ncored11_390 ncored20_392 ncored21_394 ncored30_396 ncored31_398 vddc_2
+  vddce_2 vddpe_2 vnwc_3 vpw_3 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_20 bl[0]_20 bl[1]_20 bl[2]_20 bl[3]_20 cored00 cored01 cored10
+  cored11 cored20 cored21 cored30 cored31 nbl[0]_20 nbl[1]_20 nbl[2]_20
+  nbl[3]_20 ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30
+  ncored31 vddc_20 vddce_20 vddpe_20 vnwc_21 vpw_21 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_21 bl[0]_21 bl[1]_21 bl[2]_21 bl[3]_21 cored00_16 cored01_18
+  cored10_20 cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_21
+  nbl[1]_21 nbl[2]_21 nbl[3]_21 ncored00_32 ncored01_34 ncored10_36
+  ncored11_38 ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_21
+  vddce_21 vddpe_21 vnwc_22 vpw_22 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_22 bl[0]_22 bl[1]_22 bl[2]_22 bl[3]_22 cored00_48 cored01_50
+  cored10_52 cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_22
+  nbl[1]_22 nbl[2]_22 nbl[3]_22 ncored00_64 ncored01_66 ncored10_68
+  ncored11_70 ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_22
+  vddce_22 vddpe_22 vnwc_23 vpw_23 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_23 bl[0]_23 bl[1]_23 bl[2]_23 bl[3]_23 cored00_80 cored01_82
+  cored10_84 cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_23
+  nbl[1]_23 nbl[2]_23 nbl[3]_23 ncored00_96 ncored01_98 ncored10_100
+  ncored11_102 ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_23
+  vddce_23 vddpe_23 vnwc_24 vpw_24 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_24 bl[0]_24 bl[1]_24 bl[2]_24 bl[3]_24 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_24 nbl[1]_24 nbl[2]_24 nbl[3]_24 ncored00_128 ncored01_130
+  ncored10_132 ncored11_134 ncored20_136 ncored21_138 ncored30_140
+  ncored31_142 vddc_24 vddce_24 vddpe_24 vnwc_25 vpw_25 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_25 bl[0]_25 bl[1]_25 bl[2]_25 bl[3]_25 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_25 nbl[1]_25 nbl[2]_25 nbl[3]_25 ncored00_160 ncored01_162
+  ncored10_164 ncored11_166 ncored20_168 ncored21_170 ncored30_172
+  ncored31_174 vddc_25 vddce_25 vddpe_25 vnwc_26 vpw_26 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_26 bl[0]_26 bl[1]_26 bl[2]_26 bl[3]_26 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_26 nbl[1]_26 nbl[2]_26 nbl[3]_26 ncored00_192 ncored01_194
+  ncored10_196 ncored11_198 ncored20_200 ncored21_202 ncored30_204
+  ncored31_206 vddc_26 vddce_26 vddpe_26 vnwc_27 vpw_27 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_27 bl[0]_27 bl[1]_27 bl[2]_27 bl[3]_27 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_27 nbl[1]_27 nbl[2]_27 nbl[3]_27 ncored00_224 ncored01_226
+  ncored10_228 ncored11_230 ncored20_232 ncored21_234 ncored30_236
+  ncored31_238 vddc_27 vddce_27 vddpe_27 vnwc_28 vpw_28 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_28 bl[0]_28 bl[1]_28 bl[2]_28 bl[3]_28 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_28 nbl[1]_28 nbl[2]_28 nbl[3]_28 ncored00_256 ncored01_258
+  ncored10_260 ncored11_262 ncored20_264 ncored21_266 ncored30_268
+  ncored31_270 vddc_28 vddce_28 vddpe_28 vnwc_29 vpw_29 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_29 bl[0]_29 bl[1]_29 bl[2]_29 bl[3]_29 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_29 nbl[1]_29 nbl[2]_29 nbl[3]_29 ncored00_288 ncored01_290
+  ncored10_292 ncored11_294 ncored20_296 ncored21_298 ncored30_300
+  ncored31_302 vddc_29 vddce_29 vddpe_29 vnwc_30 vpw_30 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_400 cored01_402
+  cored10_404 cored11_406 cored20_408 cored21_410 cored30_412 cored31_414
+  nbl[0]_3 nbl[1]_3 nbl[2]_3 nbl[3]_3 ncored00_416 ncored01_418 ncored10_420
+  ncored11_422 ncored20_424 ncored21_426 ncored30_428 ncored31_430 vddc_3
+  vddce_3 vddpe_3 vnwc_4 vpw_4 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_30 bl[0]_30 bl[1]_30 bl[2]_30 bl[3]_30 cored00_720 cored01_722
+  cored10_724 cored11_726 cored20_728 cored21_730 cored30_732 cored31_734
+  nbl[0]_30 nbl[1]_30 nbl[2]_30 nbl[3]_30 ncored00_736 ncored01_738
+  ncored10_740 ncored11_742 ncored20_744 ncored21_746 ncored30_748
+  ncored31_750 vddc_30 vddce_30 vddpe_30 vnwc_31 vpw_31 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_31 bl[0]_31 bl[1]_31 bl[2]_31 bl[3]_31 cored00_784 cored01_786
+  cored10_788 cored11_790 cored20_792 cored21_794 cored30_796 cored31_798
+  nbl[0]_31 nbl[1]_31 nbl[2]_31 nbl[3]_31 ncored00_800 ncored01_802
+  ncored10_804 ncored11_806 ncored20_808 ncored21_810 ncored30_812
+  ncored31_814 vddc_31 vddce_31 vddpe_31 vnwc_32 vpw_32 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_432 cored01_434
+  cored10_436 cored11_438 cored20_440 cored21_442 cored30_444 cored31_446
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_448 ncored01_450 ncored10_452
+  ncored11_454 ncored20_456 ncored21_458 ncored30_460 ncored31_462 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_464 cored01_466
+  cored10_468 cored11_470 cored20_472 cored21_474 cored30_476 cored31_478
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_480 ncored01_482 ncored10_484
+  ncored11_486 ncored20_488 ncored21_490 ncored30_492 ncored31_494 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_496 cored01_498
+  cored10_500 cored11_502 cored20_504 cored21_506 cored30_508 cored31_510
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_512 ncored01_514 ncored10_516
+  ncored11_518 ncored20_520 ncored21_522 ncored30_524 ncored31_526 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_528 cored01_530
+  cored10_532 cored11_534 cored20_536 cored21_538 cored30_540 cored31_542
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_544 ncored01_546 ncored10_548
+  ncored11_550 ncored20_552 ncored21_554 ncored30_556 ncored31_558 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_560 cored01_562
+  cored10_564 cored11_566 cored20_568 cored21_570 cored30_572 cored31_574
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_576 ncored01_578 ncored10_580
+  ncored11_582 ncored20_584 ncored21_586 ncored30_588 ncored31_590 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_592 cored01_594
+  cored10_596 cored11_598 cored20_600 cored21_602 cored30_604 cored31_606
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_608 ncored01_610 ncored10_612
+  ncored11_614 ncored20_616 ncored21_618 ncored30_620 ncored31_622 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_edger dbl dwl vddc_32 vnwc_33 vnwp_1 vpw_33 vssc wl[0] wl[1]
+  rf64x128cchs4wd_edgbl_dummy
.ends rf64x128mem_l_test2row
****
.subckt rf64x128mem_l_top_row vddc_32 vpw_33 vnwc_33 dbl dwl vddc_31 vnwc_32
+  bl[2]_31 nbl[2]_31 nbl[3]_31 bl[3]_31 bl[1]_30 vddpe_30 bl[2]_30 nbl[2]_30
+  nbl[3]_30 bl[1]_29 vddpe_29 bl[2]_29 nbl[2]_29 bl[1]_28 vddpe_28 bl[2]_28
+  nbl[2]_28 bl[1]_27 vddpe_27 bl[2]_27 nbl[2]_27 bl[0]_26 bl[1]_26 vddpe_26
+  nbl[2]_26 nbl[3]_26 bl[0]_25 bl[1]_25 vddpe_25 vddce_25 vnwc_26 vssc
+  nbl[2]_25 nbl[3]_25 bl[0]_24 nbl[0]_24 nbl[1]_24 bl[1]_24 vddpe_24 vddce_24
+  vnwc_25 vpw_25 bl[2]_24 nbl[2]_24 nbl[3]_24 bl[0]_23 nbl[0]_23 nbl[1]_23
+  bl[1]_23 vddpe_23 vddce_23 vnwc_24 vpw_24 bl[2]_23 nbl[2]_23 bl[0]_22
+  nbl[0]_22 nbl[1]_22 bl[1]_22 vddpe_22 vddce_22 vnwc_23 vpw_23 bl[2]_22
+  nbl[2]_22 bl[0]_21 nbl[0]_21 nbl[1]_21 bl[1]_21 vddpe_21 vddce_21 vddc_21
+  vnwc_22 vpw_22 bl[2]_21 nbl[2]_21 bl[0]_20 nbl[0]_20 nbl[1]_20 bl[1]_20
+  vddpe_20 vddce_20 vddc_20 vnwc_21 vpw_21 nbl[2]_20 bl[0]_19 nbl[0]_19
+  nbl[1]_19 bl[1]_19 vddpe_19 vddce_19 vddc_19 vnwc_20 vpw_20 bl[0]_18
+  nbl[0]_18 nbl[1]_18 bl[1]_18 vddpe_18 vddce_18 vnwc_19 vpw_19 bl[2]_18
+  nbl[2]_18 bl[0]_17 nbl[0]_17 nbl[1]_17 bl[1]_17 vddpe_17 vddce_17 vnwc_18
+  vpw_18 bl[2]_17 nbl[2]_17 bl[0]_16 nbl[0]_16 nbl[1]_16 bl[1]_16 vddpe_16
+  vddce_16 vddc_16 vnwc_17 vpw_17 bl[2]_16 nbl[2]_16 bl[0]_15 nbl[0]_15
+  nbl[1]_15 bl[1]_15 vddpe_15 vddce_15 vddc_15 vnwc_16 vpw_16 nbl[2]_15
+  bl[0]_14 nbl[0]_14 nbl[1]_14 bl[1]_14 vddpe_14 vddce_14 vddc_14 vnwc_15
+  vpw_15 nbl[2]_14 bl[0]_13 nbl[0]_13 nbl[1]_13 bl[1]_13 vddpe_13 vddce_13
+  vddc_13 vnwc_14 vpw_14 bl[0]_12 nbl[0]_12 nbl[1]_12 bl[1]_12 vddpe_12
+  vddce_12 vddc_12 vnwc_13 vpw_13 bl[0]_11 nbl[0]_11 nbl[1]_11 bl[1]_11
+  vddpe_11 vddce_11 vddc_11 vnwc_12 vpw_12 bl[2]_11 nbl[2]_11 bl[0]_10
+  nbl[0]_10 nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vddc_10 vnwc_11 vpw_11
+  nbl[2]_10 bl[0]_9 nbl[0]_9 nbl[1]_9 bl[1]_9 vddpe_9 vddce_9 vddc_9 vnwc_10
+  vpw_10 nbl[2]_9 bl[0]_8 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 vddce_8 vddc_8
+  vnwc_9 vpw_9 bl[0]_7 nbl[0]_7 nbl[1]_7 bl[1]_7 vddpe_7 vddce_7 vddc_7
+  vnwc_8 vpw_8 bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddpe_6 vddce_6 vddc_6
+  vnwc_7 vpw_7 bl[3]_6 bl[0]_5 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe_5 vddce_5
+  vddc_5 vnwc_6 vpw_6 nbl[2]_5 bl[0]_4 nbl[0]_4 nbl[1]_4 bl[1]_4 vddpe_4
+  vddce_4 vddc_4 vnwc_5 vpw_5 nbl[2]_4 bl[0]_3 nbl[0]_3 nbl[1]_3 bl[1]_3
+  vddpe_3 vddce_3 vddc_3 vnwc_4 vpw_4 bl[0]_2 nbl[0]_2 nbl[1]_2 bl[1]_2
+  vddpe_2 vddce_2 vddc_2 vnwc_3 vpw_3 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1
+  vddpe_1 vddce_1 vddc_1 vnwc_2 vpw_2 bl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0
+  bl[1]_0 vddpe_0 vddce_0 vddc_0 vnwc_1 vsse_0 vpw_1 bl[3]_0 vnwp_0 vnwc_0
+  vpw_0 vnwp_1 bl[0]_31 nbl[0]_31 nbl[1]_31 bl[1]_31 vddpe_31 vddce_31 vsse_1
+  vpw_32 bl[0]_30 nbl[0]_30 nbl[1]_30 vddce_30 vddc_30 vnwc_31 vpw_31
+  bl[3]_30 bl[0]_29 nbl[0]_29 nbl[1]_29 vddce_29 vddc_29 vnwc_30 vpw_30
+  nbl[3]_29 bl[3]_29 bl[0]_28 nbl[0]_28 nbl[1]_28 vddce_28 vddc_28 vnwc_29
+  vpw_29 nbl[3]_28 bl[3]_28 bl[0]_27 nbl[0]_27 nbl[1]_27 vddce_27 vddc_27
+  vnwc_28 vpw_28 nbl[3]_27 bl[3]_27 nbl[0]_26 nbl[1]_26 vddce_26 vddc_26
+  vnwc_27 vpw_27 bl[2]_26 bl[3]_26 nbl[0]_25 nbl[1]_25 vddc_25 vpw_26
+  bl[2]_25 bl[3]_25 vddc_24 bl[3]_24 vddc_23 nbl[3]_23 bl[3]_23 vddc_22
+  nbl[3]_22 bl[3]_22 nbl[3]_21 bl[3]_21 bl[2]_20 nbl[3]_20 bl[3]_20 bl[2]_19
+  nbl[2]_19 nbl[3]_19 bl[3]_19 vddc_18 nbl[3]_18 bl[3]_18 vddc_17 nbl[3]_17
+  bl[3]_17 nbl[3]_16 bl[3]_16 bl[2]_15 nbl[3]_15 bl[3]_15 bl[2]_14 nbl[3]_14
+  bl[3]_14 bl[2]_13 nbl[2]_13 nbl[3]_13 bl[3]_13 bl[2]_12 nbl[2]_12 nbl[3]_12
+  bl[3]_12 nbl[3]_11 bl[3]_11 bl[2]_10 nbl[3]_10 bl[3]_10 bl[2]_9 nbl[3]_9
+  bl[3]_9 bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7
+  bl[2]_6 nbl[2]_6 nbl[3]_6 bl[2]_5 nbl[3]_5 bl[3]_5 bl[2]_4 nbl[3]_4 bl[3]_4
+  bl[2]_3 nbl[2]_3 nbl[3]_3 bl[3]_3 bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[2]_1
+  nbl[2]_1 nbl[3]_1 bl[2]_0 nbl[2]_0 nbl[3]_0 wl[1] wl[0]
** rf64x128mem_l_top_row: 1548 flat devices **
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_368 cored01_370
+  cored10_372 cored11_374 cored20_376 cored21_378 cored30_380 cored31_382
+  nbl[0]_1 nbl[1]_1 nbl[2]_1 nbl[3]_1 ncored00_384 ncored01_386 ncored10_388
+  ncored11_390 ncored20_392 ncored21_394 ncored30_396 ncored31_398 vddc_1
+  vddce_1 vddpe_1 vnwc_2 vpw_2 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_656 cored01_658
+  cored10_660 cored11_662 cored20_664 cored21_666 cored30_668 cored31_670
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_672 ncored01_674
+  ncored10_676 ncored11_678 ncored20_680 ncored21_682 ncored30_684
+  ncored31_686 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_688 cored01_690
+  cored10_692 cored11_694 cored20_696 cored21_698 cored30_700 cored31_702
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_704 ncored01_706
+  ncored10_708 ncored11_710 ncored20_712 ncored21_714 ncored30_716
+  ncored31_718 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_12 bl[0]_12 bl[1]_12 bl[2]_12 bl[3]_12 cored00_720 cored01_722
+  cored10_724 cored11_726 cored20_728 cored21_730 cored30_732 cored31_734
+  nbl[0]_12 nbl[1]_12 nbl[2]_12 nbl[3]_12 ncored00_736 ncored01_738
+  ncored10_740 ncored11_742 ncored20_744 ncored21_746 ncored30_748
+  ncored31_750 vddc_12 vddce_12 vddpe_12 vnwc_13 vpw_13 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_13 bl[0]_13 bl[1]_13 bl[2]_13 bl[3]_13 cored00_784 cored01_786
+  cored10_788 cored11_790 cored20_792 cored21_794 cored30_796 cored31_798
+  nbl[0]_13 nbl[1]_13 nbl[2]_13 nbl[3]_13 ncored00_800 ncored01_802
+  ncored10_804 ncored11_806 ncored20_808 ncored21_810 ncored30_812
+  ncored31_814 vddc_13 vddce_13 vddpe_13 vnwc_14 vpw_14 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_14 bl[0]_14 bl[1]_14 bl[2]_14 bl[3]_14 cored00_816 cored01_818
+  cored10_820 cored11_822 cored20_824 cored21_826 cored30_828 cored31_830
+  nbl[0]_14 nbl[1]_14 nbl[2]_14 nbl[3]_14 ncored00_832 ncored01_834
+  ncored10_836 ncored11_838 ncored20_840 ncored21_842 ncored30_844
+  ncored31_846 vddc_14 vddce_14 vddpe_14 vnwc_15 vpw_15 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_15 bl[0]_15 bl[1]_15 bl[2]_15 bl[3]_15 cored00_848 cored01_850
+  cored10_852 cored11_854 cored20_856 cored21_858 cored30_860 cored31_862
+  nbl[0]_15 nbl[1]_15 nbl[2]_15 nbl[3]_15 ncored00_864 ncored01_866
+  ncored10_868 ncored11_870 ncored20_872 ncored21_874 ncored30_876
+  ncored31_878 vddc_15 vddce_15 vddpe_15 vnwc_16 vpw_16 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_16 bl[0]_16 bl[1]_16 bl[2]_16 bl[3]_16 cored00_880 cored01_882
+  cored10_884 cored11_886 cored20_888 cored21_890 cored30_892 cored31_894
+  nbl[0]_16 nbl[1]_16 nbl[2]_16 nbl[3]_16 ncored00_896 ncored01_898
+  ncored10_900 ncored11_902 ncored20_904 ncored21_906 ncored30_908
+  ncored31_910 vddc_16 vddce_16 vddpe_16 vnwc_17 vpw_17 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_17 bl[0]_17 bl[1]_17 bl[2]_17 bl[3]_17 cored00_912 cored01_914
+  cored10_916 cored11_918 cored20_920 cored21_922 cored30_924 cored31_926
+  nbl[0]_17 nbl[1]_17 nbl[2]_17 nbl[3]_17 ncored00_928 ncored01_930
+  ncored10_932 ncored11_934 ncored20_936 ncored21_938 ncored30_940
+  ncored31_942 vddc_17 vddce_17 vddpe_17 vnwc_18 vpw_18 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_18 bl[0]_18 bl[1]_18 bl[2]_18 bl[3]_18 cored00_944 cored01_946
+  cored10_948 cored11_950 cored20_952 cored21_954 cored30_956 cored31_958
+  nbl[0]_18 nbl[1]_18 nbl[2]_18 nbl[3]_18 ncored00_960 ncored01_962
+  ncored10_964 ncored11_966 ncored20_968 ncored21_970 ncored30_972
+  ncored31_974 vddc_18 vddce_18 vddpe_18 vnwc_19 vpw_19 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_19 bl[0]_19 bl[1]_19 bl[2]_19 bl[3]_19 cored00_976 cored01_978
+  cored10_980 cored11_982 cored20_984 cored21_986 cored30_988 cored31_990
+  nbl[0]_19 nbl[1]_19 nbl[2]_19 nbl[3]_19 ncored00_992 ncored01_994
+  ncored10_996 ncored11_998 ncored20_1000 ncored21_1002 ncored30_1004
+  ncored31_1006 vddc_19 vddce_19 vddpe_19 vnwc_20 vpw_20 vssc vssc wl[0]
+  wl[1] rf64x128cchs4
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_400 cored01_402
+  cored10_404 cored11_406 cored20_408 cored21_410 cored30_412 cored31_414
+  nbl[0]_2 nbl[1]_2 nbl[2]_2 nbl[3]_2 ncored00_416 ncored01_418 ncored10_420
+  ncored11_422 ncored20_424 ncored21_426 ncored30_428 ncored31_430 vddc_2
+  vddce_2 vddpe_2 vnwc_3 vpw_3 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_20 bl[0]_20 bl[1]_20 bl[2]_20 bl[3]_20 cored00_16 cored01_18
+  cored10_20 cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_20
+  nbl[1]_20 nbl[2]_20 nbl[3]_20 ncored00_32 ncored01_34 ncored10_36
+  ncored11_38 ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_20
+  vddce_20 vddpe_20 vnwc_21 vpw_21 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_21 bl[0]_21 bl[1]_21 bl[2]_21 bl[3]_21 cored00_48 cored01_50
+  cored10_52 cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_21
+  nbl[1]_21 nbl[2]_21 nbl[3]_21 ncored00_64 ncored01_66 ncored10_68
+  ncored11_70 ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_21
+  vddce_21 vddpe_21 vnwc_22 vpw_22 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_22 bl[0]_22 bl[1]_22 bl[2]_22 bl[3]_22 cored00_80 cored01_82
+  cored10_84 cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_22
+  nbl[1]_22 nbl[2]_22 nbl[3]_22 ncored00_96 ncored01_98 ncored10_100
+  ncored11_102 ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_22
+  vddce_22 vddpe_22 vnwc_23 vpw_23 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_23 bl[0]_23 bl[1]_23 bl[2]_23 bl[3]_23 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_23 nbl[1]_23 nbl[2]_23 nbl[3]_23 ncored00_160 ncored01_162
+  ncored10_164 ncored11_166 ncored20_168 ncored21_170 ncored30_172
+  ncored31_174 vddc_23 vddce_23 vddpe_23 vnwc_24 vpw_24 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_24 bl[0]_24 bl[1]_24 bl[2]_24 bl[3]_24 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_24 nbl[1]_24 nbl[2]_24 nbl[3]_24 ncored00_192 ncored01_194
+  ncored10_196 ncored11_198 ncored20_200 ncored21_202 ncored30_204
+  ncored31_206 vddc_24 vddce_24 vddpe_24 vnwc_25 vpw_25 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_25 bl[0]_25 bl[1]_25 bl[2]_25 bl[3]_25 cored00_208 cored01_210
+  cored10_212 cored11_214 cored20_216 cored21_218 cored30_220 cored31_222
+  nbl[0]_25 nbl[1]_25 nbl[2]_25 nbl[3]_25 ncored00_224 ncored01_226
+  ncored10_228 ncored11_230 ncored20_232 ncored21_234 ncored30_236
+  ncored31_238 vddc_25 vddce_25 vddpe_25 vnwc_26 vpw_26 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_26 bl[0]_26 bl[1]_26 bl[2]_26 bl[3]_26 cored00_240 cored01_242
+  cored10_244 cored11_246 cored20_248 cored21_250 cored30_252 cored31_254
+  nbl[0]_26 nbl[1]_26 nbl[2]_26 nbl[3]_26 ncored00_256 ncored01_258
+  ncored10_260 ncored11_262 ncored20_264 ncored21_266 ncored30_268
+  ncored31_270 vddc_26 vddce_26 vddpe_26 vnwc_27 vpw_27 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_27 bl[0]_27 bl[1]_27 bl[2]_27 bl[3]_27 cored00_272 cored01_274
+  cored10_276 cored11_278 cored20_280 cored21_282 cored30_284 cored31_286
+  nbl[0]_27 nbl[1]_27 nbl[2]_27 nbl[3]_27 ncored00_288 ncored01_290
+  ncored10_292 ncored11_294 ncored20_296 ncored21_298 ncored30_300
+  ncored31_302 vddc_27 vddce_27 vddpe_27 vnwc_28 vpw_28 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_28 bl[0]_28 bl[1]_28 bl[2]_28 bl[3]_28 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_28 nbl[1]_28 nbl[2]_28 nbl[3]_28 ncored00_320 ncored01_322
+  ncored10_324 ncored11_326 ncored20_328 ncored21_330 ncored30_332
+  ncored31_334 vddc_28 vddce_28 vddpe_28 vnwc_29 vpw_29 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_29 bl[0]_29 bl[1]_29 bl[2]_29 bl[3]_29 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_29 nbl[1]_29 nbl[2]_29 nbl[3]_29 ncored00_352 ncored01_354
+  ncored10_356 ncored11_358 ncored20_360 ncored21_362 ncored30_364
+  ncored31_366 vddc_29 vddce_29 vddpe_29 vnwc_30 vpw_30 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_3 bl[0]_3 bl[1]_3 bl[2]_3 bl[3]_3 cored00_432 cored01_434
+  cored10_436 cored11_438 cored20_440 cored21_442 cored30_444 cored31_446
+  nbl[0]_3 nbl[1]_3 nbl[2]_3 nbl[3]_3 ncored00_448 ncored01_450 ncored10_452
+  ncored11_454 ncored20_456 ncored21_458 ncored30_460 ncored31_462 vddc_3
+  vddce_3 vddpe_3 vnwc_4 vpw_4 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_30 bl[0]_30 bl[1]_30 bl[2]_30 bl[3]_30 cored00_752 cored01_754
+  cored10_756 cored11_758 cored20_760 cored21_762 cored30_764 cored31_766
+  nbl[0]_30 nbl[1]_30 nbl[2]_30 nbl[3]_30 ncored00_768 ncored01_770
+  ncored10_772 ncored11_774 ncored20_776 ncored21_778 ncored30_780
+  ncored31_782 vddc_30 vddce_30 vddpe_30 vnwc_31 vpw_31 vssc vssc wl[0] wl[1]
+  rf64x128cchs4
xmem_l_col_4 bl[0]_4 bl[1]_4 bl[2]_4 bl[3]_4 cored00_464 cored01_466
+  cored10_468 cored11_470 cored20_472 cored21_474 cored30_476 cored31_478
+  nbl[0]_4 nbl[1]_4 nbl[2]_4 nbl[3]_4 ncored00_480 ncored01_482 ncored10_484
+  ncored11_486 ncored20_488 ncored21_490 ncored30_492 ncored31_494 vddc_4
+  vddce_4 vddpe_4 vnwc_5 vpw_5 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_5 bl[0]_5 bl[1]_5 bl[2]_5 bl[3]_5 cored00_496 cored01_498
+  cored10_500 cored11_502 cored20_504 cored21_506 cored30_508 cored31_510
+  nbl[0]_5 nbl[1]_5 nbl[2]_5 nbl[3]_5 ncored00_512 ncored01_514 ncored10_516
+  ncored11_518 ncored20_520 ncored21_522 ncored30_524 ncored31_526 vddc_5
+  vddce_5 vddpe_5 vnwc_6 vpw_6 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_6 bl[0]_6 bl[1]_6 bl[2]_6 bl[3]_6 cored00_528 cored01_530
+  cored10_532 cored11_534 cored20_536 cored21_538 cored30_540 cored31_542
+  nbl[0]_6 nbl[1]_6 nbl[2]_6 nbl[3]_6 ncored00_544 ncored01_546 ncored10_548
+  ncored11_550 ncored20_552 ncored21_554 ncored30_556 ncored31_558 vddc_6
+  vddce_6 vddpe_6 vnwc_7 vpw_7 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_7 bl[0]_7 bl[1]_7 bl[2]_7 bl[3]_7 cored00_560 cored01_562
+  cored10_564 cored11_566 cored20_568 cored21_570 cored30_572 cored31_574
+  nbl[0]_7 nbl[1]_7 nbl[2]_7 nbl[3]_7 ncored00_576 ncored01_578 ncored10_580
+  ncored11_582 ncored20_584 ncored21_586 ncored30_588 ncored31_590 vddc_7
+  vddce_7 vddpe_7 vnwc_8 vpw_8 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_8 bl[0]_8 bl[1]_8 bl[2]_8 bl[3]_8 cored00_592 cored01_594
+  cored10_596 cored11_598 cored20_600 cored21_602 cored30_604 cored31_606
+  nbl[0]_8 nbl[1]_8 nbl[2]_8 nbl[3]_8 ncored00_608 ncored01_610 ncored10_612
+  ncored11_614 ncored20_616 ncored21_618 ncored30_620 ncored31_622 vddc_8
+  vddce_8 vddpe_8 vnwc_9 vpw_9 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_9 bl[0]_9 bl[1]_9 bl[2]_9 bl[3]_9 cored00_624 cored01_626
+  cored10_628 cored11_630 cored20_632 cored21_634 cored30_636 cored31_638
+  nbl[0]_9 nbl[1]_9 nbl[2]_9 nbl[3]_9 ncored00_640 ncored01_642 ncored10_644
+  ncored11_646 ncored20_648 ncored21_650 ncored30_652 ncored31_654 vddc_9
+  vddce_9 vddpe_9 vnwc_10 vpw_10 vssc vssc wl[0] wl[1] rf64x128cchs4
xmem_l_col_edger dbl dwl vddc_32 vnwc_33 vnwp_1 vpw_33 vssc wl[0] wl[1]
+  rf64x128cchs4wd_edgbl
xmem_l_col_top_l bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00 cored01 cored10
+  cored11 cored20 cored21 cored30 cored31 nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0
+  ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30 ncored31
+  vddc_0 vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vsse_0 wl[0] wl[1] rf64x128cchs4
xmem_l_col_top_r bl[0]_31 bl[1]_31 bl[2]_31 bl[3]_31 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_31 nbl[1]_31 nbl[2]_31 nbl[3]_31 ncored00_128 ncored01_130
+  ncored10_132 ncored11_134 ncored20_136 ncored21_138 ncored30_140
+  ncored31_142 vddc_31 vddce_31 vddpe_31 vnwc_32 vpw_32 vssc vsse_1 wl[0]
+  wl[1] rf64x128cchs4
.ends rf64x128mem_l_top_row
****
.subckt rf64x128mem_l_test3row vddc_32 vpw_33 vddc_31 vnwc_32 bl[2]_31
+  nbl[2]_31 nbl[3]_31 bl[3]_31 bl[1]_30 vddpe_30 bl[2]_30 nbl[2]_30 nbl[3]_30
+  bl[1]_29 vddpe_29 bl[2]_29 nbl[2]_29 bl[1]_28 vddpe_28 bl[2]_28 nbl[2]_28
+  bl[1]_27 vddpe_27 bl[2]_27 nbl[2]_27 bl[0]_26 bl[1]_26 vddpe_26 nbl[2]_26
+  nbl[3]_26 bl[0]_25 bl[1]_25 vddpe_25 vddce_25 vnwc_26 vssc nbl[2]_25
+  nbl[3]_25 bl[0]_24 nbl[0]_24 nbl[1]_24 bl[1]_24 vddpe_24 vddce_24 vnwc_25
+  vpw_25 bl[2]_24 nbl[2]_24 nbl[3]_24 bl[0]_23 nbl[0]_23 nbl[1]_23 bl[1]_23
+  vddpe_23 vddce_23 vnwc_24 vpw_24 bl[2]_23 nbl[2]_23 bl[0]_22 nbl[0]_22
+  nbl[1]_22 bl[1]_22 vddpe_22 vddce_22 vnwc_23 vpw_23 bl[2]_22 nbl[2]_22
+  bl[0]_21 nbl[0]_21 nbl[1]_21 bl[1]_21 vddpe_21 vddce_21 vddc_21 vnwc_22
+  vpw_22 bl[2]_21 nbl[2]_21 bl[0]_20 nbl[0]_20 nbl[1]_20 bl[1]_20 vddpe_20
+  vddce_20 vddc_20 vnwc_21 vpw_21 nbl[2]_20 bl[0]_19 nbl[0]_19 nbl[1]_19
+  bl[1]_19 vddpe_19 vddce_19 vddc_19 vnwc_20 vpw_20 bl[0]_18 nbl[0]_18
+  nbl[1]_18 bl[1]_18 vddpe_18 vddce_18 vnwc_19 vpw_19 bl[2]_18 nbl[2]_18
+  bl[0]_17 nbl[0]_17 nbl[1]_17 bl[1]_17 vddpe_17 vddce_17 vnwc_18 vpw_18
+  bl[2]_17 nbl[2]_17 bl[0]_16 nbl[0]_16 nbl[1]_16 bl[1]_16 vddpe_16 vddce_16
+  vddc_16 vnwc_17 vpw_17 bl[2]_16 nbl[2]_16 bl[0]_15 nbl[0]_15 nbl[1]_15
+  bl[1]_15 vddpe_15 vddce_15 vddc_15 vnwc_16 vpw_16 nbl[2]_15 bl[0]_14
+  nbl[0]_14 nbl[1]_14 bl[1]_14 vddpe_14 vddce_14 vddc_14 vnwc_15 vpw_15
+  nbl[2]_14 bl[0]_13 nbl[0]_13 nbl[1]_13 bl[1]_13 vddpe_13 vddce_13 vddc_13
+  vnwc_14 vpw_14 bl[0]_12 nbl[0]_12 nbl[1]_12 bl[1]_12 vddpe_12 vddce_12
+  vddc_12 vnwc_13 vpw_13 bl[0]_11 nbl[0]_11 nbl[1]_11 bl[1]_11 vddpe_11
+  vddce_11 vddc_11 vnwc_12 vpw_12 bl[2]_11 nbl[2]_11 bl[0]_10 nbl[0]_10
+  nbl[1]_10 bl[1]_10 vddpe_10 vddce_10 vddc_10 vnwc_11 vpw_11 nbl[2]_10
+  bl[0]_9 nbl[0]_9 nbl[1]_9 bl[1]_9 vddpe_9 vddce_9 vddc_9 vnwc_10 vpw_10
+  nbl[2]_9 bl[0]_8 nbl[0]_8 nbl[1]_8 bl[1]_8 vddpe_8 vddce_8 vddc_8 vnwc_9
+  vpw_9 bl[0]_7 nbl[0]_7 nbl[1]_7 bl[1]_7 vddpe_7 vddce_7 vddc_7 vnwc_8 vpw_8
+  bl[0]_6 nbl[0]_6 nbl[1]_6 bl[1]_6 vddpe_6 vddce_6 vddc_6 vnwc_7 vpw_7
+  bl[3]_6 bl[0]_5 nbl[0]_5 nbl[1]_5 bl[1]_5 vddpe_5 vddce_5 vddc_5 vnwc_6
+  vpw_6 nbl[2]_5 bl[0]_4 nbl[0]_4 nbl[1]_4 bl[1]_4 vddpe_4 vddce_4 vddc_4
+  vnwc_5 vpw_5 nbl[2]_4 bl[0]_3 nbl[0]_3 nbl[1]_3 bl[1]_3 vddpe_3 vddce_3
+  vddc_3 vnwc_4 vpw_4 bl[0]_2 nbl[0]_2 nbl[1]_2 bl[1]_2 vddpe_2 vddce_2
+  vddc_2 vnwc_3 vpw_3 bl[0]_1 nbl[0]_1 nbl[1]_1 bl[1]_1 vddpe_1 vddce_1
+  vddc_1 vnwc_2 vpw_2 bl[3]_1 bl[0]_0 nbl[0]_0 nbl[1]_0 bl[1]_0 vddpe_0
+  vddce_0 vddc_0 vnwc_1 vpw_1 bl[3]_0 vnwc_0 vpw_0 vnwc_33 vnwp_1 dbl dwl
+  bl[0]_31 nbl[0]_31 nbl[1]_31 bl[1]_31 vddpe_31 vddce_31 vpw_32 bl[0]_30
+  nbl[0]_30 nbl[1]_30 vddce_30 vddc_30 vnwc_31 vpw_31 bl[3]_30 bl[0]_29
+  nbl[0]_29 nbl[1]_29 vddce_29 vddc_29 vnwc_30 vpw_30 nbl[3]_29 bl[3]_29
+  bl[0]_28 nbl[0]_28 nbl[1]_28 vddce_28 vddc_28 vnwc_29 vpw_29 nbl[3]_28
+  bl[3]_28 bl[0]_27 nbl[0]_27 nbl[1]_27 vddce_27 vddc_27 vnwc_28 vpw_28
+  nbl[3]_27 bl[3]_27 nbl[0]_26 nbl[1]_26 vddce_26 vddc_26 vnwc_27 vpw_27
+  bl[2]_26 bl[3]_26 nbl[0]_25 nbl[1]_25 vddc_25 vpw_26 bl[2]_25 bl[3]_25
+  vddc_24 bl[3]_24 vddc_23 nbl[3]_23 bl[3]_23 vddc_22 nbl[3]_22 bl[3]_22
+  nbl[3]_21 bl[3]_21 bl[2]_20 nbl[3]_20 bl[3]_20 bl[2]_19 nbl[2]_19 nbl[3]_19
+  bl[3]_19 vddc_18 nbl[3]_18 bl[3]_18 vddc_17 nbl[3]_17 bl[3]_17 nbl[3]_16
+  bl[3]_16 bl[2]_15 nbl[3]_15 bl[3]_15 bl[2]_14 nbl[3]_14 bl[3]_14 bl[2]_13
+  nbl[2]_13 nbl[3]_13 bl[3]_13 bl[2]_12 nbl[2]_12 nbl[3]_12 bl[3]_12
+  nbl[3]_11 bl[3]_11 bl[2]_10 nbl[3]_10 bl[3]_10 bl[2]_9 nbl[3]_9 bl[3]_9
+  bl[2]_8 nbl[2]_8 nbl[3]_8 bl[3]_8 bl[2]_7 nbl[2]_7 nbl[3]_7 bl[3]_7 bl[2]_6
+  nbl[2]_6 nbl[3]_6 bl[2]_5 nbl[3]_5 bl[3]_5 bl[2]_4 nbl[3]_4 bl[3]_4 bl[2]_3
+  nbl[2]_3 nbl[3]_3 bl[3]_3 bl[2]_2 nbl[2]_2 nbl[3]_2 bl[3]_2 bl[2]_1
+  nbl[2]_1 nbl[3]_1 bl[2]_0 nbl[2]_0 nbl[3]_0 vnwp_0 wl[0] wl[1]
** rf64x128mem_l_test3row: 1548 flat devices **
xmem_l_col_0 bl[0]_0 bl[1]_0 bl[2]_0 bl[3]_0 cored00_304 cored01_306
+  cored10_308 cored11_310 cored20_312 cored21_314 cored30_316 cored31_318
+  nbl[0]_0 nbl[1]_0 nbl[2]_0 nbl[3]_0 ncored00_320 ncored01_322 ncored10_324
+  ncored11_326 ncored20_328 ncored21_330 ncored30_332 ncored31_334 vddc_0
+  vddce_0 vddpe_0 vnwc_1 vpw_1 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_1 bl[0]_1 bl[1]_1 bl[2]_1 bl[3]_1 cored00_336 cored01_338
+  cored10_340 cored11_342 cored20_344 cored21_346 cored30_348 cored31_350
+  nbl[0]_1 nbl[1]_1 nbl[2]_1 nbl[3]_1 ncored00_352 ncored01_354 ncored10_356
+  ncored11_358 ncored20_360 ncored21_362 ncored30_364 ncored31_366 vddc_1
+  vddce_1 vddpe_1 vnwc_2 vpw_2 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_10 bl[0]_10 bl[1]_10 bl[2]_10 bl[3]_10 cored00_624 cored01_626
+  cored10_628 cored11_630 cored20_632 cored21_634 cored30_636 cored31_638
+  nbl[0]_10 nbl[1]_10 nbl[2]_10 nbl[3]_10 ncored00_640 ncored01_642
+  ncored10_644 ncored11_646 ncored20_648 ncored21_650 ncored30_652
+  ncored31_654 vddc_10 vddce_10 vddpe_10 vnwc_11 vpw_11 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_11 bl[0]_11 bl[1]_11 bl[2]_11 bl[3]_11 cored00_656 cored01_658
+  cored10_660 cored11_662 cored20_664 cored21_666 cored30_668 cored31_670
+  nbl[0]_11 nbl[1]_11 nbl[2]_11 nbl[3]_11 ncored00_672 ncored01_674
+  ncored10_676 ncored11_678 ncored20_680 ncored21_682 ncored30_684
+  ncored31_686 vddc_11 vddce_11 vddpe_11 vnwc_12 vpw_12 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_12 bl[0]_12 bl[1]_12 bl[2]_12 bl[3]_12 cored00_688 cored01_690
+  cored10_692 cored11_694 cored20_696 cored21_698 cored30_700 cored31_702
+  nbl[0]_12 nbl[1]_12 nbl[2]_12 nbl[3]_12 ncored00_704 ncored01_706
+  ncored10_708 ncored11_710 ncored20_712 ncored21_714 ncored30_716
+  ncored31_718 vddc_12 vddce_12 vddpe_12 vnwc_13 vpw_13 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_13 bl[0]_13 bl[1]_13 bl[2]_13 bl[3]_13 cored00_752 cored01_754
+  cored10_756 cored11_758 cored20_760 cored21_762 cored30_764 cored31_766
+  nbl[0]_13 nbl[1]_13 nbl[2]_13 nbl[3]_13 ncored00_768 ncored01_770
+  ncored10_772 ncored11_774 ncored20_776 ncored21_778 ncored30_780
+  ncored31_782 vddc_13 vddce_13 vddpe_13 vnwc_14 vpw_14 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_14 bl[0]_14 bl[1]_14 bl[2]_14 bl[3]_14 cored00_816 cored01_818
+  cored10_820 cored11_822 cored20_824 cored21_826 cored30_828 cored31_830
+  nbl[0]_14 nbl[1]_14 nbl[2]_14 nbl[3]_14 ncored00_832 ncored01_834
+  ncored10_836 ncored11_838 ncored20_840 ncored21_842 ncored30_844
+  ncored31_846 vddc_14 vddce_14 vddpe_14 vnwc_15 vpw_15 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_15 bl[0]_15 bl[1]_15 bl[2]_15 bl[3]_15 cored00_848 cored01_850
+  cored10_852 cored11_854 cored20_856 cored21_858 cored30_860 cored31_862
+  nbl[0]_15 nbl[1]_15 nbl[2]_15 nbl[3]_15 ncored00_864 ncored01_866
+  ncored10_868 ncored11_870 ncored20_872 ncored21_874 ncored30_876
+  ncored31_878 vddc_15 vddce_15 vddpe_15 vnwc_16 vpw_16 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_16 bl[0]_16 bl[1]_16 bl[2]_16 bl[3]_16 cored00_880 cored01_882
+  cored10_884 cored11_886 cored20_888 cored21_890 cored30_892 cored31_894
+  nbl[0]_16 nbl[1]_16 nbl[2]_16 nbl[3]_16 ncored00_896 ncored01_898
+  ncored10_900 ncored11_902 ncored20_904 ncored21_906 ncored30_908
+  ncored31_910 vddc_16 vddce_16 vddpe_16 vnwc_17 vpw_17 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_17 bl[0]_17 bl[1]_17 bl[2]_17 bl[3]_17 cored00_912 cored01_914
+  cored10_916 cored11_918 cored20_920 cored21_922 cored30_924 cored31_926
+  nbl[0]_17 nbl[1]_17 nbl[2]_17 nbl[3]_17 ncored00_928 ncored01_930
+  ncored10_932 ncored11_934 ncored20_936 ncored21_938 ncored30_940
+  ncored31_942 vddc_17 vddce_17 vddpe_17 vnwc_18 vpw_18 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_18 bl[0]_18 bl[1]_18 bl[2]_18 bl[3]_18 cored00_944 cored01_946
+  cored10_948 cored11_950 cored20_952 cored21_954 cored30_956 cored31_958
+  nbl[0]_18 nbl[1]_18 nbl[2]_18 nbl[3]_18 ncored00_960 ncored01_962
+  ncored10_964 ncored11_966 ncored20_968 ncored21_970 ncored30_972
+  ncored31_974 vddc_18 vddce_18 vddpe_18 vnwc_19 vpw_19 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_19 bl[0]_19 bl[1]_19 bl[2]_19 bl[3]_19 cored00_976 cored01_978
+  cored10_980 cored11_982 cored20_984 cored21_986 cored30_988 cored31_990
+  nbl[0]_19 nbl[1]_19 nbl[2]_19 nbl[3]_19 ncored00_992 ncored01_994
+  ncored10_996 ncored11_998 ncored20_1000 ncored21_1002 ncored30_1004
+  ncored31_1006 vddc_19 vddce_19 vddpe_19 vnwc_20 vpw_20 vssc vssc wl[1]
+  wl[0] rf64x128cchs4
xmem_l_col_2 bl[0]_2 bl[1]_2 bl[2]_2 bl[3]_2 cored00_368 cored01_370
+  cored10_372 cored11_374 cored20_376 cored21_378 cored30_380 cored31_382
+  nbl[0]_2 nbl[1]_2 nbl[2]_2 nbl[3]_2 ncored00_384 ncored01_386 ncored10_388
+  ncored11_390 ncored20_392 ncored21_394 ncored30_396 ncored31_398 vddc_2
+  vddce_2 vddpe_2 vnwc_3 vpw_3 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_20 bl[0]_20 bl[1]_20 bl[2]_20 bl[3]_20 cored00 cored01 cored10
+  cored11 cored20 cored21 cored30 cored31 nbl[0]_20 nbl[1]_20 nbl[2]_20
+  nbl[3]_20 ncored00 ncored01 ncored10 ncored11 ncored20 ncored21 ncored30
+  ncored31 vddc_20 vddce_20 vddpe_20 vnwc_21 vpw_21 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_21 bl[0]_21 bl[1]_21 bl[2]_21 bl[3]_21 cored00_16 cored01_18
+  cored10_20 cored11_22 cored20_24 cored21_26 cored30_28 cored31_30 nbl[0]_21
+  nbl[1]_21 nbl[2]_21 nbl[3]_21 ncored00_32 ncored01_34 ncored10_36
+  ncored11_38 ncored20_40 ncored21_42 ncored30_44 ncored31_46 vddc_21
+  vddce_21 vddpe_21 vnwc_22 vpw_22 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_22 bl[0]_22 bl[1]_22 bl[2]_22 bl[3]_22 cored00_48 cored01_50
+  cored10_52 cored11_54 cored20_56 cored21_58 cored30_60 cored31_62 nbl[0]_22
+  nbl[1]_22 nbl[2]_22 nbl[3]_22 ncored00_64 ncored01_66 ncored10_68
+  ncored11_70 ncored20_72 ncored21_74 ncored30_76 ncored31_78 vddc_22
+  vddce_22 vddpe_22 vnwc_23 vpw_23 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_23 bl[0]_23 bl[1]_23 bl[2]_23 bl[3]_23 cored00_80 cored01_82
+  cored10_84 cored11_86 cored20_88 cored21_90 cored30_92 cored31_94 nbl[0]_23
+  nbl[1]_23 nbl[2]_23 nbl[3]_23 ncored00_96 ncored01_98 ncored10_100
+  ncored11_102 ncored20_104 ncored21_106 ncored30_108 ncored31_110 vddc_23
+  vddce_23 vddpe_23 vnwc_24 vpw_24 vssc vssc wl[1] wl[0] rf64x128cchs4
xmem_l_col_24 bl[0]_24 bl[1]_24 bl[2]_24 bl[3]_24 cored00_112 cored01_114
+  cored10_116 cored11_118 cored20_120 cored21_122 cored30_124 cored31_126
+  nbl[0]_24 nbl[1]_24 nbl[2]_24 nbl[3]_24 ncored00_128 ncored01_130
+  ncored10_132 ncored11_134 ncored20_136 ncored21_138 ncored30_140
+  ncored31_142 vddc_24 vddce_24 vddpe_24 vnwc_25 vpw_25 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_25 bl[0]_25 bl[1]_25 bl[2]_25 bl[3]_25 cored00_144 cored01_146
+  cored10_148 cored11_150 cored20_152 cored21_154 cored30_156 cored31_158
+  nbl[0]_25 nbl[1]_25 nbl[2]_25 nbl[3]_25 ncored00_160 ncored01_162
+  ncored10_164 ncored11_166 ncored20_168 ncored21_170 ncored30_172
+  ncored31_174 vddc_25 vddce_25 vddpe_25 vnwc_26 vpw_26 vssc vssc wl[1] wl[0]
+  rf64x128cchs4
xmem_l_col_26 bl[0]_26 bl[1]_26 bl[2]_26 bl[3]_26 cored00_176 cored01_178
+  cored10_180 cored11_182 cored20_184 cored21_186 cored30_188 cored31_190
+  nbl[0]_26 nbl[1]_26 nbl[2]_26 nbl[3]_26 ncored00_192 ncored01_194
